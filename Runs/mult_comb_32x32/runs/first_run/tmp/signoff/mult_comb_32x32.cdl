.SUBCKT sky130_fd_sc_hd__a2bb2o_1 A1_N A2_N B1 B2 VGND VNB VPB VPWR X
MMIN2 X y VGND VNB nfet_01v8 m=1 w=0.65 l=0.15 mult=1 sa=0.265
+ sb=0.265 sd=0.28 topography=normal area=0.063 perim=1.14
MMNnor0 inor A1_N VGND VNB nfet_01v8 m=1 w=0.42 l=0.15 mult=1 sa=0.265
+ sb=0.265 sd=0.28 topography=normal area=0.063 perim=1.14
MMNnor1 inor A2_N VGND VNB nfet_01v8 m=1 w=0.42 l=0.15 mult=1 sa=0.265
+ sb=0.265 sd=0.28 topography=normal area=0.063 perim=1.14
MMNaoi10 VGND B1 sndNB1 VNB nfet_01v8 m=1 w=0.42 l=0.15 mult=1
+ sa=0.265 sb=0.265 sd=0.28 topography=normal area=0.063 perim=1.14
MMNaoi11 sndNB1 B2 y VNB nfet_01v8 m=1 w=0.42 l=0.15 mult=1 sa=0.265
+ sb=0.265 sd=0.28 topography=normal area=0.063 perim=1.14
MMNaoi20 y inor VGND VNB nfet_01v8 m=1 w=0.42 l=0.15 mult=1 sa=0.265
+ sb=0.265 sd=0.28 topography=normal area=0.063 perim=1.14
MMPaoi20 y inor pmid VPB pfet_01v8_hvt m=1 w=0.42 l=0.15 mult=1
+ sa=0.265 sb=0.265 sd=0.28 topography=normal area=0.063 perim=1.14
MMIP2 X y VPWR VPB pfet_01v8_hvt m=1 w=1.0 l=0.15 mult=1 sa=0.265
+ sb=0.265 sd=0.28 topography=normal area=0.063 perim=1.14
MMPnor0 VPWR A1_N sndPA1N VPB pfet_01v8_hvt m=1 w=0.42 l=0.15 mult=1
+ sa=0.265 sb=0.265 sd=0.28 topography=normal area=0.063 perim=1.14
MMPnor1 sndPA1N A2_N inor VPB pfet_01v8_hvt m=1 w=0.42 l=0.15 mult=1
+ sa=0.265 sb=0.265 sd=0.28 topography=normal area=0.063 perim=1.14
MMPaoi10 pmid B1 VPWR VPB pfet_01v8_hvt m=1 w=0.42 l=0.15 mult=1
+ sa=0.265 sb=0.265 sd=0.28 topography=normal area=0.063 perim=1.14
MMPaoi11 pmid B2 VPWR VPB pfet_01v8_hvt m=1 w=0.42 l=0.15 mult=1
+ sa=0.265 sb=0.265 sd=0.28 topography=normal area=0.063 perim=1.14
.ENDS

.SUBCKT sky130_fd_sc_hd__a2bb2o_2 A1_N A2_N B1 B2 VGND VNB VPB VPWR X
MMIN2 X y VGND VNB nfet_01v8 m=2 w=0.65 l=0.15 mult=1 sa=0.265
+ sb=0.265 sd=0.28 topography=normal area=0.063 perim=1.14
MMNnor0 inor A1_N VGND VNB nfet_01v8 m=1 w=0.42 l=0.15 mult=1 sa=0.265
+ sb=0.265 sd=0.28 topography=normal area=0.063 perim=1.14
MMNnor1 inor A2_N VGND VNB nfet_01v8 m=1 w=0.42 l=0.15 mult=1 sa=0.265
+ sb=0.265 sd=0.28 topography=normal area=0.063 perim=1.14
MMNaoi10 VGND B1 sndNB1 VNB nfet_01v8 m=1 w=0.42 l=0.15 mult=1
+ sa=0.265 sb=0.265 sd=0.28 topography=normal area=0.063 perim=1.14
MMNaoi11 sndNB1 B2 y VNB nfet_01v8 m=1 w=0.42 l=0.15 mult=1 sa=0.265
+ sb=0.265 sd=0.28 topography=normal area=0.063 perim=1.14
MMNaoi20 y inor VGND VNB nfet_01v8 m=1 w=0.42 l=0.15 mult=1 sa=0.265
+ sb=0.265 sd=0.28 topography=normal area=0.063 perim=1.14
MMPaoi20 y inor pmid VPB pfet_01v8_hvt m=1 w=0.64 l=0.15 mult=1
+ sa=0.265 sb=0.265 sd=0.28 topography=normal area=0.063 perim=1.14
MMIP2 X y VPWR VPB pfet_01v8_hvt m=2 w=1.0 l=0.15 mult=1 sa=0.265
+ sb=0.265 sd=0.28 topography=normal area=0.063 perim=1.14
MMPnor0 VPWR A1_N sndPA1N VPB pfet_01v8_hvt m=1 w=0.64 l=0.15 mult=1
+ sa=0.265 sb=0.265 sd=0.28 topography=normal area=0.063 perim=1.14
MMPnor1 sndPA1N A2_N inor VPB pfet_01v8_hvt m=1 w=0.64 l=0.15 mult=1
+ sa=0.265 sb=0.265 sd=0.28 topography=normal area=0.063 perim=1.14
MMPaoi10 pmid B1 VPWR VPB pfet_01v8_hvt m=1 w=0.64 l=0.15 mult=1
+ sa=0.265 sb=0.265 sd=0.28 topography=normal area=0.063 perim=1.14
MMPaoi11 pmid B2 VPWR VPB pfet_01v8_hvt m=1 w=0.64 l=0.15 mult=1
+ sa=0.265 sb=0.265 sd=0.28 topography=normal area=0.063 perim=1.14
.ENDS

.SUBCKT sky130_fd_sc_hd__a2bb2o_4 A1_N A2_N B1 B2 VGND VNB VPB VPWR X
MMIN2 X y VGND VNB nfet_01v8 m=4 w=0.65 l=0.15 mult=1 sa=0.265
+ sb=0.265 sd=0.28 topography=normal area=0.063 perim=1.14
MMNnor0 inor A1_N VGND VNB nfet_01v8 m=2 w=0.65 l=0.15 mult=1 sa=0.265
+ sb=0.265 sd=0.28 topography=normal area=0.063 perim=1.14
MMNnor1 inor A2_N VGND VNB nfet_01v8 m=2 w=0.65 l=0.15 mult=1 sa=0.265
+ sb=0.265 sd=0.28 topography=normal area=0.063 perim=1.14
MMNaoi10 VGND B1 sndNB1 VNB nfet_01v8 m=2 w=0.65 l=0.15 mult=1
+ sa=0.265 sb=0.265 sd=0.28 topography=normal area=0.063 perim=1.14
MMNaoi11 sndNB1 B2 y VNB nfet_01v8 m=2 w=0.65 l=0.15 mult=1 sa=0.265
+ sb=0.265 sd=0.28 topography=normal area=0.063 perim=1.14
MMNaoi20 y inor VGND VNB nfet_01v8 m=2 w=0.65 l=0.15 mult=1 sa=0.265
+ sb=0.265 sd=0.28 topography=normal area=0.063 perim=1.14
MMPaoi20 y inor pmid VPB pfet_01v8_hvt m=2 w=1.0 l=0.15 mult=1
+ sa=0.265 sb=0.265 sd=0.28 topography=normal area=0.063 perim=1.14
MMIP2 X y VPWR VPB pfet_01v8_hvt m=4 w=1.0 l=0.15 mult=1 sa=0.265
+ sb=0.265 sd=0.28 topography=normal area=0.063 perim=1.14
MMPnor0 VPWR A1_N sndPA1N VPB pfet_01v8_hvt m=2 w=1.0 l=0.15 mult=1
+ sa=0.265 sb=0.265 sd=0.28 topography=normal area=0.063 perim=1.14
MMPnor1 sndPA1N A2_N inor VPB pfet_01v8_hvt m=2 w=1.0 l=0.15 mult=1
+ sa=0.265 sb=0.265 sd=0.28 topography=normal area=0.063 perim=1.14
MMPaoi10 pmid B1 VPWR VPB pfet_01v8_hvt m=2 w=1.0 l=0.15 mult=1
+ sa=0.265 sb=0.265 sd=0.28 topography=normal area=0.063 perim=1.14
MMPaoi11 pmid B2 VPWR VPB pfet_01v8_hvt m=2 w=1.0 l=0.15 mult=1
+ sa=0.265 sb=0.265 sd=0.28 topography=normal area=0.063 perim=1.14
.ENDS

.SUBCKT sky130_fd_sc_hd__a2bb2oi_1 A1_N A2_N B1 B2 VGND VNB VPB VPWR Y
MMNnor0 inor A1_N VGND VNB nfet_01v8 m=1 w=0.65 l=0.15 mult=1 sa=0.265
+ sb=0.265 sd=0.28 topography=normal area=0.063 perim=1.14
MMNnor1 inor A2_N VGND VNB nfet_01v8 m=1 w=0.65 l=0.15 mult=1 sa=0.265
+ sb=0.265 sd=0.28 topography=normal area=0.063 perim=1.14
MMNaoi10 VGND B1 sndNB1 VNB nfet_01v8 m=1 w=0.65 l=0.15 mult=1
+ sa=0.265 sb=0.265 sd=0.28 topography=normal area=0.063 perim=1.14
MMNaoi11 sndNB1 B2 Y VNB nfet_01v8 m=1 w=0.65 l=0.15 mult=1 sa=0.265
+ sb=0.265 sd=0.28 topography=normal area=0.063 perim=1.14
MMNaoi20 Y inor VGND VNB nfet_01v8 m=1 w=0.65 l=0.15 mult=1 sa=0.265
+ sb=0.265 sd=0.28 topography=normal area=0.063 perim=1.14
MMPnor0 VPWR A1_N sndPA1N VPB pfet_01v8_hvt m=1 w=1.0 l=0.15 mult=1
+ sa=0.265 sb=0.265 sd=0.28 topography=normal area=0.063 perim=1.14
MMPnor1 sndPA1N A2_N inor VPB pfet_01v8_hvt m=1 w=1.0 l=0.15 mult=1
+ sa=0.265 sb=0.265 sd=0.28 topography=normal area=0.063 perim=1.14
MMPaoi10 pmid B1 VPWR VPB pfet_01v8_hvt m=1 w=1.0 l=0.15 mult=1
+ sa=0.265 sb=0.265 sd=0.28 topography=normal area=0.063 perim=1.14
MMPaoi11 pmid B2 VPWR VPB pfet_01v8_hvt m=1 w=1.0 l=0.15 mult=1
+ sa=0.265 sb=0.265 sd=0.28 topography=normal area=0.063 perim=1.14
MMPaoi20 Y inor pmid VPB pfet_01v8_hvt m=1 w=1.0 l=0.15 mult=1
+ sa=0.265 sb=0.265 sd=0.28 topography=normal area=0.063 perim=1.14
.ENDS

.SUBCKT sky130_fd_sc_hd__a2bb2oi_2 A1_N A2_N B1 B2 VGND VNB VPB VPWR Y
MMNnor0 inor A1_N VGND VNB nfet_01v8 m=2 w=0.65 l=0.15 mult=1 sa=0.265
+ sb=0.265 sd=0.28 topography=normal area=0.063 perim=1.14
MMNnor1 inor A2_N VGND VNB nfet_01v8 m=2 w=0.65 l=0.15 mult=1 sa=0.265
+ sb=0.265 sd=0.28 topography=normal area=0.063 perim=1.14
MMNaoi10 VGND B1 sndNB1 VNB nfet_01v8 m=2 w=0.65 l=0.15 mult=1
+ sa=0.265 sb=0.265 sd=0.28 topography=normal area=0.063 perim=1.14
MMNaoi11 sndNB1 B2 Y VNB nfet_01v8 m=2 w=0.65 l=0.15 mult=1 sa=0.265
+ sb=0.265 sd=0.28 topography=normal area=0.063 perim=1.14
MMNaoi20 Y inor VGND VNB nfet_01v8 m=2 w=0.65 l=0.15 mult=1 sa=0.265
+ sb=0.265 sd=0.28 topography=normal area=0.063 perim=1.14
MMPnor0 VPWR A1_N sndPA1N VPB pfet_01v8_hvt m=2 w=1.0 l=0.15 mult=1
+ sa=0.265 sb=0.265 sd=0.28 topography=normal area=0.063 perim=1.14
MMPnor1 sndPA1N A2_N inor VPB pfet_01v8_hvt m=2 w=1.0 l=0.15 mult=1
+ sa=0.265 sb=0.265 sd=0.28 topography=normal area=0.063 perim=1.14
MMPaoi10 pmid B1 VPWR VPB pfet_01v8_hvt m=2 w=1.0 l=0.15 mult=1
+ sa=0.265 sb=0.265 sd=0.28 topography=normal area=0.063 perim=1.14
MMPaoi11 pmid B2 VPWR VPB pfet_01v8_hvt m=2 w=1.0 l=0.15 mult=1
+ sa=0.265 sb=0.265 sd=0.28 topography=normal area=0.063 perim=1.14
MMPaoi20 Y inor pmid VPB pfet_01v8_hvt m=2 w=1.0 l=0.15 mult=1
+ sa=0.265 sb=0.265 sd=0.28 topography=normal area=0.063 perim=1.14
.ENDS

.SUBCKT sky130_fd_sc_hd__a2bb2oi_4 A1_N A2_N B1 B2 VGND VNB VPB VPWR Y
MMNnor0 inor A1_N VGND VNB nfet_01v8 m=4 w=0.65 l=0.15 mult=1 sa=0.265
+ sb=0.265 sd=0.28 topography=normal area=0.063 perim=1.14
MMNnor1 inor A2_N VGND VNB nfet_01v8 m=4 w=0.65 l=0.15 mult=1 sa=0.265
+ sb=0.265 sd=0.28 topography=normal area=0.063 perim=1.14
MMNaoi10 VGND B1 sndNB1 VNB nfet_01v8 m=4 w=0.65 l=0.15 mult=1
+ sa=0.265 sb=0.265 sd=0.28 topography=normal area=0.063 perim=1.14
MMNaoi11 sndNB1 B2 Y VNB nfet_01v8 m=4 w=0.65 l=0.15 mult=1 sa=0.265
+ sb=0.265 sd=0.28 topography=normal area=0.063 perim=1.14
MMNaoi20 Y inor VGND VNB nfet_01v8 m=4 w=0.65 l=0.15 mult=1 sa=0.265
+ sb=0.265 sd=0.28 topography=normal area=0.063 perim=1.14
MMPnor0 VPWR A1_N sndPA1N VPB pfet_01v8_hvt m=4 w=1.0 l=0.15 mult=1
+ sa=0.265 sb=0.265 sd=0.28 topography=normal area=0.063 perim=1.14
MMPnor1 sndPA1N A2_N inor VPB pfet_01v8_hvt m=4 w=1.0 l=0.15 mult=1
+ sa=0.265 sb=0.265 sd=0.28 topography=normal area=0.063 perim=1.14
MMPaoi10 pmid B1 VPWR VPB pfet_01v8_hvt m=4 w=1.0 l=0.15 mult=1
+ sa=0.265 sb=0.265 sd=0.28 topography=normal area=0.063 perim=1.14
MMPaoi11 pmid B2 VPWR VPB pfet_01v8_hvt m=4 w=1.0 l=0.15 mult=1
+ sa=0.265 sb=0.265 sd=0.28 topography=normal area=0.063 perim=1.14
MMPaoi20 Y inor pmid VPB pfet_01v8_hvt m=4 w=1.0 l=0.15 mult=1
+ sa=0.265 sb=0.265 sd=0.28 topography=normal area=0.063 perim=1.14
.ENDS

.SUBCKT sky130_fd_sc_hd__a21bo_1 A1 A2 B1_N VGND VNB VPB VPWR X
MMPA0 pndA A1 VPWR VPB pfet_01v8_hvt m=1 w=1.0 l=0.15 mult=1 sa=0.265
+ sb=0.265 sd=0.28 topography=normal area=0.063 perim=1.14
MMPA1 pndA A2 VPWR VPB pfet_01v8_hvt m=1 w=1.0 l=0.15 mult=1 sa=0.265
+ sb=0.265 sd=0.28 topography=normal area=0.063 perim=1.14
MMPB0 y B1 pndA VPB pfet_01v8_hvt m=1 w=1.0 l=0.15 mult=1 sa=0.265
+ sb=0.265 sd=0.28 topography=normal area=0.063 perim=1.14
MMIPB1N B1 B1_N VPWR VPB pfet_01v8_hvt m=1 w=0.42 l=0.15 mult=1
+ sa=0.265 sb=0.265 sd=0.28 topography=normal area=0.063 perim=1.14
MMIPX X y VPWR VPB pfet_01v8_hvt m=1 w=1.0 l=0.15 mult=1 sa=0.265
+ sb=0.265 sd=0.28 topography=normal area=0.063 perim=1.14
MMNA0 y A1 sndA1 VNB nfet_01v8 m=1 w=0.65 l=0.15 mult=1 sa=0.265
+ sb=0.265 sd=0.28 topography=normal area=0.063 perim=1.14
MMNA1 sndA1 A2 VGND VNB nfet_01v8 m=1 w=0.65 l=0.15 mult=1 sa=0.265
+ sb=0.265 sd=0.28 topography=normal area=0.063 perim=1.14
MMNB0 y B1 VGND VNB nfet_01v8 m=1 w=0.65 l=0.15 mult=1 sa=0.265
+ sb=0.265 sd=0.28 topography=normal area=0.063 perim=1.14
MMINB1N B1 B1_N VGND VNB nfet_01v8 m=1 w=0.42 l=0.15 mult=1 sa=0.265
+ sb=0.265 sd=0.28 topography=normal area=0.063 perim=1.14
MMINX X y VGND VNB nfet_01v8 m=1 w=0.65 l=0.15 mult=1 sa=0.265
+ sb=0.265 sd=0.28 topography=normal area=0.063 perim=1.14
.ENDS

.SUBCKT sky130_fd_sc_hd__a21bo_2 A1 A2 B1_N VGND VNB VPB VPWR X
MMPA0 pndA A1 VPWR VPB pfet_01v8_hvt m=1 w=1.0 l=0.15 mult=1 sa=0.265
+ sb=0.265 sd=0.28 topography=normal area=0.063 perim=1.14
MMPA1 pndA A2 VPWR VPB pfet_01v8_hvt m=1 w=1.0 l=0.15 mult=1 sa=0.265
+ sb=0.265 sd=0.28 topography=normal area=0.063 perim=1.14
MMPB0 y B1 pndA VPB pfet_01v8_hvt m=1 w=1.0 l=0.15 mult=1 sa=0.265
+ sb=0.265 sd=0.28 topography=normal area=0.063 perim=1.14
MMIPB1N B1 B1_N VPWR VPB pfet_01v8_hvt m=1 w=0.42 l=0.15 mult=1
+ sa=0.265 sb=0.265 sd=0.28 topography=normal area=0.063 perim=1.14
MMIPX X y VPWR VPB pfet_01v8_hvt m=2 w=1.0 l=0.15 mult=1 sa=0.265
+ sb=0.265 sd=0.28 topography=normal area=0.063 perim=1.14
MMNA0 y A1 sndA1 VNB nfet_01v8 m=1 w=0.65 l=0.15 mult=1 sa=0.265
+ sb=0.265 sd=0.28 topography=normal area=0.063 perim=1.14
MMNA1 sndA1 A2 VGND VNB nfet_01v8 m=1 w=0.65 l=0.15 mult=1 sa=0.265
+ sb=0.265 sd=0.28 topography=normal area=0.063 perim=1.14
MMNB0 y B1 VGND VNB nfet_01v8 m=1 w=0.65 l=0.15 mult=1 sa=0.265
+ sb=0.265 sd=0.28 topography=normal area=0.063 perim=1.14
MMINB1N B1 B1_N VGND VNB nfet_01v8 m=1 w=0.42 l=0.15 mult=1 sa=0.265
+ sb=0.265 sd=0.28 topography=normal area=0.063 perim=1.14
MMINX X y VGND VNB nfet_01v8 m=2 w=0.65 l=0.15 mult=1 sa=0.265
+ sb=0.265 sd=0.28 topography=normal area=0.063 perim=1.14
.ENDS

.SUBCKT sky130_fd_sc_hd__a21bo_4 A1 A2 B1_N VGND VNB VPB VPWR X
MMPA0 pndA A1 VPWR VPB pfet_01v8_hvt m=2 w=1.0 l=0.15 mult=1 sa=0.265
+ sb=0.265 sd=0.28 topography=normal area=0.063 perim=1.14
MMPA1 pndA A2 VPWR VPB pfet_01v8_hvt m=2 w=1.0 l=0.15 mult=1 sa=0.265
+ sb=0.265 sd=0.28 topography=normal area=0.063 perim=1.14
MMPB0 y B1 pndA VPB pfet_01v8_hvt m=2 w=1.0 l=0.15 mult=1 sa=0.265
+ sb=0.265 sd=0.28 topography=normal area=0.063 perim=1.14
MMIPB1N B1 B1_N VPWR VPB pfet_01v8_hvt m=1 w=1.0 l=0.15 mult=1
+ sa=0.265 sb=0.265 sd=0.28 topography=normal area=0.063 perim=1.14
MMIPX X y VPWR VPB pfet_01v8_hvt m=4 w=1.0 l=0.15 mult=1 sa=0.265
+ sb=0.265 sd=0.28 topography=normal area=0.063 perim=1.14
MMNA0 y A1 sndA1 VNB nfet_01v8 w=0.65 l=0.15 mult=1 sa=0.265
+ sb=0.265 sd=0.28 topography=normal area=0.063 perim=1.14
MMNA20 y A1 snd2A1 VNB nfet_01v8 w=0.65 l=0.15 mult=1 sa=0.265
+ sb=0.265 sd=0.28 topography=normal area=0.063 perim=1.14
MMNA1 sndA1 A2 VGND VNB nfet_01v8 w=0.65 l=0.15 mult=1 sa=0.265
+ sb=0.265 sd=0.28 topography=normal area=0.063 perim=1.14
MMNA21 snd2A1 A2 VGND VNB nfet_01v8 w=0.65 l=0.15 mult=1 sa=0.265
+ sb=0.265 sd=0.28 topography=normal area=0.063 perim=1.14
MMNB0 y B1 VGND VNB nfet_01v8 m=2 w=0.65 l=0.15 mult=1 sa=0.265
+ sb=0.265 sd=0.28 topography=normal area=0.063 perim=1.14
MMINB1N B1 B1_N VGND VNB nfet_01v8 m=1 w=0.65 l=0.15 mult=1 sa=0.265
+ sb=0.265 sd=0.28 topography=normal area=0.063 perim=1.14
MMINX X y VGND VNB nfet_01v8 m=4 w=0.65 l=0.15 mult=1 sa=0.265
+ sb=0.265 sd=0.28 topography=normal area=0.063 perim=1.14
.ENDS

.SUBCKT sky130_fd_sc_hd__a21boi_0 A1 A2 B1_N VGND VNB VPB VPWR Y
MMPA0 net40 A1 VPWR VPB pfet_01v8_hvt m=1 w=0.64 l=0.15 mult=1
+ sa=0.265 sb=0.265 sd=0.28 topography=normal area=0.063 perim=1.14
MMPA1 net40 A2 VPWR VPB pfet_01v8_hvt m=1 w=0.64 l=0.15 mult=1
+ sa=0.265 sb=0.265 sd=0.28 topography=normal area=0.063 perim=1.14
MMPB0 Y B1 net40 VPB pfet_01v8_hvt m=1 w=0.64 l=0.15 mult=1 sa=0.265
+ sb=0.265 sd=0.28 topography=normal area=0.063 perim=1.14
MMIPB1N B1 B1_N VPWR VPB pfet_01v8_hvt m=1 w=0.42 l=0.15 mult=1
+ sa=0.265 sb=0.265 sd=0.28 topography=normal area=0.063 perim=1.14
MMNA0 Y A1 sndA1 VNB nfet_01v8 m=1 w=0.42 l=0.15 mult=1 sa=0.265
+ sb=0.265 sd=0.28 topography=normal area=0.063 perim=1.14
MMNA1 sndA1 A2 VGND VNB nfet_01v8 m=1 w=0.42 l=0.15 mult=1 sa=0.265
+ sb=0.265 sd=0.28 topography=normal area=0.063 perim=1.14
MMNB0 Y B1 VGND VNB nfet_01v8 m=1 w=0.42 l=0.15 mult=1 sa=0.265
+ sb=0.265 sd=0.28 topography=normal area=0.063 perim=1.14
MMINB1N B1 B1_N VGND VNB nfet_01v8 m=1 w=0.42 l=0.15 mult=1 sa=0.265
+ sb=0.265 sd=0.28 topography=normal area=0.063 perim=1.14
.ENDS

.SUBCKT sky130_fd_sc_hd__a21boi_1 A1 A2 B1_N VGND VNB VPB VPWR Y
MMPA0 net40 A1 VPWR VPB pfet_01v8_hvt m=1 w=1.0 l=0.15 mult=1 sa=0.265
+ sb=0.265 sd=0.28 topography=normal area=0.063 perim=1.14
MMPA1 net40 A2 VPWR VPB pfet_01v8_hvt m=1 w=1.0 l=0.15 mult=1 sa=0.265
+ sb=0.265 sd=0.28 topography=normal area=0.063 perim=1.14
MMPB0 Y B1 net40 VPB pfet_01v8_hvt m=1 w=1.0 l=0.15 mult=1 sa=0.265
+ sb=0.265 sd=0.28 topography=normal area=0.063 perim=1.14
MMIPB1N B1 B1_N VPWR VPB pfet_01v8_hvt m=1 w=0.42 l=0.15 mult=1
+ sa=0.265 sb=0.265 sd=0.28 topography=normal area=0.063 perim=1.14
MMNA0 Y A1 sndA1 VNB nfet_01v8 m=1 w=0.65 l=0.15 mult=1 sa=0.265
+ sb=0.265 sd=0.28 topography=normal area=0.063 perim=1.14
MMNA1 sndA1 A2 VGND VNB nfet_01v8 m=1 w=0.65 l=0.15 mult=1 sa=0.265
+ sb=0.265 sd=0.28 topography=normal area=0.063 perim=1.14
MMNB0 Y B1 VGND VNB nfet_01v8 m=1 w=0.65 l=0.15 mult=1 sa=0.265
+ sb=0.265 sd=0.28 topography=normal area=0.063 perim=1.14
MMINB1N B1 B1_N VGND VNB nfet_01v8 m=1 w=0.42 l=0.15 mult=1 sa=0.265
+ sb=0.265 sd=0.28 topography=normal area=0.063 perim=1.14
.ENDS

.SUBCKT sky130_fd_sc_hd__a21boi_2 A1 A2 B1_N VGND VNB VPB VPWR Y
MMPA0 net40 A1 VPWR VPB pfet_01v8_hvt m=2 w=1.0 l=0.15 mult=1 sa=0.265
+ sb=0.265 sd=0.28 topography=normal area=0.063 perim=1.14
MMPA1 net40 A2 VPWR VPB pfet_01v8_hvt m=2 w=1.0 l=0.15 mult=1 sa=0.265
+ sb=0.265 sd=0.28 topography=normal area=0.063 perim=1.14
MMPB0 Y B1 net40 VPB pfet_01v8_hvt m=2 w=1.0 l=0.15 mult=1 sa=0.265
+ sb=0.265 sd=0.28 topography=normal area=0.063 perim=1.14
MMIPB1N B1 B1_N VPWR VPB pfet_01v8_hvt m=1 w=0.42 l=0.15 mult=1
+ sa=0.265 sb=0.265 sd=0.28 topography=normal area=0.063 perim=1.14
MMNA0 Y A1 sndA1 VNB nfet_01v8 m=2 w=0.65 l=0.15 mult=1 sa=0.265
+ sb=0.265 sd=0.28 topography=normal area=0.063 perim=1.14
MMNA1 sndA1 A2 VGND VNB nfet_01v8 m=2 w=0.65 l=0.15 mult=1 sa=0.265
+ sb=0.265 sd=0.28 topography=normal area=0.063 perim=1.14
MMNB0 Y B1 VGND VNB nfet_01v8 m=2 w=0.65 l=0.15 mult=1 sa=0.265
+ sb=0.265 sd=0.28 topography=normal area=0.063 perim=1.14
MMINB1N B1 B1_N VGND VNB nfet_01v8 m=1 w=0.42 l=0.15 mult=1 sa=0.265
+ sb=0.265 sd=0.28 topography=normal area=0.063 perim=1.14
.ENDS

.SUBCKT sky130_fd_sc_hd__a21boi_4 A1 A2 B1_N VGND VNB VPB VPWR Y
MMPA0 net40 A1 VPWR VPB pfet_01v8_hvt m=4 w=1.0 l=0.15 mult=1 sa=0.265
+ sb=0.265 sd=0.28 topography=normal area=0.063 perim=1.14
MMPA1 net40 A2 VPWR VPB pfet_01v8_hvt m=4 w=1.0 l=0.15 mult=1 sa=0.265
+ sb=0.265 sd=0.28 topography=normal area=0.063 perim=1.14
MMPB0 Y B1 net40 VPB pfet_01v8_hvt m=4 w=1.0 l=0.15 mult=1 sa=0.265
+ sb=0.265 sd=0.28 topography=normal area=0.063 perim=1.14
MMIPB1N B1 B1_N VPWR VPB pfet_01v8_hvt m=1 w=1.0 l=0.15 mult=1
+ sa=0.265 sb=0.265 sd=0.28 topography=normal area=0.063 perim=1.14
MMNA0 Y A1 sndA1 VNB nfet_01v8 m=4 w=0.65 l=0.15 mult=1 sa=0.265
+ sb=0.265 sd=0.28 topography=normal area=0.063 perim=1.14
MMNA1 sndA1 A2 VGND VNB nfet_01v8 m=4 w=0.65 l=0.15 mult=1 sa=0.265
+ sb=0.265 sd=0.28 topography=normal area=0.063 perim=1.14
MMNB0 Y B1 VGND VNB nfet_01v8 m=4 w=0.65 l=0.15 mult=1 sa=0.265
+ sb=0.265 sd=0.28 topography=normal area=0.063 perim=1.14
MMINB1N B1 B1_N VGND VNB nfet_01v8 m=1 w=0.65 l=0.15 mult=1 sa=0.265
+ sb=0.265 sd=0.28 topography=normal area=0.063 perim=1.14
.ENDS

.SUBCKT sky130_fd_sc_hd__a21o_1 A1 A2 B1 VGND VNB VPB VPWR X
MMPA0 pndA A1 VPWR VPB pfet_01v8_hvt m=1 w=1.0 l=0.15 mult=1 sa=0.265
+ sb=0.265 sd=0.28 topography=normal area=0.063 perim=1.14
MMPA1 pndA A2 VPWR VPB pfet_01v8_hvt m=1 w=1.0 l=0.15 mult=1 sa=0.265
+ sb=0.265 sd=0.28 topography=normal area=0.063 perim=1.14
MMPB0 y B1 pndA VPB pfet_01v8_hvt m=1 w=1.0 l=0.15 mult=1 sa=0.265
+ sb=0.265 sd=0.28 topography=normal area=0.063 perim=1.14
MMIPX X y VPWR VPB pfet_01v8_hvt m=1 w=1.0 l=0.15 mult=1 sa=0.265
+ sb=0.265 sd=0.28 topography=normal area=0.063 perim=1.14
MMNA0 y A1 sndA1 VNB nfet_01v8 m=1 w=0.65 l=0.15 mult=1 sa=0.265
+ sb=0.265 sd=0.28 topography=normal area=0.063 perim=1.14
MMNA1 sndA1 A2 VGND VNB nfet_01v8 m=1 w=0.65 l=0.15 mult=1 sa=0.265
+ sb=0.265 sd=0.28 topography=normal area=0.063 perim=1.14
MMNB0 y B1 VGND VNB nfet_01v8 m=1 w=0.65 l=0.15 mult=1 sa=0.265
+ sb=0.265 sd=0.28 topography=normal area=0.063 perim=1.14
MMINX X y VGND VNB nfet_01v8 m=1 w=0.65 l=0.15 mult=1 sa=0.265
+ sb=0.265 sd=0.28 topography=normal area=0.063 perim=1.14
.ENDS

.SUBCKT sky130_fd_sc_hd__a21o_2 A1 A2 B1 VGND VNB VPB VPWR X
MMPA0 pndA A1 VPWR VPB pfet_01v8_hvt m=1 w=1.0 l=0.15 mult=1 sa=0.265
+ sb=0.265 sd=0.28 topography=normal area=0.063 perim=1.14
MMPA1 pndA A2 VPWR VPB pfet_01v8_hvt m=1 w=1.0 l=0.15 mult=1 sa=0.265
+ sb=0.265 sd=0.28 topography=normal area=0.063 perim=1.14
MMPB0 y B1 pndA VPB pfet_01v8_hvt m=1 w=1.0 l=0.15 mult=1 sa=0.265
+ sb=0.265 sd=0.28 topography=normal area=0.063 perim=1.14
MMIPX X y VPWR VPB pfet_01v8_hvt m=2 w=1.0 l=0.15 mult=1 sa=0.265
+ sb=0.265 sd=0.28 topography=normal area=0.063 perim=1.14
MMNA0 y A1 sndA1 VNB nfet_01v8 m=1 w=0.65 l=0.15 mult=1 sa=0.265
+ sb=0.265 sd=0.28 topography=normal area=0.063 perim=1.14
MMNA1 sndA1 A2 VGND VNB nfet_01v8 m=1 w=0.65 l=0.15 mult=1 sa=0.265
+ sb=0.265 sd=0.28 topography=normal area=0.063 perim=1.14
MMNB0 y B1 VGND VNB nfet_01v8 m=1 w=0.65 l=0.15 mult=1 sa=0.265
+ sb=0.265 sd=0.28 topography=normal area=0.063 perim=1.14
MMINX X y VGND VNB nfet_01v8 m=2 w=0.65 l=0.15 mult=1 sa=0.265
+ sb=0.265 sd=0.28 topography=normal area=0.063 perim=1.14
.ENDS

.SUBCKT sky130_fd_sc_hd__a21o_4 A1 A2 B1 VGND VNB VPB VPWR X
MMPA0 pndA A1 VPWR VPB pfet_01v8_hvt m=2 w=1.0 l=0.15 mult=1 sa=0.265
+ sb=0.265 sd=0.28 topography=normal area=0.063 perim=1.14
MMPA1 pndA A2 VPWR VPB pfet_01v8_hvt m=2 w=1.0 l=0.15 mult=1 sa=0.265
+ sb=0.265 sd=0.28 topography=normal area=0.063 perim=1.14
MMPB0 y B1 pndA VPB pfet_01v8_hvt m=2 w=1.0 l=0.15 mult=1 sa=0.265
+ sb=0.265 sd=0.28 topography=normal area=0.063 perim=1.14
MMIPX X y VPWR VPB pfet_01v8_hvt m=4 w=1.0 l=0.15 mult=1 sa=0.265
+ sb=0.265 sd=0.28 topography=normal area=0.063 perim=1.14
MMNA0 y A1 sndA1 VNB nfet_01v8 w=0.65 l=0.15 mult=1 sa=0.265
+ sb=0.265 sd=0.28 topography=normal area=0.063 perim=1.14
MMNA20 y A1 snd2A1 VNB nfet_01v8 w=0.65 l=0.15 mult=1 sa=0.265
+ sb=0.265 sd=0.28 topography=normal area=0.063 perim=1.14
MMNA1 sndA1 A2 VGND VNB nfet_01v8 w=0.65 l=0.15 mult=1 sa=0.265
+ sb=0.265 sd=0.28 topography=normal area=0.063 perim=1.14
MMNA21 snd2A1 A2 VGND VNB nfet_01v8 w=0.65 l=0.15 mult=1 sa=0.265
+ sb=0.265 sd=0.28 topography=normal area=0.063 perim=1.14
MMNB0 y B1 VGND VNB nfet_01v8 m=2 w=0.65 l=0.15 mult=1 sa=0.265
+ sb=0.265 sd=0.28 topography=normal area=0.063 perim=1.14
MMINX X y VGND VNB nfet_01v8 m=4 w=0.65 l=0.15 mult=1 sa=0.265
+ sb=0.265 sd=0.28 topography=normal area=0.063 perim=1.14
.ENDS

.SUBCKT sky130_fd_sc_hd__a21oi_1 A1 A2 B1 VGND VNB VPB VPWR Y
MMPA0 pndA A1 VPWR VPB pfet_01v8_hvt m=1 w=1.0 l=0.15 mult=1 sa=0.265
+ sb=0.265 sd=0.28 topography=normal area=0.063 perim=1.14
MMPA1 pndA A2 VPWR VPB pfet_01v8_hvt m=1 w=1.0 l=0.15 mult=1 sa=0.265
+ sb=0.265 sd=0.28 topography=normal area=0.063 perim=1.14
MMPB0 Y B1 pndA VPB pfet_01v8_hvt m=1 w=1.0 l=0.15 mult=1 sa=0.265
+ sb=0.265 sd=0.28 topography=normal area=0.063 perim=1.14
MMNA0 Y A1 sndA1 VNB nfet_01v8 m=1 w=0.65 l=0.15 mult=1 sa=0.265
+ sb=0.265 sd=0.28 topography=normal area=0.063 perim=1.14
MMNA1 sndA1 A2 VGND VNB nfet_01v8 m=1 w=0.65 l=0.15 mult=1 sa=0.265
+ sb=0.265 sd=0.28 topography=normal area=0.063 perim=1.14
MMNB0 Y B1 VGND VNB nfet_01v8 m=1 w=0.65 l=0.15 mult=1 sa=0.265
+ sb=0.265 sd=0.28 topography=normal area=0.063 perim=1.14
.ENDS

.SUBCKT sky130_fd_sc_hd__a21oi_2 A1 A2 B1 VGND VNB VPB VPWR Y
MMPA0 pndA A1 VPWR VPB pfet_01v8_hvt m=2 w=1.0 l=0.15 mult=1 sa=0.265
+ sb=0.265 sd=0.28 topography=normal area=0.063 perim=1.14
MMPA1 pndA A2 VPWR VPB pfet_01v8_hvt m=2 w=1.0 l=0.15 mult=1 sa=0.265
+ sb=0.265 sd=0.28 topography=normal area=0.063 perim=1.14
MMPB0 Y B1 pndA VPB pfet_01v8_hvt m=2 w=1.0 l=0.15 mult=1 sa=0.265
+ sb=0.265 sd=0.28 topography=normal area=0.063 perim=1.14
MMNA0 Y A1 sndA1 VNB nfet_01v8 m=2 w=0.65 l=0.15 mult=1 sa=0.265
+ sb=0.265 sd=0.28 topography=normal area=0.063 perim=1.14
MMNA1 sndA1 A2 VGND VNB nfet_01v8 m=2 w=0.65 l=0.15 mult=1 sa=0.265
+ sb=0.265 sd=0.28 topography=normal area=0.063 perim=1.14
MMNB0 Y B1 VGND VNB nfet_01v8 m=2 w=0.65 l=0.15 mult=1 sa=0.265
+ sb=0.265 sd=0.28 topography=normal area=0.063 perim=1.14
.ENDS

.SUBCKT sky130_fd_sc_hd__a21oi_4 A1 A2 B1 VGND VNB VPB VPWR Y
MMPA0 pndA A1 VPWR VPB pfet_01v8_hvt m=4 w=1.0 l=0.15 mult=1 sa=0.265
+ sb=0.265 sd=0.28 topography=normal area=0.063 perim=1.14
MMPA1 pndA A2 VPWR VPB pfet_01v8_hvt m=4 w=1.0 l=0.15 mult=1 sa=0.265
+ sb=0.265 sd=0.28 topography=normal area=0.063 perim=1.14
MMPB0 Y B1 pndA VPB pfet_01v8_hvt m=4 w=1.0 l=0.15 mult=1 sa=0.265
+ sb=0.265 sd=0.28 topography=normal area=0.063 perim=1.14
MMNA0 Y A1 sndA1 VNB nfet_01v8 m=4 w=0.65 l=0.15 mult=1 sa=0.265
+ sb=0.265 sd=0.28 topography=normal area=0.063 perim=1.14
MMNA1 sndA1 A2 VGND VNB nfet_01v8 m=4 w=0.65 l=0.15 mult=1 sa=0.265
+ sb=0.265 sd=0.28 topography=normal area=0.063 perim=1.14
MMNB0 Y B1 VGND VNB nfet_01v8 m=4 w=0.65 l=0.15 mult=1 sa=0.265
+ sb=0.265 sd=0.28 topography=normal area=0.063 perim=1.14
.ENDS

.SUBCKT sky130_fd_sc_hd__a22o_1 A1 A2 B1 B2 VGND VNB VPB VPWR X
MMPA0 pndA A1 VPWR VPB pfet_01v8_hvt m=1 w=1.0 l=0.15 mult=1 sa=0.265
+ sb=0.265 sd=0.28 topography=normal area=0.063 perim=1.14
MMPA1 pndA A2 VPWR VPB pfet_01v8_hvt m=1 w=1.0 l=0.15 mult=1 sa=0.265
+ sb=0.265 sd=0.28 topography=normal area=0.063 perim=1.14
MMPB0 y B1 pndA VPB pfet_01v8_hvt m=1 w=1.0 l=0.15 mult=1 sa=0.265
+ sb=0.265 sd=0.28 topography=normal area=0.063 perim=1.14
MMPB1 y B2 pndA VPB pfet_01v8_hvt m=1 w=1.0 l=0.15 mult=1 sa=0.265
+ sb=0.265 sd=0.28 topography=normal area=0.063 perim=1.14
MMIPX X y VPWR VPB pfet_01v8_hvt m=1 w=1.0 l=0.15 mult=1 sa=0.265
+ sb=0.265 sd=0.28 topography=normal area=0.063 perim=1.14
MMNA0 y A1 sndA1 VNB nfet_01v8 m=1 w=0.65 l=0.15 mult=1 sa=0.265
+ sb=0.265 sd=0.28 topography=normal area=0.063 perim=1.14
MMNA1 sndA1 A2 VGND VNB nfet_01v8 m=1 w=0.65 l=0.15 mult=1 sa=0.265
+ sb=0.265 sd=0.28 topography=normal area=0.063 perim=1.14
MMNB0 y B1 sndB1 VNB nfet_01v8 m=1 w=0.65 l=0.15 mult=1 sa=0.265
+ sb=0.265 sd=0.28 topography=normal area=0.063 perim=1.14
MMNB1 sndB1 B2 VGND VNB nfet_01v8 m=1 w=0.65 l=0.15 mult=1 sa=0.265
+ sb=0.265 sd=0.28 topography=normal area=0.063 perim=1.14
MMINX X y VGND VNB nfet_01v8 m=1 w=0.65 l=0.15 mult=1 sa=0.265
+ sb=0.265 sd=0.28 topography=normal area=0.063 perim=1.14
.ENDS

.SUBCKT sky130_fd_sc_hd__a22o_2 A1 A2 B1 B2 VGND VNB VPB VPWR X
MMPA0 pndA A1 VPWR VPB pfet_01v8_hvt m=1 w=1.0 l=0.15 mult=1 sa=0.265
+ sb=0.265 sd=0.28 topography=normal area=0.063 perim=1.14
MMPA1 pndA A2 VPWR VPB pfet_01v8_hvt m=1 w=1.0 l=0.15 mult=1 sa=0.265
+ sb=0.265 sd=0.28 topography=normal area=0.063 perim=1.14
MMPB0 y B1 pndA VPB pfet_01v8_hvt m=1 w=1.0 l=0.15 mult=1 sa=0.265
+ sb=0.265 sd=0.28 topography=normal area=0.063 perim=1.14
MMPB1 y B2 pndA VPB pfet_01v8_hvt m=1 w=1.0 l=0.15 mult=1 sa=0.265
+ sb=0.265 sd=0.28 topography=normal area=0.063 perim=1.14
MMIPX X y VPWR VPB pfet_01v8_hvt m=2 w=1.0 l=0.15 mult=1 sa=0.265
+ sb=0.265 sd=0.28 topography=normal area=0.063 perim=1.14
MMNA0 y A1 sndA1 VNB nfet_01v8 m=1 w=0.65 l=0.15 mult=1 sa=0.265
+ sb=0.265 sd=0.28 topography=normal area=0.063 perim=1.14
MMNA1 sndA1 A2 VGND VNB nfet_01v8 m=1 w=0.65 l=0.15 mult=1 sa=0.265
+ sb=0.265 sd=0.28 topography=normal area=0.063 perim=1.14
MMNB0 y B1 sndB1 VNB nfet_01v8 m=1 w=0.65 l=0.15 mult=1 sa=0.265
+ sb=0.265 sd=0.28 topography=normal area=0.063 perim=1.14
MMNB1 sndB1 B2 VGND VNB nfet_01v8 m=1 w=0.65 l=0.15 mult=1 sa=0.265
+ sb=0.265 sd=0.28 topography=normal area=0.063 perim=1.14
MMINX X y VGND VNB nfet_01v8 m=2 w=0.65 l=0.15 mult=1 sa=0.265
+ sb=0.265 sd=0.28 topography=normal area=0.063 perim=1.14
.ENDS

.SUBCKT sky130_fd_sc_hd__a22o_4 A1 A2 B1 B2 VGND VNB VPB VPWR X
MMPA0 pndA A1 VPWR VPB pfet_01v8_hvt m=2 w=1.0 l=0.15 mult=1 sa=0.265
+ sb=0.265 sd=0.28 topography=normal area=0.063 perim=1.14
MMPA1 pndA A2 VPWR VPB pfet_01v8_hvt m=2 w=1.0 l=0.15 mult=1 sa=0.265
+ sb=0.265 sd=0.28 topography=normal area=0.063 perim=1.14
MMPB0 y B1 pndA VPB pfet_01v8_hvt m=2 w=1.0 l=0.15 mult=1 sa=0.265
+ sb=0.265 sd=0.28 topography=normal area=0.063 perim=1.14
MMPB1 y B2 pndA VPB pfet_01v8_hvt m=2 w=1.0 l=0.15 mult=1 sa=0.265
+ sb=0.265 sd=0.28 topography=normal area=0.063 perim=1.14
MMIPX X y VPWR VPB pfet_01v8_hvt m=4 w=1.0 l=0.15 mult=1 sa=0.265
+ sb=0.265 sd=0.28 topography=normal area=0.063 perim=1.14
MMNA0 y A1 sndA1 VNB nfet_01v8 m=2 w=0.65 l=0.15 mult=1 sa=0.265
+ sb=0.265 sd=0.28 topography=normal area=0.063 perim=1.14
MMNA1 sndA1 A2 VGND VNB nfet_01v8 m=2 w=0.65 l=0.15 mult=1 sa=0.265
+ sb=0.265 sd=0.28 topography=normal area=0.063 perim=1.14
MMNB0 y B1 sndB1 VNB nfet_01v8 m=2 w=0.65 l=0.15 mult=1 sa=0.265
+ sb=0.265 sd=0.28 topography=normal area=0.063 perim=1.14
MMNB1 sndB1 B2 VGND VNB nfet_01v8 m=2 w=0.65 l=0.15 mult=1 sa=0.265
+ sb=0.265 sd=0.28 topography=normal area=0.063 perim=1.14
MMINX X y VGND VNB nfet_01v8 m=4 w=0.65 l=0.15 mult=1 sa=0.265
+ sb=0.265 sd=0.28 topography=normal area=0.063 perim=1.14
.ENDS

.SUBCKT sky130_fd_sc_hd__a22oi_1 A1 A2 B1 B2 VGND VNB VPB VPWR Y
MMPA0 pndA A1 VPWR VPB pfet_01v8_hvt m=1 w=1.0 l=0.15 mult=1 sa=0.265
+ sb=0.265 sd=0.28 topography=normal area=0.063 perim=1.14
MMPA1 pndA A2 VPWR VPB pfet_01v8_hvt m=1 w=1.0 l=0.15 mult=1 sa=0.265
+ sb=0.265 sd=0.28 topography=normal area=0.063 perim=1.14
MMPB0 Y B1 pndA VPB pfet_01v8_hvt m=1 w=1.0 l=0.15 mult=1 sa=0.265
+ sb=0.265 sd=0.28 topography=normal area=0.063 perim=1.14
MMPB1 Y B2 pndA VPB pfet_01v8_hvt m=1 w=1.0 l=0.15 mult=1 sa=0.265
+ sb=0.265 sd=0.28 topography=normal area=0.063 perim=1.14
MMNA0 Y A1 sndA1 VNB nfet_01v8 m=1 w=0.65 l=0.15 mult=1 sa=0.265
+ sb=0.265 sd=0.28 topography=normal area=0.063 perim=1.14
MMNA1 sndA1 A2 VGND VNB nfet_01v8 m=1 w=0.65 l=0.15 mult=1 sa=0.265
+ sb=0.265 sd=0.28 topography=normal area=0.063 perim=1.14
MMNB0 Y B1 sndB1 VNB nfet_01v8 m=1 w=0.65 l=0.15 mult=1 sa=0.265
+ sb=0.265 sd=0.28 topography=normal area=0.063 perim=1.14
MMNB1 sndB1 B2 VGND VNB nfet_01v8 m=1 w=0.65 l=0.15 mult=1 sa=0.265
+ sb=0.265 sd=0.28 topography=normal area=0.063 perim=1.14
.ENDS

.SUBCKT sky130_fd_sc_hd__a22oi_2 A1 A2 B1 B2 VGND VNB VPB VPWR Y
MMPA0 pndA A1 VPWR VPB pfet_01v8_hvt m=2 w=1.0 l=0.15 mult=1 sa=0.265
+ sb=0.265 sd=0.28 topography=normal area=0.063 perim=1.14
MMPA1 pndA A2 VPWR VPB pfet_01v8_hvt m=2 w=1.0 l=0.15 mult=1 sa=0.265
+ sb=0.265 sd=0.28 topography=normal area=0.063 perim=1.14
MMPB0 Y B1 pndA VPB pfet_01v8_hvt m=2 w=1.0 l=0.15 mult=1 sa=0.265
+ sb=0.265 sd=0.28 topography=normal area=0.063 perim=1.14
MMPB1 Y B2 pndA VPB pfet_01v8_hvt m=2 w=1.0 l=0.15 mult=1 sa=0.265
+ sb=0.265 sd=0.28 topography=normal area=0.063 perim=1.14
MMNA0 Y A1 sndA1 VNB nfet_01v8 m=2 w=0.65 l=0.15 mult=1 sa=0.265
+ sb=0.265 sd=0.28 topography=normal area=0.063 perim=1.14
MMNA1 sndA1 A2 VGND VNB nfet_01v8 m=2 w=0.65 l=0.15 mult=1 sa=0.265
+ sb=0.265 sd=0.28 topography=normal area=0.063 perim=1.14
MMNB0 Y B1 sndB1 VNB nfet_01v8 m=2 w=0.65 l=0.15 mult=1 sa=0.265
+ sb=0.265 sd=0.28 topography=normal area=0.063 perim=1.14
MMNB1 sndB1 B2 VGND VNB nfet_01v8 m=2 w=0.65 l=0.15 mult=1 sa=0.265
+ sb=0.265 sd=0.28 topography=normal area=0.063 perim=1.14
.ENDS

.SUBCKT sky130_fd_sc_hd__a22oi_4 A1 A2 B1 B2 VGND VNB VPB VPWR Y
MMPA0 pndA A1 VPWR VPB pfet_01v8_hvt m=4 w=1.0 l=0.15 mult=1 sa=0.265
+ sb=0.265 sd=0.28 topography=normal area=0.063 perim=1.14
MMPA1 pndA A2 VPWR VPB pfet_01v8_hvt m=4 w=1.0 l=0.15 mult=1 sa=0.265
+ sb=0.265 sd=0.28 topography=normal area=0.063 perim=1.14
MMPB0 Y B1 pndA VPB pfet_01v8_hvt m=4 w=1.0 l=0.15 mult=1 sa=0.265
+ sb=0.265 sd=0.28 topography=normal area=0.063 perim=1.14
MMPB1 Y B2 pndA VPB pfet_01v8_hvt m=4 w=1.0 l=0.15 mult=1 sa=0.265
+ sb=0.265 sd=0.28 topography=normal area=0.063 perim=1.14
MMNA0 Y A1 sndA1 VNB nfet_01v8 m=4 w=0.65 l=0.15 mult=1 sa=0.265
+ sb=0.265 sd=0.28 topography=normal area=0.063 perim=1.14
MMNA1 sndA1 A2 VGND VNB nfet_01v8 m=4 w=0.65 l=0.15 mult=1 sa=0.265
+ sb=0.265 sd=0.28 topography=normal area=0.063 perim=1.14
MMNB0 Y B1 sndB1 VNB nfet_01v8 m=4 w=0.65 l=0.15 mult=1 sa=0.265
+ sb=0.265 sd=0.28 topography=normal area=0.063 perim=1.14
MMNB1 sndB1 B2 VGND VNB nfet_01v8 m=4 w=0.65 l=0.15 mult=1 sa=0.265
+ sb=0.265 sd=0.28 topography=normal area=0.063 perim=1.14
.ENDS

.SUBCKT sky130_fd_sc_hd__a31o_1 A1 A2 A3 B1 VGND VNB VPB VPWR X
MMPA0 pndA A1 VPWR VPB pfet_01v8_hvt m=1 w=1.0 l=0.15 mult=1 sa=0.265
+ sb=0.265 sd=0.28 topography=normal area=0.063 perim=1.14
MMPA1 pndA A2 VPWR VPB pfet_01v8_hvt m=1 w=1.0 l=0.15 mult=1 sa=0.265
+ sb=0.265 sd=0.28 topography=normal area=0.063 perim=1.14
MMPA2 pndA A3 VPWR VPB pfet_01v8_hvt m=1 w=1.0 l=0.15 mult=1 sa=0.265
+ sb=0.265 sd=0.28 topography=normal area=0.063 perim=1.14
MMPB0 y B1 pndA VPB pfet_01v8_hvt m=1 w=1.0 l=0.15 mult=1 sa=0.265
+ sb=0.265 sd=0.28 topography=normal area=0.063 perim=1.14
MMIPX X y VPWR VPB pfet_01v8_hvt m=1 w=1.0 l=0.15 mult=1 sa=0.265
+ sb=0.265 sd=0.28 topography=normal area=0.063 perim=1.14
MMNA0 y A1 sndA1 VNB nfet_01v8 m=1 w=0.65 l=0.15 mult=1 sa=0.265
+ sb=0.265 sd=0.28 topography=normal area=0.063 perim=1.14
MMNA1 sndA1 A2 sndA2 VNB nfet_01v8 m=1 w=0.65 l=0.15 mult=1 sa=0.265
+ sb=0.265 sd=0.28 topography=normal area=0.063 perim=1.14
MMNA2 sndA2 A3 VGND VNB nfet_01v8 m=1 w=0.65 l=0.15 mult=1 sa=0.265
+ sb=0.265 sd=0.28 topography=normal area=0.063 perim=1.14
MMNB0 y B1 VGND VNB nfet_01v8 m=1 w=0.65 l=0.15 mult=1 sa=0.265
+ sb=0.265 sd=0.28 topography=normal area=0.063 perim=1.14
MMINX X y VGND VNB nfet_01v8 m=1 w=0.65 l=0.15 mult=1 sa=0.265
+ sb=0.265 sd=0.28 topography=normal area=0.063 perim=1.14
.ENDS

.SUBCKT sky130_fd_sc_hd__a31o_2 A1 A2 A3 B1 VGND VNB VPB VPWR X
MMPA0 pndA A1 VPWR VPB pfet_01v8_hvt m=1 w=1.0 l=0.15 mult=1 sa=0.265
+ sb=0.265 sd=0.28 topography=normal area=0.063 perim=1.14
MMPA1 pndA A2 VPWR VPB pfet_01v8_hvt m=1 w=1.0 l=0.15 mult=1 sa=0.265
+ sb=0.265 sd=0.28 topography=normal area=0.063 perim=1.14
MMPA2 pndA A3 VPWR VPB pfet_01v8_hvt m=1 w=1.0 l=0.15 mult=1 sa=0.265
+ sb=0.265 sd=0.28 topography=normal area=0.063 perim=1.14
MMPB0 y B1 pndA VPB pfet_01v8_hvt m=1 w=1.0 l=0.15 mult=1 sa=0.265
+ sb=0.265 sd=0.28 topography=normal area=0.063 perim=1.14
MMIPX X y VPWR VPB pfet_01v8_hvt m=2 w=1.0 l=0.15 mult=1 sa=0.265
+ sb=0.265 sd=0.28 topography=normal area=0.063 perim=1.14
MMNA0 y A1 sndA1 VNB nfet_01v8 m=1 w=0.65 l=0.15 mult=1 sa=0.265
+ sb=0.265 sd=0.28 topography=normal area=0.063 perim=1.14
MMNA1 sndA1 A2 sndA2 VNB nfet_01v8 m=1 w=0.65 l=0.15 mult=1 sa=0.265
+ sb=0.265 sd=0.28 topography=normal area=0.063 perim=1.14
MMNA2 sndA2 A3 VGND VNB nfet_01v8 m=1 w=0.65 l=0.15 mult=1 sa=0.265
+ sb=0.265 sd=0.28 topography=normal area=0.063 perim=1.14
MMNB0 y B1 VGND VNB nfet_01v8 m=1 w=0.65 l=0.15 mult=1 sa=0.265
+ sb=0.265 sd=0.28 topography=normal area=0.063 perim=1.14
MMINX X y VGND VNB nfet_01v8 m=2 w=0.65 l=0.15 mult=1 sa=0.265
+ sb=0.265 sd=0.28 topography=normal area=0.063 perim=1.14
.ENDS

.SUBCKT sky130_fd_sc_hd__a31o_4 A1 A2 A3 B1 VGND VNB VPB VPWR X
MMPA0 pndA A1 VPWR VPB pfet_01v8_hvt m=2 w=1.0 l=0.15 mult=1 sa=0.265
+ sb=0.265 sd=0.28 topography=normal area=0.063 perim=1.14
MMPA1 pndA A2 VPWR VPB pfet_01v8_hvt m=2 w=1.0 l=0.15 mult=1 sa=0.265
+ sb=0.265 sd=0.28 topography=normal area=0.063 perim=1.14
MMPA2 pndA A3 VPWR VPB pfet_01v8_hvt m=2 w=1.0 l=0.15 mult=1 sa=0.265
+ sb=0.265 sd=0.28 topography=normal area=0.063 perim=1.14
MMPB0 y B1 pndA VPB pfet_01v8_hvt m=2 w=1.0 l=0.15 mult=1 sa=0.265
+ sb=0.265 sd=0.28 topography=normal area=0.063 perim=1.14
MMIPX X y VPWR VPB pfet_01v8_hvt m=4 w=1.0 l=0.15 mult=1 sa=0.265
+ sb=0.265 sd=0.28 topography=normal area=0.063 perim=1.14
MMNA0 y A1 sndA1 VNB nfet_01v8 m=2 w=0.65 l=0.15 mult=1 sa=0.265
+ sb=0.265 sd=0.28 topography=normal area=0.063 perim=1.14
MMNA1 sndA1 A2 sndA2 VNB nfet_01v8 m=2 w=0.65 l=0.15 mult=1 sa=0.265
+ sb=0.265 sd=0.28 topography=normal area=0.063 perim=1.14
MMNA2 sndA2 A3 VGND VNB nfet_01v8 m=2 w=0.65 l=0.15 mult=1 sa=0.265
+ sb=0.265 sd=0.28 topography=normal area=0.063 perim=1.14
MMNB0 y B1 VGND VNB nfet_01v8 m=2 w=0.65 l=0.15 mult=1 sa=0.265
+ sb=0.265 sd=0.28 topography=normal area=0.063 perim=1.14
MMINX X y VGND VNB nfet_01v8 m=4 w=0.65 l=0.15 mult=1 sa=0.265
+ sb=0.265 sd=0.28 topography=normal area=0.063 perim=1.14
.ENDS

.SUBCKT sky130_fd_sc_hd__a31oi_1 A1 A2 A3 B1 VGND VNB VPB VPWR Y
MMPA0 pndA A1 VPWR VPB pfet_01v8_hvt m=1 w=1.0 l=0.15 mult=1 sa=0.265
+ sb=0.265 sd=0.28 topography=normal area=0.063 perim=1.14
MMPA1 pndA A2 VPWR VPB pfet_01v8_hvt m=1 w=1.0 l=0.15 mult=1 sa=0.265
+ sb=0.265 sd=0.28 topography=normal area=0.063 perim=1.14
MMPA2 pndA A3 VPWR VPB pfet_01v8_hvt m=1 w=1.0 l=0.15 mult=1 sa=0.265
+ sb=0.265 sd=0.28 topography=normal area=0.063 perim=1.14
MMPB0 Y B1 pndA VPB pfet_01v8_hvt m=1 w=1.0 l=0.15 mult=1 sa=0.265
+ sb=0.265 sd=0.28 topography=normal area=0.063 perim=1.14
MMNA0 Y A1 sndA1 VNB nfet_01v8 m=1 w=0.65 l=0.15 mult=1 sa=0.265
+ sb=0.265 sd=0.28 topography=normal area=0.063 perim=1.14
MMNA1 sndA1 A2 sndA2 VNB nfet_01v8 m=1 w=0.65 l=0.15 mult=1 sa=0.265
+ sb=0.265 sd=0.28 topography=normal area=0.063 perim=1.14
MMNA2 sndA2 A3 VGND VNB nfet_01v8 m=1 w=0.65 l=0.15 mult=1 sa=0.265
+ sb=0.265 sd=0.28 topography=normal area=0.063 perim=1.14
MMNB0 Y B1 VGND VNB nfet_01v8 m=1 w=0.65 l=0.15 mult=1 sa=0.265
+ sb=0.265 sd=0.28 topography=normal area=0.063 perim=1.14
.ENDS

.SUBCKT sky130_fd_sc_hd__a31oi_2 A1 A2 A3 B1 VGND VNB VPB VPWR Y
MMPA0 pndA A1 VPWR VPB pfet_01v8_hvt m=2 w=1.0 l=0.15 mult=1 sa=0.265
+ sb=0.265 sd=0.28 topography=normal area=0.063 perim=1.14
MMPA1 pndA A2 VPWR VPB pfet_01v8_hvt m=2 w=1.0 l=0.15 mult=1 sa=0.265
+ sb=0.265 sd=0.28 topography=normal area=0.063 perim=1.14
MMPA2 pndA A3 VPWR VPB pfet_01v8_hvt m=2 w=1.0 l=0.15 mult=1 sa=0.265
+ sb=0.265 sd=0.28 topography=normal area=0.063 perim=1.14
MMPB0 Y B1 pndA VPB pfet_01v8_hvt m=2 w=1.0 l=0.15 mult=1 sa=0.265
+ sb=0.265 sd=0.28 topography=normal area=0.063 perim=1.14
MMNA0 Y A1 sndA1 VNB nfet_01v8 m=2 w=0.65 l=0.15 mult=1 sa=0.265
+ sb=0.265 sd=0.28 topography=normal area=0.063 perim=1.14
MMNA1 sndA1 A2 sndA2 VNB nfet_01v8 m=2 w=0.65 l=0.15 mult=1 sa=0.265
+ sb=0.265 sd=0.28 topography=normal area=0.063 perim=1.14
MMNA2 sndA2 A3 VGND VNB nfet_01v8 m=2 w=0.65 l=0.15 mult=1 sa=0.265
+ sb=0.265 sd=0.28 topography=normal area=0.063 perim=1.14
MMNB0 Y B1 VGND VNB nfet_01v8 m=2 w=0.65 l=0.15 mult=1 sa=0.265
+ sb=0.265 sd=0.28 topography=normal area=0.063 perim=1.14
.ENDS

.SUBCKT sky130_fd_sc_hd__a31oi_4 A1 A2 A3 B1 VGND VNB VPB VPWR Y
MMPA0 pndA A1 VPWR VPB pfet_01v8_hvt m=4 w=1.0 l=0.15 mult=1 sa=0.265
+ sb=0.265 sd=0.28 topography=normal area=0.063 perim=1.14
MMPA1 pndA A2 VPWR VPB pfet_01v8_hvt m=4 w=1.0 l=0.15 mult=1 sa=0.265
+ sb=0.265 sd=0.28 topography=normal area=0.063 perim=1.14
MMPA2 pndA A3 VPWR VPB pfet_01v8_hvt m=4 w=1.0 l=0.15 mult=1 sa=0.265
+ sb=0.265 sd=0.28 topography=normal area=0.063 perim=1.14
MMPB0 Y B1 pndA VPB pfet_01v8_hvt m=4 w=1.0 l=0.15 mult=1 sa=0.265
+ sb=0.265 sd=0.28 topography=normal area=0.063 perim=1.14
MMNA0 Y A1 sndA1 VNB nfet_01v8 m=4 w=0.65 l=0.15 mult=1 sa=0.265
+ sb=0.265 sd=0.28 topography=normal area=0.063 perim=1.14
MMNA1 sndA1 A2 sndA2 VNB nfet_01v8 m=4 w=0.65 l=0.15 mult=1 sa=0.265
+ sb=0.265 sd=0.28 topography=normal area=0.063 perim=1.14
MMNA2 sndA2 A3 VGND VNB nfet_01v8 m=4 w=0.65 l=0.15 mult=1 sa=0.265
+ sb=0.265 sd=0.28 topography=normal area=0.063 perim=1.14
MMNB0 Y B1 VGND VNB nfet_01v8 m=4 w=0.65 l=0.15 mult=1 sa=0.265
+ sb=0.265 sd=0.28 topography=normal area=0.063 perim=1.14
.ENDS

.SUBCKT sky130_fd_sc_hd__a32o_1 A1 A2 A3 B1 B2 VGND VNB VPB VPWR X
MMPA0 pndA A1 VPWR VPB pfet_01v8_hvt m=1 w=1.0 l=0.15 mult=1 sa=0.265
+ sb=0.265 sd=0.28 topography=normal area=0.063 perim=1.14
MMPA1 pndA A2 VPWR VPB pfet_01v8_hvt m=1 w=1.0 l=0.15 mult=1 sa=0.265
+ sb=0.265 sd=0.28 topography=normal area=0.063 perim=1.14
MMPA2 pndA A3 VPWR VPB pfet_01v8_hvt m=1 w=1.0 l=0.15 mult=1 sa=0.265
+ sb=0.265 sd=0.28 topography=normal area=0.063 perim=1.14
MMPB0 y B1 pndA VPB pfet_01v8_hvt m=1 w=1.0 l=0.15 mult=1 sa=0.265
+ sb=0.265 sd=0.28 topography=normal area=0.063 perim=1.14
MMPB1 y B2 pndA VPB pfet_01v8_hvt m=1 w=1.0 l=0.15 mult=1 sa=0.265
+ sb=0.265 sd=0.28 topography=normal area=0.063 perim=1.14
MMIPX X y VPWR VPB pfet_01v8_hvt m=1 w=1.0 l=0.15 mult=1 sa=0.265
+ sb=0.265 sd=0.28 topography=normal area=0.063 perim=1.14
MMNA0 y A1 sndA1 VNB nfet_01v8 m=1 w=0.65 l=0.15 mult=1 sa=0.265
+ sb=0.265 sd=0.28 topography=normal area=0.063 perim=1.14
MMNA1 sndA1 A2 sndA2 VNB nfet_01v8 m=1 w=0.65 l=0.15 mult=1 sa=0.265
+ sb=0.265 sd=0.28 topography=normal area=0.063 perim=1.14
MMNA2 sndA2 A3 VGND VNB nfet_01v8 m=1 w=0.65 l=0.15 mult=1 sa=0.265
+ sb=0.265 sd=0.28 topography=normal area=0.063 perim=1.14
MMNB0 y B1 sndB1 VNB nfet_01v8 m=1 w=0.65 l=0.15 mult=1 sa=0.265
+ sb=0.265 sd=0.28 topography=normal area=0.063 perim=1.14
MMNB1 sndB1 B2 VGND VNB nfet_01v8 m=1 w=0.65 l=0.15 mult=1 sa=0.265
+ sb=0.265 sd=0.28 topography=normal area=0.063 perim=1.14
MMINX X y VGND VNB nfet_01v8 m=1 w=0.65 l=0.15 mult=1 sa=0.265
+ sb=0.265 sd=0.28 topography=normal area=0.063 perim=1.14
.ENDS

.SUBCKT sky130_fd_sc_hd__a32o_2 A1 A2 A3 B1 B2 VGND VNB VPB VPWR X
MMPA0 pndA A1 VPWR VPB pfet_01v8_hvt m=1 w=1.0 l=0.15 mult=1 sa=0.265
+ sb=0.265 sd=0.28 topography=normal area=0.063 perim=1.14
MMPA1 pndA A2 VPWR VPB pfet_01v8_hvt m=1 w=1.0 l=0.15 mult=1 sa=0.265
+ sb=0.265 sd=0.28 topography=normal area=0.063 perim=1.14
MMPA2 pndA A3 VPWR VPB pfet_01v8_hvt m=1 w=1.0 l=0.15 mult=1 sa=0.265
+ sb=0.265 sd=0.28 topography=normal area=0.063 perim=1.14
MMPB0 y B1 pndA VPB pfet_01v8_hvt m=1 w=1.0 l=0.15 mult=1 sa=0.265
+ sb=0.265 sd=0.28 topography=normal area=0.063 perim=1.14
MMPB1 y B2 pndA VPB pfet_01v8_hvt m=1 w=1.0 l=0.15 mult=1 sa=0.265
+ sb=0.265 sd=0.28 topography=normal area=0.063 perim=1.14
MMIPX X y VPWR VPB pfet_01v8_hvt m=2 w=1.0 l=0.15 mult=1 sa=0.265
+ sb=0.265 sd=0.28 topography=normal area=0.063 perim=1.14
MMNA0 y A1 sndA1 VNB nfet_01v8 m=1 w=0.65 l=0.15 mult=1 sa=0.265
+ sb=0.265 sd=0.28 topography=normal area=0.063 perim=1.14
MMNA1 sndA1 A2 sndA2 VNB nfet_01v8 m=1 w=0.65 l=0.15 mult=1 sa=0.265
+ sb=0.265 sd=0.28 topography=normal area=0.063 perim=1.14
MMNA2 sndA2 A3 VGND VNB nfet_01v8 m=1 w=0.65 l=0.15 mult=1 sa=0.265
+ sb=0.265 sd=0.28 topography=normal area=0.063 perim=1.14
MMNB0 y B1 sndB1 VNB nfet_01v8 m=1 w=0.65 l=0.15 mult=1 sa=0.265
+ sb=0.265 sd=0.28 topography=normal area=0.063 perim=1.14
MMNB1 sndB1 B2 VGND VNB nfet_01v8 m=1 w=0.65 l=0.15 mult=1 sa=0.265
+ sb=0.265 sd=0.28 topography=normal area=0.063 perim=1.14
MMINX X y VGND VNB nfet_01v8 m=2 w=0.65 l=0.15 mult=1 sa=0.265
+ sb=0.265 sd=0.28 topography=normal area=0.063 perim=1.14
.ENDS

.SUBCKT sky130_fd_sc_hd__a32o_4 A1 A2 A3 B1 B2 VGND VNB VPB VPWR X
MMPA0 pndA A1 VPWR VPB pfet_01v8_hvt m=2 w=1.0 l=0.15 mult=1 sa=0.265
+ sb=0.265 sd=0.28 topography=normal area=0.063 perim=1.14
MMPA1 pndA A2 VPWR VPB pfet_01v8_hvt m=2 w=1.0 l=0.15 mult=1 sa=0.265
+ sb=0.265 sd=0.28 topography=normal area=0.063 perim=1.14
MMPA2 pndA A3 VPWR VPB pfet_01v8_hvt m=2 w=1.0 l=0.15 mult=1 sa=0.265
+ sb=0.265 sd=0.28 topography=normal area=0.063 perim=1.14
MMPB0 y B1 pndA VPB pfet_01v8_hvt m=2 w=1.0 l=0.15 mult=1 sa=0.265
+ sb=0.265 sd=0.28 topography=normal area=0.063 perim=1.14
MMPB1 y B2 pndA VPB pfet_01v8_hvt m=2 w=1.0 l=0.15 mult=1 sa=0.265
+ sb=0.265 sd=0.28 topography=normal area=0.063 perim=1.14
MMIPX X y VPWR VPB pfet_01v8_hvt m=4 w=1.0 l=0.15 mult=1 sa=0.265
+ sb=0.265 sd=0.28 topography=normal area=0.063 perim=1.14
MMNA0 y A1 sndA1 VNB nfet_01v8 m=2 w=0.65 l=0.15 mult=1 sa=0.265
+ sb=0.265 sd=0.28 topography=normal area=0.063 perim=1.14
MMNA1 sndA1 A2 sndA2 VNB nfet_01v8 m=2 w=0.65 l=0.15 mult=1 sa=0.265
+ sb=0.265 sd=0.28 topography=normal area=0.063 perim=1.14
MMNA2 sndA2 A3 VGND VNB nfet_01v8 m=2 w=0.65 l=0.15 mult=1 sa=0.265
+ sb=0.265 sd=0.28 topography=normal area=0.063 perim=1.14
MMNB0 y B1 sndB1 VNB nfet_01v8 m=2 w=0.65 l=0.15 mult=1 sa=0.265
+ sb=0.265 sd=0.28 topography=normal area=0.063 perim=1.14
MMNB1 sndB1 B2 VGND VNB nfet_01v8 m=2 w=0.65 l=0.15 mult=1 sa=0.265
+ sb=0.265 sd=0.28 topography=normal area=0.063 perim=1.14
MMINX X y VGND VNB nfet_01v8 m=4 w=0.65 l=0.15 mult=1 sa=0.265
+ sb=0.265 sd=0.28 topography=normal area=0.063 perim=1.14
.ENDS

.SUBCKT sky130_fd_sc_hd__a32oi_1 A1 A2 A3 B1 B2 VGND VNB VPB VPWR Y
MMPA0 pndA A1 VPWR VPB pfet_01v8_hvt m=1 w=1.0 l=0.15 mult=1 sa=0.265
+ sb=0.265 sd=0.28 topography=normal area=0.063 perim=1.14
MMPA1 pndA A2 VPWR VPB pfet_01v8_hvt m=1 w=1.0 l=0.15 mult=1 sa=0.265
+ sb=0.265 sd=0.28 topography=normal area=0.063 perim=1.14
MMPA2 pndA A3 VPWR VPB pfet_01v8_hvt m=1 w=1.0 l=0.15 mult=1 sa=0.265
+ sb=0.265 sd=0.28 topography=normal area=0.063 perim=1.14
MMPB0 Y B1 pndA VPB pfet_01v8_hvt m=1 w=1.0 l=0.15 mult=1 sa=0.265
+ sb=0.265 sd=0.28 topography=normal area=0.063 perim=1.14
MMPB1 Y B2 pndA VPB pfet_01v8_hvt m=1 w=1.0 l=0.15 mult=1 sa=0.265
+ sb=0.265 sd=0.28 topography=normal area=0.063 perim=1.14
MMNA0 Y A1 sndA1 VNB nfet_01v8 m=1 w=0.65 l=0.15 mult=1 sa=0.265
+ sb=0.265 sd=0.28 topography=normal area=0.063 perim=1.14
MMNA1 sndA1 A2 sndA2 VNB nfet_01v8 m=1 w=0.65 l=0.15 mult=1 sa=0.265
+ sb=0.265 sd=0.28 topography=normal area=0.063 perim=1.14
MMNA2 sndA2 A3 VGND VNB nfet_01v8 m=1 w=0.65 l=0.15 mult=1 sa=0.265
+ sb=0.265 sd=0.28 topography=normal area=0.063 perim=1.14
MMNB0 Y B1 sndB1 VNB nfet_01v8 m=1 w=0.65 l=0.15 mult=1 sa=0.265
+ sb=0.265 sd=0.28 topography=normal area=0.063 perim=1.14
MMNB1 sndB1 B2 VGND VNB nfet_01v8 m=1 w=0.65 l=0.15 mult=1 sa=0.265
+ sb=0.265 sd=0.28 topography=normal area=0.063 perim=1.14
.ENDS

.SUBCKT sky130_fd_sc_hd__a32oi_2 A1 A2 A3 B1 B2 VGND VNB VPB VPWR Y
MMPA0 pndA A1 VPWR VPB pfet_01v8_hvt m=2 w=1.0 l=0.15 mult=1 sa=0.265
+ sb=0.265 sd=0.28 topography=normal area=0.063 perim=1.14
MMPA1 pndA A2 VPWR VPB pfet_01v8_hvt m=2 w=1.0 l=0.15 mult=1 sa=0.265
+ sb=0.265 sd=0.28 topography=normal area=0.063 perim=1.14
MMPA2 pndA A3 VPWR VPB pfet_01v8_hvt m=2 w=1.0 l=0.15 mult=1 sa=0.265
+ sb=0.265 sd=0.28 topography=normal area=0.063 perim=1.14
MMPB0 Y B1 pndA VPB pfet_01v8_hvt m=2 w=1.0 l=0.15 mult=1 sa=0.265
+ sb=0.265 sd=0.28 topography=normal area=0.063 perim=1.14
MMPB1 Y B2 pndA VPB pfet_01v8_hvt m=2 w=1.0 l=0.15 mult=1 sa=0.265
+ sb=0.265 sd=0.28 topography=normal area=0.063 perim=1.14
MMNA0 Y A1 sndA1 VNB nfet_01v8 m=2 w=0.65 l=0.15 mult=1 sa=0.265
+ sb=0.265 sd=0.28 topography=normal area=0.063 perim=1.14
MMNA1 sndA1 A2 sndA2 VNB nfet_01v8 m=2 w=0.65 l=0.15 mult=1 sa=0.265
+ sb=0.265 sd=0.28 topography=normal area=0.063 perim=1.14
MMNA2 sndA2 A3 VGND VNB nfet_01v8 m=2 w=0.65 l=0.15 mult=1 sa=0.265
+ sb=0.265 sd=0.28 topography=normal area=0.063 perim=1.14
MMNB0 Y B1 sndB1 VNB nfet_01v8 m=2 w=0.65 l=0.15 mult=1 sa=0.265
+ sb=0.265 sd=0.28 topography=normal area=0.063 perim=1.14
MMNB1 sndB1 B2 VGND VNB nfet_01v8 m=2 w=0.65 l=0.15 mult=1 sa=0.265
+ sb=0.265 sd=0.28 topography=normal area=0.063 perim=1.14
.ENDS

.SUBCKT sky130_fd_sc_hd__a32oi_4 A1 A2 A3 B1 B2 VGND VNB VPB VPWR Y
MMPA0 pndA A1 VPWR VPB pfet_01v8_hvt m=4 w=1.0 l=0.15 mult=1 sa=0.265
+ sb=0.265 sd=0.28 topography=normal area=0.063 perim=1.14
MMPA1 pndA A2 VPWR VPB pfet_01v8_hvt m=4 w=1.0 l=0.15 mult=1 sa=0.265
+ sb=0.265 sd=0.28 topography=normal area=0.063 perim=1.14
MMPA2 pndA A3 VPWR VPB pfet_01v8_hvt m=4 w=1.0 l=0.15 mult=1 sa=0.265
+ sb=0.265 sd=0.28 topography=normal area=0.063 perim=1.14
MMPB0 Y B1 pndA VPB pfet_01v8_hvt m=4 w=1.0 l=0.15 mult=1 sa=0.265
+ sb=0.265 sd=0.28 topography=normal area=0.063 perim=1.14
MMPB1 Y B2 pndA VPB pfet_01v8_hvt m=4 w=1.0 l=0.15 mult=1 sa=0.265
+ sb=0.265 sd=0.28 topography=normal area=0.063 perim=1.14
MMNA0 Y A1 sndA1 VNB nfet_01v8 m=4 w=0.65 l=0.15 mult=1 sa=0.265
+ sb=0.265 sd=0.28 topography=normal area=0.063 perim=1.14
MMNA1 sndA1 A2 sndA2 VNB nfet_01v8 m=4 w=0.65 l=0.15 mult=1 sa=0.265
+ sb=0.265 sd=0.28 topography=normal area=0.063 perim=1.14
MMNA2 sndA2 A3 VGND VNB nfet_01v8 m=4 w=0.65 l=0.15 mult=1 sa=0.265
+ sb=0.265 sd=0.28 topography=normal area=0.063 perim=1.14
MMNB0 Y B1 sndB1 VNB nfet_01v8 m=4 w=0.65 l=0.15 mult=1 sa=0.265
+ sb=0.265 sd=0.28 topography=normal area=0.063 perim=1.14
MMNB1 sndB1 B2 VGND VNB nfet_01v8 m=4 w=0.65 l=0.15 mult=1 sa=0.265
+ sb=0.265 sd=0.28 topography=normal area=0.063 perim=1.14
.ENDS

.SUBCKT sky130_fd_sc_hd__a41o_1 A1 A2 A3 A4 B1 VGND VNB VPB VPWR X
MMPA0 pndA A1 VPWR VPB pfet_01v8_hvt m=1 w=1.0 l=0.15 mult=1 sa=0.265
+ sb=0.265 sd=0.28 topography=normal area=0.063 perim=1.14
MMPA1 pndA A2 VPWR VPB pfet_01v8_hvt m=1 w=1.0 l=0.15 mult=1 sa=0.265
+ sb=0.265 sd=0.28 topography=normal area=0.063 perim=1.14
MMPA2 pndA A3 VPWR VPB pfet_01v8_hvt m=1 w=1.0 l=0.15 mult=1 sa=0.265
+ sb=0.265 sd=0.28 topography=normal area=0.063 perim=1.14
MMPA3 pndA A4 VPWR VPB pfet_01v8_hvt m=1 w=1.0 l=0.15 mult=1 sa=0.265
+ sb=0.265 sd=0.28 topography=normal area=0.063 perim=1.14
MMPB0 y B1 pndA VPB pfet_01v8_hvt m=1 w=1.0 l=0.15 mult=1 sa=0.265
+ sb=0.265 sd=0.28 topography=normal area=0.063 perim=1.14
MMIPX X y VPWR VPB pfet_01v8_hvt m=1 w=1.0 l=0.15 mult=1 sa=0.265
+ sb=0.265 sd=0.28 topography=normal area=0.063 perim=1.14
MMNA0 y A1 sndA1 VNB nfet_01v8 m=1 w=0.65 l=0.15 mult=1 sa=0.265
+ sb=0.265 sd=0.28 topography=normal area=0.063 perim=1.14
MMNA1 sndA1 A2 sndA2 VNB nfet_01v8 m=1 w=0.65 l=0.15 mult=1 sa=0.265
+ sb=0.265 sd=0.28 topography=normal area=0.063 perim=1.14
MMNA2 sndA2 A3 sndA3 VNB nfet_01v8 m=1 w=0.65 l=0.15 mult=1 sa=0.265
+ sb=0.265 sd=0.28 topography=normal area=0.063 perim=1.14
MMNA3 sndA3 A4 VGND VNB nfet_01v8 m=1 w=0.65 l=0.15 mult=1 sa=0.265
+ sb=0.265 sd=0.28 topography=normal area=0.063 perim=1.14
MMNB0 y B1 VGND VNB nfet_01v8 m=1 w=0.65 l=0.15 mult=1 sa=0.265
+ sb=0.265 sd=0.28 topography=normal area=0.063 perim=1.14
MMINX X y VGND VNB nfet_01v8 m=1 w=0.65 l=0.15 mult=1 sa=0.265
+ sb=0.265 sd=0.28 topography=normal area=0.063 perim=1.14
.ENDS

.SUBCKT sky130_fd_sc_hd__a41o_2 A1 A2 A3 A4 B1 VGND VNB VPB VPWR X
MMPA0 pndA A1 VPWR VPB pfet_01v8_hvt m=1 w=1.0 l=0.15 mult=1 sa=0.265
+ sb=0.265 sd=0.28 topography=normal area=0.063 perim=1.14
MMPA1 pndA A2 VPWR VPB pfet_01v8_hvt m=1 w=1.0 l=0.15 mult=1 sa=0.265
+ sb=0.265 sd=0.28 topography=normal area=0.063 perim=1.14
MMPA2 pndA A3 VPWR VPB pfet_01v8_hvt m=1 w=1.0 l=0.15 mult=1 sa=0.265
+ sb=0.265 sd=0.28 topography=normal area=0.063 perim=1.14
MMPA3 pndA A4 VPWR VPB pfet_01v8_hvt m=1 w=1.0 l=0.15 mult=1 sa=0.265
+ sb=0.265 sd=0.28 topography=normal area=0.063 perim=1.14
MMPB0 y B1 pndA VPB pfet_01v8_hvt m=1 w=1.0 l=0.15 mult=1 sa=0.265
+ sb=0.265 sd=0.28 topography=normal area=0.063 perim=1.14
MMIPX X y VPWR VPB pfet_01v8_hvt m=2 w=1.0 l=0.15 mult=1 sa=0.265
+ sb=0.265 sd=0.28 topography=normal area=0.063 perim=1.14
MMNA0 y A1 sndA1 VNB nfet_01v8 m=1 w=0.65 l=0.15 mult=1 sa=0.265
+ sb=0.265 sd=0.28 topography=normal area=0.063 perim=1.14
MMNA1 sndA1 A2 sndA2 VNB nfet_01v8 m=1 w=0.65 l=0.15 mult=1 sa=0.265
+ sb=0.265 sd=0.28 topography=normal area=0.063 perim=1.14
MMNA2 sndA2 A3 sndA3 VNB nfet_01v8 m=1 w=0.65 l=0.15 mult=1 sa=0.265
+ sb=0.265 sd=0.28 topography=normal area=0.063 perim=1.14
MMNA3 sndA3 A4 VGND VNB nfet_01v8 m=1 w=0.65 l=0.15 mult=1 sa=0.265
+ sb=0.265 sd=0.28 topography=normal area=0.063 perim=1.14
MMNB0 y B1 VGND VNB nfet_01v8 m=1 w=0.65 l=0.15 mult=1 sa=0.265
+ sb=0.265 sd=0.28 topography=normal area=0.063 perim=1.14
MMINX X y VGND VNB nfet_01v8 m=2 w=0.65 l=0.15 mult=1 sa=0.265
+ sb=0.265 sd=0.28 topography=normal area=0.063 perim=1.14
.ENDS

.SUBCKT sky130_fd_sc_hd__a41o_4 A1 A2 A3 A4 B1 VGND VNB VPB VPWR X
MMPA0 pndA A1 VPWR VPB pfet_01v8_hvt m=2 w=1.0 l=0.15 mult=1 sa=0.265
+ sb=0.265 sd=0.28 topography=normal area=0.063 perim=1.14
MMPA1 pndA A2 VPWR VPB pfet_01v8_hvt m=2 w=1.0 l=0.15 mult=1 sa=0.265
+ sb=0.265 sd=0.28 topography=normal area=0.063 perim=1.14
MMPA2 pndA A3 VPWR VPB pfet_01v8_hvt m=2 w=1.0 l=0.15 mult=1 sa=0.265
+ sb=0.265 sd=0.28 topography=normal area=0.063 perim=1.14
MMPA3 pndA A4 VPWR VPB pfet_01v8_hvt m=2 w=1.0 l=0.15 mult=1 sa=0.265
+ sb=0.265 sd=0.28 topography=normal area=0.063 perim=1.14
MMPB0 y B1 pndA VPB pfet_01v8_hvt m=2 w=1.0 l=0.15 mult=1 sa=0.265
+ sb=0.265 sd=0.28 topography=normal area=0.063 perim=1.14
MMIPX X y VPWR VPB pfet_01v8_hvt m=4 w=1.0 l=0.15 mult=1 sa=0.265
+ sb=0.265 sd=0.28 topography=normal area=0.063 perim=1.14
MMNA0 y A1 sndA1 VNB nfet_01v8 m=2 w=0.65 l=0.15 mult=1 sa=0.265
+ sb=0.265 sd=0.28 topography=normal area=0.063 perim=1.14
MMNA1 sndA1 A2 sndA2 VNB nfet_01v8 m=2 w=0.65 l=0.15 mult=1 sa=0.265
+ sb=0.265 sd=0.28 topography=normal area=0.063 perim=1.14
MMNA2 sndA2 A3 sndA3 VNB nfet_01v8 m=2 w=0.65 l=0.15 mult=1 sa=0.265
+ sb=0.265 sd=0.28 topography=normal area=0.063 perim=1.14
MMNA3 sndA3 A4 VGND VNB nfet_01v8 m=2 w=0.65 l=0.15 mult=1 sa=0.265
+ sb=0.265 sd=0.28 topography=normal area=0.063 perim=1.14
MMNB0 y B1 VGND VNB nfet_01v8 m=2 w=0.65 l=0.15 mult=1 sa=0.265
+ sb=0.265 sd=0.28 topography=normal area=0.063 perim=1.14
MMINX X y VGND VNB nfet_01v8 m=4 w=0.65 l=0.15 mult=1 sa=0.265
+ sb=0.265 sd=0.28 topography=normal area=0.063 perim=1.14
.ENDS

.SUBCKT sky130_fd_sc_hd__a41oi_1 A1 A2 A3 A4 B1 VGND VNB VPB VPWR Y
MMPA0 pndA A1 VPWR VPB pfet_01v8_hvt m=1 w=1.0 l=0.15 mult=1 sa=0.265
+ sb=0.265 sd=0.28 topography=normal area=0.063 perim=1.14
MMPA1 pndA A2 VPWR VPB pfet_01v8_hvt m=1 w=1.0 l=0.15 mult=1 sa=0.265
+ sb=0.265 sd=0.28 topography=normal area=0.063 perim=1.14
MMPA2 pndA A3 VPWR VPB pfet_01v8_hvt m=1 w=1.0 l=0.15 mult=1 sa=0.265
+ sb=0.265 sd=0.28 topography=normal area=0.063 perim=1.14
MMPA3 pndA A4 VPWR VPB pfet_01v8_hvt m=1 w=1.0 l=0.15 mult=1 sa=0.265
+ sb=0.265 sd=0.28 topography=normal area=0.063 perim=1.14
MMPB0 Y B1 pndA VPB pfet_01v8_hvt m=1 w=1.0 l=0.15 mult=1 sa=0.265
+ sb=0.265 sd=0.28 topography=normal area=0.063 perim=1.14
MMNA0 Y A1 sndA1 VNB nfet_01v8 m=1 w=0.65 l=0.15 mult=1 sa=0.265
+ sb=0.265 sd=0.28 topography=normal area=0.063 perim=1.14
MMNA1 sndA1 A2 sndA2 VNB nfet_01v8 m=1 w=0.65 l=0.15 mult=1 sa=0.265
+ sb=0.265 sd=0.28 topography=normal area=0.063 perim=1.14
MMNA2 sndA2 A3 sndA3 VNB nfet_01v8 m=1 w=0.65 l=0.15 mult=1 sa=0.265
+ sb=0.265 sd=0.28 topography=normal area=0.063 perim=1.14
MMNA3 sndA3 A4 VGND VNB nfet_01v8 m=1 w=0.65 l=0.15 mult=1 sa=0.265
+ sb=0.265 sd=0.28 topography=normal area=0.063 perim=1.14
MMNB0 Y B1 VGND VNB nfet_01v8 m=1 w=0.65 l=0.15 mult=1 sa=0.265
+ sb=0.265 sd=0.28 topography=normal area=0.063 perim=1.14
.ENDS

.SUBCKT sky130_fd_sc_hd__a41oi_2 A1 A2 A3 A4 B1 VGND VNB VPB VPWR Y
MMPA0 pndA A1 VPWR VPB pfet_01v8_hvt m=2 w=1.0 l=0.15 mult=1 sa=0.265
+ sb=0.265 sd=0.28 topography=normal area=0.063 perim=1.14
MMPA1 pndA A2 VPWR VPB pfet_01v8_hvt m=2 w=1.0 l=0.15 mult=1 sa=0.265
+ sb=0.265 sd=0.28 topography=normal area=0.063 perim=1.14
MMPA2 pndA A3 VPWR VPB pfet_01v8_hvt m=2 w=1.0 l=0.15 mult=1 sa=0.265
+ sb=0.265 sd=0.28 topography=normal area=0.063 perim=1.14
MMPA3 pndA A4 VPWR VPB pfet_01v8_hvt m=2 w=1.0 l=0.15 mult=1 sa=0.265
+ sb=0.265 sd=0.28 topography=normal area=0.063 perim=1.14
MMPB0 Y B1 pndA VPB pfet_01v8_hvt m=2 w=1.0 l=0.15 mult=1 sa=0.265
+ sb=0.265 sd=0.28 topography=normal area=0.063 perim=1.14
MMNA0 Y A1 sndA1 VNB nfet_01v8 m=2 w=0.65 l=0.15 mult=1 sa=0.265
+ sb=0.265 sd=0.28 topography=normal area=0.063 perim=1.14
MMNA1 sndA1 A2 sndA2 VNB nfet_01v8 m=2 w=0.65 l=0.15 mult=1 sa=0.265
+ sb=0.265 sd=0.28 topography=normal area=0.063 perim=1.14
MMNA2 sndA2 A3 sndA3 VNB nfet_01v8 m=2 w=0.65 l=0.15 mult=1 sa=0.265
+ sb=0.265 sd=0.28 topography=normal area=0.063 perim=1.14
MMNA3 sndA3 A4 VGND VNB nfet_01v8 m=2 w=0.65 l=0.15 mult=1 sa=0.265
+ sb=0.265 sd=0.28 topography=normal area=0.063 perim=1.14
MMNB0 Y B1 VGND VNB nfet_01v8 m=2 w=0.65 l=0.15 mult=1 sa=0.265
+ sb=0.265 sd=0.28 topography=normal area=0.063 perim=1.14
.ENDS

.SUBCKT sky130_fd_sc_hd__a41oi_4 A1 A2 A3 A4 B1 VGND VNB VPB VPWR Y
MMPA0 pndA A1 VPWR VPB pfet_01v8_hvt m=4 w=1.0 l=0.15 mult=1 sa=0.265
+ sb=0.265 sd=0.28 topography=normal area=0.063 perim=1.14
MMPA1 pndA A2 VPWR VPB pfet_01v8_hvt m=4 w=1.0 l=0.15 mult=1 sa=0.265
+ sb=0.265 sd=0.28 topography=normal area=0.063 perim=1.14
MMPA2 pndA A3 VPWR VPB pfet_01v8_hvt m=4 w=1.0 l=0.15 mult=1 sa=0.265
+ sb=0.265 sd=0.28 topography=normal area=0.063 perim=1.14
MMPA3 pndA A4 VPWR VPB pfet_01v8_hvt m=4 w=1.0 l=0.15 mult=1 sa=0.265
+ sb=0.265 sd=0.28 topography=normal area=0.063 perim=1.14
MMPB0 Y B1 pndA VPB pfet_01v8_hvt m=4 w=1.0 l=0.15 mult=1 sa=0.265
+ sb=0.265 sd=0.28 topography=normal area=0.063 perim=1.14
MMNA0 Y A1 sndA1 VNB nfet_01v8 m=4 w=0.65 l=0.15 mult=1 sa=0.265
+ sb=0.265 sd=0.28 topography=normal area=0.063 perim=1.14
MMNA1 sndA1 A2 sndA2 VNB nfet_01v8 m=4 w=0.65 l=0.15 mult=1 sa=0.265
+ sb=0.265 sd=0.28 topography=normal area=0.063 perim=1.14
MMNA2 sndA2 A3 sndA3 VNB nfet_01v8 m=4 w=0.65 l=0.15 mult=1 sa=0.265
+ sb=0.265 sd=0.28 topography=normal area=0.063 perim=1.14
MMNA3 sndA3 A4 VGND VNB nfet_01v8 m=4 w=0.65 l=0.15 mult=1 sa=0.265
+ sb=0.265 sd=0.28 topography=normal area=0.063 perim=1.14
MMNB0 Y B1 VGND VNB nfet_01v8 m=4 w=0.65 l=0.15 mult=1 sa=0.265
+ sb=0.265 sd=0.28 topography=normal area=0.063 perim=1.14
.ENDS

.SUBCKT sky130_fd_sc_hd__a211o_1 A1 A2 B1 C1 VGND VNB VPB VPWR X
MMPA0 pndA A1 VPWR VPB pfet_01v8_hvt m=1 w=1.0 l=0.15 mult=1 sa=0.265
+ sb=0.265 sd=0.28 topography=normal area=0.063 perim=1.14
MMPA1 pndA A2 VPWR VPB pfet_01v8_hvt m=1 w=1.0 l=0.15 mult=1 sa=0.265
+ sb=0.265 sd=0.28 topography=normal area=0.063 perim=1.14
MMPB0 pndB B1 pndA VPB pfet_01v8_hvt m=1 w=1.0 l=0.15 mult=1 sa=0.265
+ sb=0.265 sd=0.28 topography=normal area=0.063 perim=1.14
MMPC0 y C1 pndB VPB pfet_01v8_hvt m=1 w=1.0 l=0.15 mult=1 sa=0.265
+ sb=0.265 sd=0.28 topography=normal area=0.063 perim=1.14
MMIPX X y VPWR VPB pfet_01v8_hvt m=1 w=1.0 l=0.15 mult=1 sa=0.265
+ sb=0.265 sd=0.28 topography=normal area=0.063 perim=1.14
MMNA0 y A1 sndA1 VNB nfet_01v8 m=1 w=0.65 l=0.15 mult=1 sa=0.265
+ sb=0.265 sd=0.28 topography=normal area=0.063 perim=1.14
MMNA1 sndA1 A2 VGND VNB nfet_01v8 m=1 w=0.65 l=0.15 mult=1 sa=0.265
+ sb=0.265 sd=0.28 topography=normal area=0.063 perim=1.14
MMNB0 y B1 VGND VNB nfet_01v8 m=1 w=0.65 l=0.15 mult=1 sa=0.265
+ sb=0.265 sd=0.28 topography=normal area=0.063 perim=1.14
MMNC0 y C1 VGND VNB nfet_01v8 m=1 w=0.65 l=0.15 mult=1 sa=0.265
+ sb=0.265 sd=0.28 topography=normal area=0.063 perim=1.14
MMINX X y VGND VNB nfet_01v8 m=1 w=0.65 l=0.15 mult=1 sa=0.265
+ sb=0.265 sd=0.28 topography=normal area=0.063 perim=1.14
.ENDS

.SUBCKT sky130_fd_sc_hd__a211o_2 A1 A2 B1 C1 VGND VNB VPB VPWR X
MMPA0 pndA A1 VPWR VPB pfet_01v8_hvt m=1 w=1.0 l=0.15 mult=1 sa=0.265
+ sb=0.265 sd=0.28 topography=normal area=0.063 perim=1.14
MMPA1 pndA A2 VPWR VPB pfet_01v8_hvt m=1 w=1.0 l=0.15 mult=1 sa=0.265
+ sb=0.265 sd=0.28 topography=normal area=0.063 perim=1.14
MMPB0 pndB B1 pndA VPB pfet_01v8_hvt m=1 w=1.0 l=0.15 mult=1 sa=0.265
+ sb=0.265 sd=0.28 topography=normal area=0.063 perim=1.14
MMPC0 y C1 pndB VPB pfet_01v8_hvt m=1 w=1.0 l=0.15 mult=1 sa=0.265
+ sb=0.265 sd=0.28 topography=normal area=0.063 perim=1.14
MMIPX X y VPWR VPB pfet_01v8_hvt m=2 w=1.0 l=0.15 mult=1 sa=0.265
+ sb=0.265 sd=0.28 topography=normal area=0.063 perim=1.14
MMNA0 y A1 sndA1 VNB nfet_01v8 m=1 w=0.65 l=0.15 mult=1 sa=0.265
+ sb=0.265 sd=0.28 topography=normal area=0.063 perim=1.14
MMNA1 sndA1 A2 VGND VNB nfet_01v8 m=1 w=0.65 l=0.15 mult=1 sa=0.265
+ sb=0.265 sd=0.28 topography=normal area=0.063 perim=1.14
MMNB0 y B1 VGND VNB nfet_01v8 m=1 w=0.65 l=0.15 mult=1 sa=0.265
+ sb=0.265 sd=0.28 topography=normal area=0.063 perim=1.14
MMNC0 y C1 VGND VNB nfet_01v8 m=1 w=0.65 l=0.15 mult=1 sa=0.265
+ sb=0.265 sd=0.28 topography=normal area=0.063 perim=1.14
MMINX X y VGND VNB nfet_01v8 m=2 w=0.65 l=0.15 mult=1 sa=0.265
+ sb=0.265 sd=0.28 topography=normal area=0.063 perim=1.14
.ENDS

.SUBCKT sky130_fd_sc_hd__a211o_4 A1 A2 B1 C1 VGND VNB VPB VPWR X
MMPA0 pndA A1 VPWR VPB pfet_01v8_hvt m=2 w=1.0 l=0.15 mult=1 sa=0.265
+ sb=0.265 sd=0.28 topography=normal area=0.063 perim=1.14
MMPA1 pndA A2 VPWR VPB pfet_01v8_hvt m=2 w=1.0 l=0.15 mult=1 sa=0.265
+ sb=0.265 sd=0.28 topography=normal area=0.063 perim=1.14
MMPB0 pndB B1 pndA VPB pfet_01v8_hvt w=1.0 l=0.15 mult=1 sa=0.265
+ sb=0.265 sd=0.28 topography=normal area=0.063 perim=1.14
MMPB20 pnd2B B1 pndA VPB pfet_01v8_hvt w=1.0 l=0.15 mult=1 sa=0.265
+ sb=0.265 sd=0.28 topography=normal area=0.063 perim=1.14
MMPC0 y C1 pndB VPB pfet_01v8_hvt w=1.0 l=0.15 mult=1 sa=0.265
+ sb=0.265 sd=0.28 topography=normal area=0.063 perim=1.14
MMPC20 y C1 pnd2B VPB pfet_01v8_hvt w=1.0 l=0.15 mult=1 sa=0.265
+ sb=0.265 sd=0.28 topography=normal area=0.063 perim=1.14
MMIPX X y VPWR VPB pfet_01v8_hvt m=4 w=1.0 l=0.15 mult=1 sa=0.265
+ sb=0.265 sd=0.28 topography=normal area=0.063 perim=1.14
MMNA0 y A1 sndA1 VNB nfet_01v8 w=0.65 l=0.15 mult=1 sa=0.265
+ sb=0.265 sd=0.28 topography=normal area=0.063 perim=1.14
MMNA20 y A1 snd2A1 VNB nfet_01v8 w=0.65 l=0.15 mult=1 sa=0.265
+ sb=0.265 sd=0.28 topography=normal area=0.063 perim=1.14
MMNA1 sndA1 A2 VGND VNB nfet_01v8 w=0.65 l=0.15 mult=1 sa=0.265
+ sb=0.265 sd=0.28 topography=normal area=0.063 perim=1.14
MMNA21 snd2A1 A2 VGND VNB nfet_01v8 w=0.65 l=0.15 mult=1 sa=0.265
+ sb=0.265 sd=0.28 topography=normal area=0.063 perim=1.14
MMNB0 y B1 VGND VNB nfet_01v8 m=2 w=0.65 l=0.15 mult=1 sa=0.265
+ sb=0.265 sd=0.28 topography=normal area=0.063 perim=1.14
MMNC0 y C1 VGND VNB nfet_01v8 m=2 w=0.65 l=0.15 mult=1 sa=0.265
+ sb=0.265 sd=0.28 topography=normal area=0.063 perim=1.14
MMINX X y VGND VNB nfet_01v8 m=4 w=0.65 l=0.15 mult=1 sa=0.265
+ sb=0.265 sd=0.28 topography=normal area=0.063 perim=1.14
.ENDS

.SUBCKT sky130_fd_sc_hd__a211oi_1 A1 A2 B1 C1 VGND VNB VPB VPWR Y
MMPA0 pndA A1 VPWR VPB pfet_01v8_hvt m=1 w=1.0 l=0.15 mult=1 sa=0.265
+ sb=0.265 sd=0.28 topography=normal area=0.063 perim=1.14
MMPA1 pndA A2 VPWR VPB pfet_01v8_hvt m=1 w=1.0 l=0.15 mult=1 sa=0.265
+ sb=0.265 sd=0.28 topography=normal area=0.063 perim=1.14
MMPB0 pndB B1 pndA VPB pfet_01v8_hvt m=1 w=1.0 l=0.15 mult=1 sa=0.265
+ sb=0.265 sd=0.28 topography=normal area=0.063 perim=1.14
MMPC0 Y C1 pndB VPB pfet_01v8_hvt m=1 w=1.0 l=0.15 mult=1 sa=0.265
+ sb=0.265 sd=0.28 topography=normal area=0.063 perim=1.14
MMNA0 Y A1 sndA1 VNB nfet_01v8 m=1 w=0.65 l=0.15 mult=1 sa=0.265
+ sb=0.265 sd=0.28 topography=normal area=0.063 perim=1.14
MMNA1 sndA1 A2 VGND VNB nfet_01v8 m=1 w=0.65 l=0.15 mult=1 sa=0.265
+ sb=0.265 sd=0.28 topography=normal area=0.063 perim=1.14
MMNB0 Y B1 VGND VNB nfet_01v8 m=1 w=0.65 l=0.15 mult=1 sa=0.265
+ sb=0.265 sd=0.28 topography=normal area=0.063 perim=1.14
MMNC0 Y C1 VGND VNB nfet_01v8 m=1 w=0.65 l=0.15 mult=1 sa=0.265
+ sb=0.265 sd=0.28 topography=normal area=0.063 perim=1.14
.ENDS

.SUBCKT sky130_fd_sc_hd__a211oi_2 A1 A2 B1 C1 VGND VNB VPB VPWR Y
MMPA0 pndA A1 VPWR VPB pfet_01v8_hvt m=2 w=1.0 l=0.15 mult=1 sa=0.265
+ sb=0.265 sd=0.28 topography=normal area=0.063 perim=1.14
MMPA1 pndA A2 VPWR VPB pfet_01v8_hvt m=2 w=1.0 l=0.15 mult=1 sa=0.265
+ sb=0.265 sd=0.28 topography=normal area=0.063 perim=1.14
MMPB0 pndB B1 pndA VPB pfet_01v8_hvt m=2 w=1.0 l=0.15 mult=1 sa=0.265
+ sb=0.265 sd=0.28 topography=normal area=0.063 perim=1.14
MMPC0 Y C1 pndB VPB pfet_01v8_hvt m=2 w=1.0 l=0.15 mult=1 sa=0.265
+ sb=0.265 sd=0.28 topography=normal area=0.063 perim=1.14
MMNA0 Y A1 sndA1 VNB nfet_01v8 m=2 w=0.65 l=0.15 mult=1 sa=0.265
+ sb=0.265 sd=0.28 topography=normal area=0.063 perim=1.14
MMNA1 sndA1 A2 VGND VNB nfet_01v8 m=2 w=0.65 l=0.15 mult=1 sa=0.265
+ sb=0.265 sd=0.28 topography=normal area=0.063 perim=1.14
MMNB0 Y B1 VGND VNB nfet_01v8 m=2 w=0.65 l=0.15 mult=1 sa=0.265
+ sb=0.265 sd=0.28 topography=normal area=0.063 perim=1.14
MMNC0 Y C1 VGND VNB nfet_01v8 m=2 w=0.65 l=0.15 mult=1 sa=0.265
+ sb=0.265 sd=0.28 topography=normal area=0.063 perim=1.14
.ENDS

.SUBCKT sky130_fd_sc_hd__a211oi_4 A1 A2 B1 C1 VGND VNB VPB VPWR Y
MMPA0 pndA A1 VPWR VPB pfet_01v8_hvt m=4 w=1.0 l=0.15 mult=1 sa=0.265
+ sb=0.265 sd=0.28 topography=normal area=0.063 perim=1.14
MMPA1 pndA A2 VPWR VPB pfet_01v8_hvt m=4 w=1.0 l=0.15 mult=1 sa=0.265
+ sb=0.265 sd=0.28 topography=normal area=0.063 perim=1.14
MMPB0 pndB B1 pndA VPB pfet_01v8_hvt m=4 w=1.0 l=0.15 mult=1 sa=0.265
+ sb=0.265 sd=0.28 topography=normal area=0.063 perim=1.14
MMPC0 Y C1 pndB VPB pfet_01v8_hvt m=4 w=1.0 l=0.15 mult=1 sa=0.265
+ sb=0.265 sd=0.28 topography=normal area=0.063 perim=1.14
MMNA0 Y A1 sndA1 VNB nfet_01v8 m=4 w=0.65 l=0.15 mult=1 sa=0.265
+ sb=0.265 sd=0.28 topography=normal area=0.063 perim=1.14
MMNA1 sndA1 A2 VGND VNB nfet_01v8 m=4 w=0.65 l=0.15 mult=1 sa=0.265
+ sb=0.265 sd=0.28 topography=normal area=0.063 perim=1.14
MMNB0 Y B1 VGND VNB nfet_01v8 m=4 w=0.65 l=0.15 mult=1 sa=0.265
+ sb=0.265 sd=0.28 topography=normal area=0.063 perim=1.14
MMNC0 Y C1 VGND VNB nfet_01v8 m=4 w=0.65 l=0.15 mult=1 sa=0.265
+ sb=0.265 sd=0.28 topography=normal area=0.063 perim=1.14
.ENDS

.SUBCKT sky130_fd_sc_hd__a221o_1 A1 A2 B1 B2 C1 VGND VNB VPB VPWR X
MMPA0 pndA A1 VPWR VPB pfet_01v8_hvt m=1 w=1.0 l=0.15 mult=1 sa=0.265
+ sb=0.265 sd=0.28 topography=normal area=0.063 perim=1.14
MMPA1 pndA A2 VPWR VPB pfet_01v8_hvt m=1 w=1.0 l=0.15 mult=1 sa=0.265
+ sb=0.265 sd=0.28 topography=normal area=0.063 perim=1.14
MMPB0 pndB B1 pndA VPB pfet_01v8_hvt m=1 w=1.0 l=0.15 mult=1 sa=0.265
+ sb=0.265 sd=0.28 topography=normal area=0.063 perim=1.14
MMPB1 pndB B2 pndA VPB pfet_01v8_hvt m=1 w=1.0 l=0.15 mult=1 sa=0.265
+ sb=0.265 sd=0.28 topography=normal area=0.063 perim=1.14
MMPC0 y C1 pndB VPB pfet_01v8_hvt m=1 w=1.0 l=0.15 mult=1 sa=0.265
+ sb=0.265 sd=0.28 topography=normal area=0.063 perim=1.14
MMIPX X y VPWR VPB pfet_01v8_hvt m=1 w=1.0 l=0.15 mult=1 sa=0.265
+ sb=0.265 sd=0.28 topography=normal area=0.063 perim=1.14
MMNA0 y A1 sndA1 VNB nfet_01v8 m=1 w=0.65 l=0.15 mult=1 sa=0.265
+ sb=0.265 sd=0.28 topography=normal area=0.063 perim=1.14
MMNA1 sndA1 A2 VGND VNB nfet_01v8 m=1 w=0.65 l=0.15 mult=1 sa=0.265
+ sb=0.265 sd=0.28 topography=normal area=0.063 perim=1.14
MMNB0 y B1 sndB1 VNB nfet_01v8 m=1 w=0.65 l=0.15 mult=1 sa=0.265
+ sb=0.265 sd=0.28 topography=normal area=0.063 perim=1.14
MMNB1 sndB1 B2 VGND VNB nfet_01v8 m=1 w=0.65 l=0.15 mult=1 sa=0.265
+ sb=0.265 sd=0.28 topography=normal area=0.063 perim=1.14
MMNC0 y C1 VGND VNB nfet_01v8 m=1 w=0.65 l=0.15 mult=1 sa=0.265
+ sb=0.265 sd=0.28 topography=normal area=0.063 perim=1.14
MMINX X y VGND VNB nfet_01v8 m=1 w=0.65 l=0.15 mult=1 sa=0.265
+ sb=0.265 sd=0.28 topography=normal area=0.063 perim=1.14
.ENDS

.SUBCKT sky130_fd_sc_hd__a221o_2 A1 A2 B1 B2 C1 VGND VNB VPB VPWR X
MMPA0 pndA A1 VPWR VPB pfet_01v8_hvt m=1 w=1.0 l=0.15 mult=1 sa=0.265
+ sb=0.265 sd=0.28 topography=normal area=0.063 perim=1.14
MMPA1 pndA A2 VPWR VPB pfet_01v8_hvt m=1 w=1.0 l=0.15 mult=1 sa=0.265
+ sb=0.265 sd=0.28 topography=normal area=0.063 perim=1.14
MMPB0 pndB B1 pndA VPB pfet_01v8_hvt m=1 w=1.0 l=0.15 mult=1 sa=0.265
+ sb=0.265 sd=0.28 topography=normal area=0.063 perim=1.14
MMPB1 pndB B2 pndA VPB pfet_01v8_hvt m=1 w=1.0 l=0.15 mult=1 sa=0.265
+ sb=0.265 sd=0.28 topography=normal area=0.063 perim=1.14
MMPC0 y C1 pndB VPB pfet_01v8_hvt m=1 w=1.0 l=0.15 mult=1 sa=0.265
+ sb=0.265 sd=0.28 topography=normal area=0.063 perim=1.14
MMIPX X y VPWR VPB pfet_01v8_hvt m=2 w=1.0 l=0.15 mult=1 sa=0.265
+ sb=0.265 sd=0.28 topography=normal area=0.063 perim=1.14
MMNA0 y A1 sndA1 VNB nfet_01v8 m=1 w=0.65 l=0.15 mult=1 sa=0.265
+ sb=0.265 sd=0.28 topography=normal area=0.063 perim=1.14
MMNA1 sndA1 A2 VGND VNB nfet_01v8 m=1 w=0.65 l=0.15 mult=1 sa=0.265
+ sb=0.265 sd=0.28 topography=normal area=0.063 perim=1.14
MMNB0 y B1 sndB1 VNB nfet_01v8 m=1 w=0.65 l=0.15 mult=1 sa=0.265
+ sb=0.265 sd=0.28 topography=normal area=0.063 perim=1.14
MMNB1 sndB1 B2 VGND VNB nfet_01v8 m=1 w=0.65 l=0.15 mult=1 sa=0.265
+ sb=0.265 sd=0.28 topography=normal area=0.063 perim=1.14
MMNC0 y C1 VGND VNB nfet_01v8 m=1 w=0.65 l=0.15 mult=1 sa=0.265
+ sb=0.265 sd=0.28 topography=normal area=0.063 perim=1.14
MMINX X y VGND VNB nfet_01v8 m=2 w=0.65 l=0.15 mult=1 sa=0.265
+ sb=0.265 sd=0.28 topography=normal area=0.063 perim=1.14
.ENDS

.SUBCKT sky130_fd_sc_hd__a221o_4 A1 A2 B1 B2 C1 VGND VNB VPB VPWR X
MMPA0 pndA A1 VPWR VPB pfet_01v8_hvt m=2 w=1.0 l=0.15 mult=1 sa=0.265
+ sb=0.265 sd=0.28 topography=normal area=0.063 perim=1.14
MMPA1 pndA A2 VPWR VPB pfet_01v8_hvt m=2 w=1.0 l=0.15 mult=1 sa=0.265
+ sb=0.265 sd=0.28 topography=normal area=0.063 perim=1.14
MMPB0 pndB B1 pndA VPB pfet_01v8_hvt m=2 w=1.0 l=0.15 mult=1 sa=0.265
+ sb=0.265 sd=0.28 topography=normal area=0.063 perim=1.14
MMPB1 pndB B2 pndA VPB pfet_01v8_hvt m=2 w=1.0 l=0.15 mult=1 sa=0.265
+ sb=0.265 sd=0.28 topography=normal area=0.063 perim=1.14
MMPC0 y C1 pndB VPB pfet_01v8_hvt m=2 w=1.0 l=0.15 mult=1 sa=0.265
+ sb=0.265 sd=0.28 topography=normal area=0.063 perim=1.14
MMIPX X y VPWR VPB pfet_01v8_hvt m=4 w=1.0 l=0.15 mult=1 sa=0.265
+ sb=0.265 sd=0.28 topography=normal area=0.063 perim=1.14
MMNA0 y A1 sndA1 VNB nfet_01v8 m=2 w=0.65 l=0.15 mult=1 sa=0.265
+ sb=0.265 sd=0.28 topography=normal area=0.063 perim=1.14
MMNA1 sndA1 A2 VGND VNB nfet_01v8 m=2 w=0.65 l=0.15 mult=1 sa=0.265
+ sb=0.265 sd=0.28 topography=normal area=0.063 perim=1.14
MMNB0 y B1 sndB1 VNB nfet_01v8 m=2 w=0.65 l=0.15 mult=1 sa=0.265
+ sb=0.265 sd=0.28 topography=normal area=0.063 perim=1.14
MMNB1 sndB1 B2 VGND VNB nfet_01v8 m=2 w=0.65 l=0.15 mult=1 sa=0.265
+ sb=0.265 sd=0.28 topography=normal area=0.063 perim=1.14
MMNC0 y C1 VGND VNB nfet_01v8 m=2 w=0.65 l=0.15 mult=1 sa=0.265
+ sb=0.265 sd=0.28 topography=normal area=0.063 perim=1.14
MMINX X y VGND VNB nfet_01v8 m=4 w=0.65 l=0.15 mult=1 sa=0.265
+ sb=0.265 sd=0.28 topography=normal area=0.063 perim=1.14
.ENDS

.SUBCKT sky130_fd_sc_hd__a221oi_1 A1 A2 B1 B2 C1 VGND VNB VPB VPWR Y
MMPA0 pndA A1 VPWR VPB pfet_01v8_hvt m=1 w=1.0 l=0.15 mult=1 sa=0.265
+ sb=0.265 sd=0.28 topography=normal area=0.063 perim=1.14
MMPA1 pndA A2 VPWR VPB pfet_01v8_hvt m=1 w=1.0 l=0.15 mult=1 sa=0.265
+ sb=0.265 sd=0.28 topography=normal area=0.063 perim=1.14
MMPB0 pndB B1 pndA VPB pfet_01v8_hvt m=1 w=1.0 l=0.15 mult=1 sa=0.265
+ sb=0.265 sd=0.28 topography=normal area=0.063 perim=1.14
MMPB1 pndB B2 pndA VPB pfet_01v8_hvt m=1 w=1.0 l=0.15 mult=1 sa=0.265
+ sb=0.265 sd=0.28 topography=normal area=0.063 perim=1.14
MMPC0 Y C1 pndB VPB pfet_01v8_hvt m=1 w=1.0 l=0.15 mult=1 sa=0.265
+ sb=0.265 sd=0.28 topography=normal area=0.063 perim=1.14
MMNA0 Y A1 sndA1 VNB nfet_01v8 m=1 w=0.65 l=0.15 mult=1 sa=0.265
+ sb=0.265 sd=0.28 topography=normal area=0.063 perim=1.14
MMNA1 sndA1 A2 VGND VNB nfet_01v8 m=1 w=0.65 l=0.15 mult=1 sa=0.265
+ sb=0.265 sd=0.28 topography=normal area=0.063 perim=1.14
MMNB0 Y B1 sndB1 VNB nfet_01v8 m=1 w=0.65 l=0.15 mult=1 sa=0.265
+ sb=0.265 sd=0.28 topography=normal area=0.063 perim=1.14
MMNB1 sndB1 B2 VGND VNB nfet_01v8 m=1 w=0.65 l=0.15 mult=1 sa=0.265
+ sb=0.265 sd=0.28 topography=normal area=0.063 perim=1.14
MMNC0 Y C1 VGND VNB nfet_01v8 m=1 w=0.65 l=0.15 mult=1 sa=0.265
+ sb=0.265 sd=0.28 topography=normal area=0.063 perim=1.14
.ENDS

.SUBCKT sky130_fd_sc_hd__a221oi_2 A1 A2 B1 B2 C1 VGND VNB VPB VPWR Y
MMPA0 pndA A1 VPWR VPB pfet_01v8_hvt m=2 w=1.0 l=0.15 mult=1 sa=0.265
+ sb=0.265 sd=0.28 topography=normal area=0.063 perim=1.14
MMPA1 pndA A2 VPWR VPB pfet_01v8_hvt m=2 w=1.0 l=0.15 mult=1 sa=0.265
+ sb=0.265 sd=0.28 topography=normal area=0.063 perim=1.14
MMPB0 pndB B1 pndA VPB pfet_01v8_hvt m=2 w=1.0 l=0.15 mult=1 sa=0.265
+ sb=0.265 sd=0.28 topography=normal area=0.063 perim=1.14
MMPB1 pndB B2 pndA VPB pfet_01v8_hvt m=2 w=1.0 l=0.15 mult=1 sa=0.265
+ sb=0.265 sd=0.28 topography=normal area=0.063 perim=1.14
MMPC0 Y C1 pndB VPB pfet_01v8_hvt m=2 w=1.0 l=0.15 mult=1 sa=0.265
+ sb=0.265 sd=0.28 topography=normal area=0.063 perim=1.14
MMNA0 Y A1 sndA1 VNB nfet_01v8 m=2 w=0.65 l=0.15 mult=1 sa=0.265
+ sb=0.265 sd=0.28 topography=normal area=0.063 perim=1.14
MMNA1 sndA1 A2 VGND VNB nfet_01v8 m=2 w=0.65 l=0.15 mult=1 sa=0.265
+ sb=0.265 sd=0.28 topography=normal area=0.063 perim=1.14
MMNB0 Y B1 sndB1 VNB nfet_01v8 m=2 w=0.65 l=0.15 mult=1 sa=0.265
+ sb=0.265 sd=0.28 topography=normal area=0.063 perim=1.14
MMNB1 sndB1 B2 VGND VNB nfet_01v8 m=2 w=0.65 l=0.15 mult=1 sa=0.265
+ sb=0.265 sd=0.28 topography=normal area=0.063 perim=1.14
MMNC0 Y C1 VGND VNB nfet_01v8 m=2 w=0.65 l=0.15 mult=1 sa=0.265
+ sb=0.265 sd=0.28 topography=normal area=0.063 perim=1.14
.ENDS

.SUBCKT sky130_fd_sc_hd__a221oi_4 A1 A2 B1 B2 C1 VGND VNB VPB VPWR Y
MMPA0 pndA A1 VPWR VPB pfet_01v8_hvt m=4 w=1.0 l=0.15 mult=1 sa=0.265
+ sb=0.265 sd=0.28 topography=normal area=0.063 perim=1.14
MMPA1 pndA A2 VPWR VPB pfet_01v8_hvt m=4 w=1.0 l=0.15 mult=1 sa=0.265
+ sb=0.265 sd=0.28 topography=normal area=0.063 perim=1.14
MMPB0 pndB B1 pndA VPB pfet_01v8_hvt m=4 w=1.0 l=0.15 mult=1 sa=0.265
+ sb=0.265 sd=0.28 topography=normal area=0.063 perim=1.14
MMPB1 pndB B2 pndA VPB pfet_01v8_hvt m=4 w=1.0 l=0.15 mult=1 sa=0.265
+ sb=0.265 sd=0.28 topography=normal area=0.063 perim=1.14
MMPC0 Y C1 pndB VPB pfet_01v8_hvt m=4 w=1.0 l=0.15 mult=1 sa=0.265
+ sb=0.265 sd=0.28 topography=normal area=0.063 perim=1.14
MMNA0 Y A1 sndA1 VNB nfet_01v8 m=4 w=0.65 l=0.15 mult=1 sa=0.265
+ sb=0.265 sd=0.28 topography=normal area=0.063 perim=1.14
MMNA1 sndA1 A2 VGND VNB nfet_01v8 m=4 w=0.65 l=0.15 mult=1 sa=0.265
+ sb=0.265 sd=0.28 topography=normal area=0.063 perim=1.14
MMNB0 Y B1 sndB1 VNB nfet_01v8 m=4 w=0.65 l=0.15 mult=1 sa=0.265
+ sb=0.265 sd=0.28 topography=normal area=0.063 perim=1.14
MMNB1 sndB1 B2 VGND VNB nfet_01v8 m=4 w=0.65 l=0.15 mult=1 sa=0.265
+ sb=0.265 sd=0.28 topography=normal area=0.063 perim=1.14
MMNC0 Y C1 VGND VNB nfet_01v8 m=4 w=0.65 l=0.15 mult=1 sa=0.265
+ sb=0.265 sd=0.28 topography=normal area=0.063 perim=1.14
.ENDS

.SUBCKT sky130_fd_sc_hd__a222oi_1 A1 A2 B1 B2 C1 C2 VGND VNB VPB VPWR Y
MMPA0 pndA A1 VPWR VPB pfet_01v8_hvt m=1 w=1.0 l=0.15 mult=1 sa=0.265
+ sb=0.265 sd=0.28 topography=normal area=0.063 perim=1.14
MMPA1 pndA A2 VPWR VPB pfet_01v8_hvt m=1 w=1.0 l=0.15 mult=1 sa=0.265
+ sb=0.265 sd=0.28 topography=normal area=0.063 perim=1.14
MMPB0 pndB B1 pndA VPB pfet_01v8_hvt m=1 w=1.0 l=0.15 mult=1 sa=0.265
+ sb=0.265 sd=0.28 topography=normal area=0.063 perim=1.14
MMPB1 pndB B2 pndA VPB pfet_01v8_hvt m=1 w=1.0 l=0.15 mult=1 sa=0.265
+ sb=0.265 sd=0.28 topography=normal area=0.063 perim=1.14
MMPC0 Y C1 pndB VPB pfet_01v8_hvt m=1 w=1.0 l=0.15 mult=1 sa=0.265
+ sb=0.265 sd=0.28 topography=normal area=0.063 perim=1.14
MI8 Y C2 pndB VPB pfet_01v8_hvt m=1 w=1.0 l=0.15 mult=1 sa=0.265
+ sb=0.265 sd=0.28 topography=normal area=0.063 perim=1.14
MMNA0 Y A1 sndA1 VNB nfet_01v8 m=1 w=0.64 l=0.15 mult=1 sa=0.265
+ sb=0.265 sd=0.28 topography=normal area=0.063 perim=1.14
MMNA1 sndA1 A2 VGND VNB nfet_01v8 m=1 w=0.64 l=0.15 mult=1 sa=0.265
+ sb=0.265 sd=0.28 topography=normal area=0.063 perim=1.14
MMNB0 Y B1 sndB1 VNB nfet_01v8 m=1 w=0.64 l=0.15 mult=1 sa=0.265
+ sb=0.265 sd=0.28 topography=normal area=0.063 perim=1.14
MMNB1 sndB1 B2 VGND VNB nfet_01v8 m=1 w=0.64 l=0.15 mult=1 sa=0.265
+ sb=0.265 sd=0.28 topography=normal area=0.063 perim=1.14
MMNC0 Y C1 net62 VNB nfet_01v8 m=1 w=0.64 l=0.15 mult=1 sa=0.265
+ sb=0.265 sd=0.28 topography=normal area=0.063 perim=1.14
MI10 net62 C2 VGND VNB nfet_01v8 m=1 w=0.64 l=0.15 mult=1 sa=0.265
+ sb=0.265 sd=0.28 topography=normal area=0.063 perim=1.14
.ENDS

.SUBCKT sky130_fd_sc_hd__a311o_1 A1 A2 A3 B1 C1 VGND VNB VPB VPWR X
MMPA0 pndA A1 VPWR VPB pfet_01v8_hvt m=1 w=1.0 l=0.15 mult=1 sa=0.265
+ sb=0.265 sd=0.28 topography=normal area=0.063 perim=1.14
MMPA1 pndA A2 VPWR VPB pfet_01v8_hvt m=1 w=1.0 l=0.15 mult=1 sa=0.265
+ sb=0.265 sd=0.28 topography=normal area=0.063 perim=1.14
MMPA2 pndA A3 VPWR VPB pfet_01v8_hvt m=1 w=1.0 l=0.15 mult=1 sa=0.265
+ sb=0.265 sd=0.28 topography=normal area=0.063 perim=1.14
MMPB0 pndB B1 pndA VPB pfet_01v8_hvt m=1 w=1.0 l=0.15 mult=1 sa=0.265
+ sb=0.265 sd=0.28 topography=normal area=0.063 perim=1.14
MMPC0 y C1 pndB VPB pfet_01v8_hvt m=1 w=1.0 l=0.15 mult=1 sa=0.265
+ sb=0.265 sd=0.28 topography=normal area=0.063 perim=1.14
MMIPX X y VPWR VPB pfet_01v8_hvt m=1 w=1.0 l=0.15 mult=1 sa=0.265
+ sb=0.265 sd=0.28 topography=normal area=0.063 perim=1.14
MMNA0 y A1 sndA1 VNB nfet_01v8 m=1 w=0.65 l=0.15 mult=1 sa=0.265
+ sb=0.265 sd=0.28 topography=normal area=0.063 perim=1.14
MMNA1 sndA1 A2 sndA2 VNB nfet_01v8 m=1 w=0.65 l=0.15 mult=1 sa=0.265
+ sb=0.265 sd=0.28 topography=normal area=0.063 perim=1.14
MMNA2 sndA2 A3 VGND VNB nfet_01v8 m=1 w=0.65 l=0.15 mult=1 sa=0.265
+ sb=0.265 sd=0.28 topography=normal area=0.063 perim=1.14
MMNB0 y B1 VGND VNB nfet_01v8 m=1 w=0.65 l=0.15 mult=1 sa=0.265
+ sb=0.265 sd=0.28 topography=normal area=0.063 perim=1.14
MMNC0 y C1 VGND VNB nfet_01v8 m=1 w=0.65 l=0.15 mult=1 sa=0.265
+ sb=0.265 sd=0.28 topography=normal area=0.063 perim=1.14
MMINX X y VGND VNB nfet_01v8 m=1 w=0.65 l=0.15 mult=1 sa=0.265
+ sb=0.265 sd=0.28 topography=normal area=0.063 perim=1.14
.ENDS

.SUBCKT sky130_fd_sc_hd__a311o_2 A1 A2 A3 B1 C1 VGND VNB VPB VPWR X
MMPA0 pndA A1 VPWR VPB pfet_01v8_hvt m=1 w=1.0 l=0.15 mult=1 sa=0.265
+ sb=0.265 sd=0.28 topography=normal area=0.063 perim=1.14
MMPA1 pndA A2 VPWR VPB pfet_01v8_hvt m=1 w=1.0 l=0.15 mult=1 sa=0.265
+ sb=0.265 sd=0.28 topography=normal area=0.063 perim=1.14
MMPA2 pndA A3 VPWR VPB pfet_01v8_hvt m=1 w=1.0 l=0.15 mult=1 sa=0.265
+ sb=0.265 sd=0.28 topography=normal area=0.063 perim=1.14
MMPB0 pndB B1 pndA VPB pfet_01v8_hvt m=1 w=1.0 l=0.15 mult=1 sa=0.265
+ sb=0.265 sd=0.28 topography=normal area=0.063 perim=1.14
MMPC0 y C1 pndB VPB pfet_01v8_hvt m=1 w=1.0 l=0.15 mult=1 sa=0.265
+ sb=0.265 sd=0.28 topography=normal area=0.063 perim=1.14
MMIPX X y VPWR VPB pfet_01v8_hvt m=2 w=1.0 l=0.15 mult=1 sa=0.265
+ sb=0.265 sd=0.28 topography=normal area=0.063 perim=1.14
MMNA0 y A1 sndA1 VNB nfet_01v8 m=1 w=0.65 l=0.15 mult=1 sa=0.265
+ sb=0.265 sd=0.28 topography=normal area=0.063 perim=1.14
MMNA1 sndA1 A2 sndA2 VNB nfet_01v8 m=1 w=0.65 l=0.15 mult=1 sa=0.265
+ sb=0.265 sd=0.28 topography=normal area=0.063 perim=1.14
MMNA2 sndA2 A3 VGND VNB nfet_01v8 m=1 w=0.65 l=0.15 mult=1 sa=0.265
+ sb=0.265 sd=0.28 topography=normal area=0.063 perim=1.14
MMNB0 y B1 VGND VNB nfet_01v8 m=1 w=0.65 l=0.15 mult=1 sa=0.265
+ sb=0.265 sd=0.28 topography=normal area=0.063 perim=1.14
MMNC0 y C1 VGND VNB nfet_01v8 m=1 w=0.65 l=0.15 mult=1 sa=0.265
+ sb=0.265 sd=0.28 topography=normal area=0.063 perim=1.14
MMINX X y VGND VNB nfet_01v8 m=2 w=0.65 l=0.15 mult=1 sa=0.265
+ sb=0.265 sd=0.28 topography=normal area=0.063 perim=1.14
.ENDS

.SUBCKT sky130_fd_sc_hd__a311o_4 A1 A2 A3 B1 C1 VGND VNB VPB VPWR X
MMPA0 pndA A1 VPWR VPB pfet_01v8_hvt m=2 w=1.0 l=0.15 mult=1 sa=0.265
+ sb=0.265 sd=0.28 topography=normal area=0.063 perim=1.14
MMPA1 pndA A2 VPWR VPB pfet_01v8_hvt m=2 w=1.0 l=0.15 mult=1 sa=0.265
+ sb=0.265 sd=0.28 topography=normal area=0.063 perim=1.14
MMPA2 pndA A3 VPWR VPB pfet_01v8_hvt m=2 w=1.0 l=0.15 mult=1 sa=0.265
+ sb=0.265 sd=0.28 topography=normal area=0.063 perim=1.14
MMPB0 pndB B1 pndA VPB pfet_01v8_hvt m=2 w=1.0 l=0.15 mult=1 sa=0.265
+ sb=0.265 sd=0.28 topography=normal area=0.063 perim=1.14
MMPC0 y C1 pndB VPB pfet_01v8_hvt m=2 w=1.0 l=0.15 mult=1 sa=0.265
+ sb=0.265 sd=0.28 topography=normal area=0.063 perim=1.14
MMIPX X y VPWR VPB pfet_01v8_hvt m=4 w=1.0 l=0.15 mult=1 sa=0.265
+ sb=0.265 sd=0.28 topography=normal area=0.063 perim=1.14
MMNA0 y A1 sndA1 VNB nfet_01v8 m=2 w=0.65 l=0.15 mult=1 sa=0.265
+ sb=0.265 sd=0.28 topography=normal area=0.063 perim=1.14
MMNA1 sndA1 A2 sndA2 VNB nfet_01v8 m=2 w=0.65 l=0.15 mult=1 sa=0.265
+ sb=0.265 sd=0.28 topography=normal area=0.063 perim=1.14
MMNA2 sndA2 A3 VGND VNB nfet_01v8 m=2 w=0.65 l=0.15 mult=1 sa=0.265
+ sb=0.265 sd=0.28 topography=normal area=0.063 perim=1.14
MMNB0 y B1 VGND VNB nfet_01v8 m=2 w=0.65 l=0.15 mult=1 sa=0.265
+ sb=0.265 sd=0.28 topography=normal area=0.063 perim=1.14
MMNC0 y C1 VGND VNB nfet_01v8 m=2 w=0.65 l=0.15 mult=1 sa=0.265
+ sb=0.265 sd=0.28 topography=normal area=0.063 perim=1.14
MMINX X y VGND VNB nfet_01v8 m=4 w=0.65 l=0.15 mult=1 sa=0.265
+ sb=0.265 sd=0.28 topography=normal area=0.063 perim=1.14
.ENDS

.SUBCKT sky130_fd_sc_hd__a311oi_1 A1 A2 A3 B1 C1 VGND VNB VPB VPWR Y
MMPA0 pndA A1 VPWR VPB pfet_01v8_hvt m=1 w=1.0 l=0.15 mult=1 sa=0.265
+ sb=0.265 sd=0.28 topography=normal area=0.063 perim=1.14
MMPA1 pndA A2 VPWR VPB pfet_01v8_hvt m=1 w=1.0 l=0.15 mult=1 sa=0.265
+ sb=0.265 sd=0.28 topography=normal area=0.063 perim=1.14
MMPA2 pndA A3 VPWR VPB pfet_01v8_hvt m=1 w=1.0 l=0.15 mult=1 sa=0.265
+ sb=0.265 sd=0.28 topography=normal area=0.063 perim=1.14
MMPB0 pndB B1 pndA VPB pfet_01v8_hvt m=1 w=1.0 l=0.15 mult=1 sa=0.265
+ sb=0.265 sd=0.28 topography=normal area=0.063 perim=1.14
MMPC0 Y C1 pndB VPB pfet_01v8_hvt m=1 w=1.0 l=0.15 mult=1 sa=0.265
+ sb=0.265 sd=0.28 topography=normal area=0.063 perim=1.14
MMNA0 Y A1 sndA1 VNB nfet_01v8 m=1 w=0.65 l=0.15 mult=1 sa=0.265
+ sb=0.265 sd=0.28 topography=normal area=0.063 perim=1.14
MMNA1 sndA1 A2 sndA2 VNB nfet_01v8 m=1 w=0.65 l=0.15 mult=1 sa=0.265
+ sb=0.265 sd=0.28 topography=normal area=0.063 perim=1.14
MMNA2 sndA2 A3 VGND VNB nfet_01v8 m=1 w=0.65 l=0.15 mult=1 sa=0.265
+ sb=0.265 sd=0.28 topography=normal area=0.063 perim=1.14
MMNB0 Y B1 VGND VNB nfet_01v8 m=1 w=0.65 l=0.15 mult=1 sa=0.265
+ sb=0.265 sd=0.28 topography=normal area=0.063 perim=1.14
MMNC0 Y C1 VGND VNB nfet_01v8 m=1 w=0.65 l=0.15 mult=1 sa=0.265
+ sb=0.265 sd=0.28 topography=normal area=0.063 perim=1.14
.ENDS

.SUBCKT sky130_fd_sc_hd__a311oi_2 A1 A2 A3 B1 C1 VGND VNB VPB VPWR Y
MMPA0 pndA A1 VPWR VPB pfet_01v8_hvt m=2 w=1.0 l=0.15 mult=1 sa=0.265
+ sb=0.265 sd=0.28 topography=normal area=0.063 perim=1.14
MMPA1 pndA A2 VPWR VPB pfet_01v8_hvt m=2 w=1.0 l=0.15 mult=1 sa=0.265
+ sb=0.265 sd=0.28 topography=normal area=0.063 perim=1.14
MMPA2 pndA A3 VPWR VPB pfet_01v8_hvt m=2 w=1.0 l=0.15 mult=1 sa=0.265
+ sb=0.265 sd=0.28 topography=normal area=0.063 perim=1.14
MMPB0 pndB B1 pndA VPB pfet_01v8_hvt m=2 w=1.0 l=0.15 mult=1 sa=0.265
+ sb=0.265 sd=0.28 topography=normal area=0.063 perim=1.14
MMPC0 Y C1 pndB VPB pfet_01v8_hvt m=2 w=1.0 l=0.15 mult=1 sa=0.265
+ sb=0.265 sd=0.28 topography=normal area=0.063 perim=1.14
MMNA0 Y A1 sndA1 VNB nfet_01v8 m=2 w=0.65 l=0.15 mult=1 sa=0.265
+ sb=0.265 sd=0.28 topography=normal area=0.063 perim=1.14
MMNA1 sndA1 A2 sndA2 VNB nfet_01v8 m=2 w=0.65 l=0.15 mult=1 sa=0.265
+ sb=0.265 sd=0.28 topography=normal area=0.063 perim=1.14
MMNA2 sndA2 A3 VGND VNB nfet_01v8 m=2 w=0.65 l=0.15 mult=1 sa=0.265
+ sb=0.265 sd=0.28 topography=normal area=0.063 perim=1.14
MMNB0 Y B1 VGND VNB nfet_01v8 m=2 w=0.65 l=0.15 mult=1 sa=0.265
+ sb=0.265 sd=0.28 topography=normal area=0.063 perim=1.14
MMNC0 Y C1 VGND VNB nfet_01v8 m=2 w=0.65 l=0.15 mult=1 sa=0.265
+ sb=0.265 sd=0.28 topography=normal area=0.063 perim=1.14
.ENDS

.SUBCKT sky130_fd_sc_hd__a311oi_4 A1 A2 A3 B1 C1 VGND VNB VPB VPWR Y
MMPA0 pndA A1 VPWR VPB pfet_01v8_hvt m=4 w=1.0 l=0.15 mult=1 sa=0.265
+ sb=0.265 sd=0.28 topography=normal area=0.063 perim=1.14
MMPA1 pndA A2 VPWR VPB pfet_01v8_hvt m=4 w=1.0 l=0.15 mult=1 sa=0.265
+ sb=0.265 sd=0.28 topography=normal area=0.063 perim=1.14
MMPA2 pndA A3 VPWR VPB pfet_01v8_hvt m=4 w=1.0 l=0.15 mult=1 sa=0.265
+ sb=0.265 sd=0.28 topography=normal area=0.063 perim=1.14
MMPB0 pndB B1 pndA VPB pfet_01v8_hvt m=4 w=1.0 l=0.15 mult=1 sa=0.265
+ sb=0.265 sd=0.28 topography=normal area=0.063 perim=1.14
MMPC0 Y C1 pndB VPB pfet_01v8_hvt m=4 w=1.0 l=0.15 mult=1 sa=0.265
+ sb=0.265 sd=0.28 topography=normal area=0.063 perim=1.14
MMNA0 Y A1 sndA1 VNB nfet_01v8 m=4 w=0.65 l=0.15 mult=1 sa=0.265
+ sb=0.265 sd=0.28 topography=normal area=0.063 perim=1.14
MMNA1 sndA1 A2 sndA2 VNB nfet_01v8 m=4 w=0.65 l=0.15 mult=1 sa=0.265
+ sb=0.265 sd=0.28 topography=normal area=0.063 perim=1.14
MMNA2 sndA2 A3 VGND VNB nfet_01v8 m=4 w=0.65 l=0.15 mult=1 sa=0.265
+ sb=0.265 sd=0.28 topography=normal area=0.063 perim=1.14
MMNB0 Y B1 VGND VNB nfet_01v8 m=4 w=0.65 l=0.15 mult=1 sa=0.265
+ sb=0.265 sd=0.28 topography=normal area=0.063 perim=1.14
MMNC0 Y C1 VGND VNB nfet_01v8 m=4 w=0.65 l=0.15 mult=1 sa=0.265
+ sb=0.265 sd=0.28 topography=normal area=0.063 perim=1.14
.ENDS

.SUBCKT sky130_fd_sc_hd__a2111o_1 A1 A2 B1 C1 D1 VGND VNB VPB VPWR X
MMPA0 pndA A1 VPWR VPB pfet_01v8_hvt m=1 w=1.0 l=0.15 mult=1 sa=0.265
+ sb=0.265 sd=0.28 topography=normal area=0.063 perim=1.14
MMPA1 pndA A2 VPWR VPB pfet_01v8_hvt m=1 w=1.0 l=0.15 mult=1 sa=0.265
+ sb=0.265 sd=0.28 topography=normal area=0.063 perim=1.14
MMPB0 pndB B1 pndA VPB pfet_01v8_hvt m=1 w=1.0 l=0.15 mult=1 sa=0.265
+ sb=0.265 sd=0.28 topography=normal area=0.063 perim=1.14
MMPC0 pndC C1 pndB VPB pfet_01v8_hvt m=1 w=1.0 l=0.15 mult=1 sa=0.265
+ sb=0.265 sd=0.28 topography=normal area=0.063 perim=1.14
MMPD0 y D1 pndC VPB pfet_01v8_hvt m=1 w=1.0 l=0.15 mult=1 sa=0.265
+ sb=0.265 sd=0.28 topography=normal area=0.063 perim=1.14
MMIPX X y VPWR VPB pfet_01v8_hvt m=1 w=1.0 l=0.15 mult=1 sa=0.265
+ sb=0.265 sd=0.28 topography=normal area=0.063 perim=1.14
MMNA0 y A1 sndA1 VNB nfet_01v8 m=1 w=0.65 l=0.15 mult=1 sa=0.265
+ sb=0.265 sd=0.28 topography=normal area=0.063 perim=1.14
MMNA1 sndA1 A2 VGND VNB nfet_01v8 m=1 w=0.65 l=0.15 mult=1 sa=0.265
+ sb=0.265 sd=0.28 topography=normal area=0.063 perim=1.14
MMNB0 y B1 VGND VNB nfet_01v8 m=1 w=0.65 l=0.15 mult=1 sa=0.265
+ sb=0.265 sd=0.28 topography=normal area=0.063 perim=1.14
MMNC0 y C1 VGND VNB nfet_01v8 m=1 w=0.65 l=0.15 mult=1 sa=0.265
+ sb=0.265 sd=0.28 topography=normal area=0.063 perim=1.14
MMND0 y D1 VGND VNB nfet_01v8 m=1 w=0.65 l=0.15 mult=1 sa=0.265
+ sb=0.265 sd=0.28 topography=normal area=0.063 perim=1.14
MMINX X y VGND VNB nfet_01v8 m=1 w=0.65 l=0.15 mult=1 sa=0.265
+ sb=0.265 sd=0.28 topography=normal area=0.063 perim=1.14
.ENDS

.SUBCKT sky130_fd_sc_hd__a2111o_2 A1 A2 B1 C1 D1 VGND VNB VPB VPWR X
MMPA0 pndA A1 VPWR VPB pfet_01v8_hvt m=1 w=1.0 l=0.15 mult=1 sa=0.265
+ sb=0.265 sd=0.28 topography=normal area=0.063 perim=1.14
MMPA1 pndA A2 VPWR VPB pfet_01v8_hvt m=1 w=1.0 l=0.15 mult=1 sa=0.265
+ sb=0.265 sd=0.28 topography=normal area=0.063 perim=1.14
MMPB0 pndB B1 pndA VPB pfet_01v8_hvt m=1 w=1.0 l=0.15 mult=1 sa=0.265
+ sb=0.265 sd=0.28 topography=normal area=0.063 perim=1.14
MMPC0 pndC C1 pndB VPB pfet_01v8_hvt m=1 w=1.0 l=0.15 mult=1 sa=0.265
+ sb=0.265 sd=0.28 topography=normal area=0.063 perim=1.14
MMPD0 y D1 pndC VPB pfet_01v8_hvt m=1 w=1.0 l=0.15 mult=1 sa=0.265
+ sb=0.265 sd=0.28 topography=normal area=0.063 perim=1.14
MMIPX X y VPWR VPB pfet_01v8_hvt m=2 w=1.0 l=0.15 mult=1 sa=0.265
+ sb=0.265 sd=0.28 topography=normal area=0.063 perim=1.14
MMNA0 y A1 sndA1 VNB nfet_01v8 m=1 w=0.65 l=0.15 mult=1 sa=0.265
+ sb=0.265 sd=0.28 topography=normal area=0.063 perim=1.14
MMNA1 sndA1 A2 VGND VNB nfet_01v8 m=1 w=0.65 l=0.15 mult=1 sa=0.265
+ sb=0.265 sd=0.28 topography=normal area=0.063 perim=1.14
MMNB0 y B1 VGND VNB nfet_01v8 m=1 w=0.65 l=0.15 mult=1 sa=0.265
+ sb=0.265 sd=0.28 topography=normal area=0.063 perim=1.14
MMNC0 y C1 VGND VNB nfet_01v8 m=1 w=0.65 l=0.15 mult=1 sa=0.265
+ sb=0.265 sd=0.28 topography=normal area=0.063 perim=1.14
MMND0 y D1 VGND VNB nfet_01v8 m=1 w=0.65 l=0.15 mult=1 sa=0.265
+ sb=0.265 sd=0.28 topography=normal area=0.063 perim=1.14
MMINX X y VGND VNB nfet_01v8 m=2 w=0.65 l=0.15 mult=1 sa=0.265
+ sb=0.265 sd=0.28 topography=normal area=0.063 perim=1.14
.ENDS

.SUBCKT sky130_fd_sc_hd__a2111o_4 A1 A2 B1 C1 D1 VGND VNB VPB VPWR X
MMPA0 pndA A1 VPWR VPB pfet_01v8_hvt m=2 w=1.0 l=0.15 mult=1 sa=0.265
+ sb=0.265 sd=0.28 topography=normal area=0.063 perim=1.14
MMPA1 pndA A2 VPWR VPB pfet_01v8_hvt m=2 w=1.0 l=0.15 mult=1 sa=0.265
+ sb=0.265 sd=0.28 topography=normal area=0.063 perim=1.14
MMPB0 pndB B1 pndA VPB pfet_01v8_hvt m=2 w=1.0 l=0.15 mult=1 sa=0.265
+ sb=0.265 sd=0.28 topography=normal area=0.063 perim=1.14
MMPC0 pndC C1 pndB VPB pfet_01v8_hvt m=2 w=1.0 l=0.15 mult=1 sa=0.265
+ sb=0.265 sd=0.28 topography=normal area=0.063 perim=1.14
MMPD0 y D1 pndC VPB pfet_01v8_hvt m=2 w=1.0 l=0.15 mult=1 sa=0.265
+ sb=0.265 sd=0.28 topography=normal area=0.063 perim=1.14
MMIPX X y VPWR VPB pfet_01v8_hvt m=4 w=1.0 l=0.15 mult=1 sa=0.265
+ sb=0.265 sd=0.28 topography=normal area=0.063 perim=1.14
MMNA0 y A1 sndA1 VNB nfet_01v8 m=2 w=0.65 l=0.15 mult=1 sa=0.265
+ sb=0.265 sd=0.28 topography=normal area=0.063 perim=1.14
MMNA1 sndA1 A2 VGND VNB nfet_01v8 m=2 w=0.65 l=0.15 mult=1 sa=0.265
+ sb=0.265 sd=0.28 topography=normal area=0.063 perim=1.14
MMNB0 y B1 VGND VNB nfet_01v8 m=2 w=0.65 l=0.15 mult=1 sa=0.265
+ sb=0.265 sd=0.28 topography=normal area=0.063 perim=1.14
MMNC0 y C1 VGND VNB nfet_01v8 m=2 w=0.65 l=0.15 mult=1 sa=0.265
+ sb=0.265 sd=0.28 topography=normal area=0.063 perim=1.14
MMND0 y D1 VGND VNB nfet_01v8 m=2 w=0.65 l=0.15 mult=1 sa=0.265
+ sb=0.265 sd=0.28 topography=normal area=0.063 perim=1.14
MMINX X y VGND VNB nfet_01v8 m=4 w=0.65 l=0.15 mult=1 sa=0.265
+ sb=0.265 sd=0.28 topography=normal area=0.063 perim=1.14
.ENDS

.SUBCKT sky130_fd_sc_hd__a2111oi_0 A1 A2 B1 C1 D1 VGND VNB VPB VPWR Y
MMPA0 pndA A1 VPWR VPB pfet_01v8_hvt m=1 w=0.64 l=0.15 mult=1 sa=0.265
+ sb=0.265 sd=0.28 topography=normal area=0.063 perim=1.14
MMPA1 pndA A2 VPWR VPB pfet_01v8_hvt m=1 w=0.64 l=0.15 mult=1 sa=0.265
+ sb=0.265 sd=0.28 topography=normal area=0.063 perim=1.14
MMPB0 pndB B1 pndA VPB pfet_01v8_hvt m=1 w=0.64 l=0.15 mult=1 sa=0.265
+ sb=0.265 sd=0.28 topography=normal area=0.063 perim=1.14
MMPC0 pndC C1 pndB VPB pfet_01v8_hvt m=1 w=0.64 l=0.15 mult=1 sa=0.265
+ sb=0.265 sd=0.28 topography=normal area=0.063 perim=1.14
MMPD0 Y D1 pndC VPB pfet_01v8_hvt m=1 w=0.64 l=0.15 mult=1 sa=0.265
+ sb=0.265 sd=0.28 topography=normal area=0.063 perim=1.14
MMNA0 Y A1 sndA1 VNB nfet_01v8 m=1 w=0.42 l=0.15 mult=1 sa=0.265
+ sb=0.265 sd=0.28 topography=normal area=0.063 perim=1.14
MMNA1 sndA1 A2 VGND VNB nfet_01v8 m=1 w=0.42 l=0.15 mult=1 sa=0.265
+ sb=0.265 sd=0.28 topography=normal area=0.063 perim=1.14
MMNB0 Y B1 VGND VNB nfet_01v8 m=1 w=0.42 l=0.15 mult=1 sa=0.265
+ sb=0.265 sd=0.28 topography=normal area=0.063 perim=1.14
MMNC0 Y C1 VGND VNB nfet_01v8 m=1 w=0.42 l=0.15 mult=1 sa=0.265
+ sb=0.265 sd=0.28 topography=normal area=0.063 perim=1.14
MMND0 Y D1 VGND VNB nfet_01v8 m=1 w=0.42 l=0.15 mult=1 sa=0.265
+ sb=0.265 sd=0.28 topography=normal area=0.063 perim=1.14
.ENDS

.SUBCKT sky130_fd_sc_hd__a2111oi_1 A1 A2 B1 C1 D1 VGND VNB VPB VPWR Y
MMPA0 pndA A1 VPWR VPB pfet_01v8_hvt m=1 w=1.0 l=0.15 mult=1 sa=0.265
+ sb=0.265 sd=0.28 topography=normal area=0.063 perim=1.14
MMPA1 pndA A2 VPWR VPB pfet_01v8_hvt m=1 w=1.0 l=0.15 mult=1 sa=0.265
+ sb=0.265 sd=0.28 topography=normal area=0.063 perim=1.14
MMPB0 pndB B1 pndA VPB pfet_01v8_hvt m=1 w=1.0 l=0.15 mult=1 sa=0.265
+ sb=0.265 sd=0.28 topography=normal area=0.063 perim=1.14
MMPC0 pndC C1 pndB VPB pfet_01v8_hvt m=1 w=1.0 l=0.15 mult=1 sa=0.265
+ sb=0.265 sd=0.28 topography=normal area=0.063 perim=1.14
MMPD0 Y D1 pndC VPB pfet_01v8_hvt m=1 w=1.0 l=0.15 mult=1 sa=0.265
+ sb=0.265 sd=0.28 topography=normal area=0.063 perim=1.14
MMNA0 Y A1 sndA1 VNB nfet_01v8 m=1 w=0.65 l=0.15 mult=1 sa=0.265
+ sb=0.265 sd=0.28 topography=normal area=0.063 perim=1.14
MMNA1 sndA1 A2 VGND VNB nfet_01v8 m=1 w=0.65 l=0.15 mult=1 sa=0.265
+ sb=0.265 sd=0.28 topography=normal area=0.063 perim=1.14
MMNB0 Y B1 VGND VNB nfet_01v8 m=1 w=0.65 l=0.15 mult=1 sa=0.265
+ sb=0.265 sd=0.28 topography=normal area=0.063 perim=1.14
MMNC0 Y C1 VGND VNB nfet_01v8 m=1 w=0.65 l=0.15 mult=1 sa=0.265
+ sb=0.265 sd=0.28 topography=normal area=0.063 perim=1.14
MMND0 Y D1 VGND VNB nfet_01v8 m=1 w=0.65 l=0.15 mult=1 sa=0.265
+ sb=0.265 sd=0.28 topography=normal area=0.063 perim=1.14
.ENDS

.SUBCKT sky130_fd_sc_hd__a2111oi_2 A1 A2 B1 C1 D1 VGND VNB VPB VPWR Y
MMPA0 pndA A1 VPWR VPB pfet_01v8_hvt m=2 w=1.0 l=0.15 mult=1 sa=0.265
+ sb=0.265 sd=0.28 topography=normal area=0.063 perim=1.14
MMPA1 pndA A2 VPWR VPB pfet_01v8_hvt m=2 w=1.0 l=0.15 mult=1 sa=0.265
+ sb=0.265 sd=0.28 topography=normal area=0.063 perim=1.14
MMPB0 pndB B1 pndA VPB pfet_01v8_hvt m=2 w=1.0 l=0.15 mult=1 sa=0.265
+ sb=0.265 sd=0.28 topography=normal area=0.063 perim=1.14
MMPC0 pndC C1 pndB VPB pfet_01v8_hvt m=2 w=1.0 l=0.15 mult=1 sa=0.265
+ sb=0.265 sd=0.28 topography=normal area=0.063 perim=1.14
MMPD0 Y D1 pndC VPB pfet_01v8_hvt m=2 w=1.0 l=0.15 mult=1 sa=0.265
+ sb=0.265 sd=0.28 topography=normal area=0.063 perim=1.14
MMNA0 Y A1 sndA1 VNB nfet_01v8 m=2 w=0.65 l=0.15 mult=1 sa=0.265
+ sb=0.265 sd=0.28 topography=normal area=0.063 perim=1.14
MMNA1 sndA1 A2 VGND VNB nfet_01v8 m=2 w=0.65 l=0.15 mult=1 sa=0.265
+ sb=0.265 sd=0.28 topography=normal area=0.063 perim=1.14
MMNB0 Y B1 VGND VNB nfet_01v8 m=2 w=0.65 l=0.15 mult=1 sa=0.265
+ sb=0.265 sd=0.28 topography=normal area=0.063 perim=1.14
MMNC0 Y C1 VGND VNB nfet_01v8 m=2 w=0.65 l=0.15 mult=1 sa=0.265
+ sb=0.265 sd=0.28 topography=normal area=0.063 perim=1.14
MMND0 Y D1 VGND VNB nfet_01v8 m=2 w=0.65 l=0.15 mult=1 sa=0.265
+ sb=0.265 sd=0.28 topography=normal area=0.063 perim=1.14
.ENDS

.SUBCKT sky130_fd_sc_hd__a2111oi_4 A1 A2 B1 C1 D1 VGND VNB VPB VPWR Y
MMPA0 pndA A1 VPWR VPB pfet_01v8_hvt m=4 w=1.0 l=0.15 mult=1 sa=0.265
+ sb=0.265 sd=0.28 topography=normal area=0.063 perim=1.14
MMPA1 pndA A2 VPWR VPB pfet_01v8_hvt m=4 w=1.0 l=0.15 mult=1 sa=0.265
+ sb=0.265 sd=0.28 topography=normal area=0.063 perim=1.14
MMPB0 pndB B1 pndA VPB pfet_01v8_hvt m=4 w=1.0 l=0.15 mult=1 sa=0.265
+ sb=0.265 sd=0.28 topography=normal area=0.063 perim=1.14
MMPC0 pndC C1 pndB VPB pfet_01v8_hvt m=4 w=1.0 l=0.15 mult=1 sa=0.265
+ sb=0.265 sd=0.28 topography=normal area=0.063 perim=1.14
MMPD0 Y D1 pndC VPB pfet_01v8_hvt m=4 w=1.0 l=0.15 mult=1 sa=0.265
+ sb=0.265 sd=0.28 topography=normal area=0.063 perim=1.14
MMNA0 Y A1 sndA1 VNB nfet_01v8 m=4 w=0.65 l=0.15 mult=1 sa=0.265
+ sb=0.265 sd=0.28 topography=normal area=0.063 perim=1.14
MMNA1 sndA1 A2 VGND VNB nfet_01v8 m=4 w=0.65 l=0.15 mult=1 sa=0.265
+ sb=0.265 sd=0.28 topography=normal area=0.063 perim=1.14
MMNB0 Y B1 VGND VNB nfet_01v8 m=4 w=0.65 l=0.15 mult=1 sa=0.265
+ sb=0.265 sd=0.28 topography=normal area=0.063 perim=1.14
MMNC0 Y C1 VGND VNB nfet_01v8 m=4 w=0.65 l=0.15 mult=1 sa=0.265
+ sb=0.265 sd=0.28 topography=normal area=0.063 perim=1.14
MMND0 Y D1 VGND VNB nfet_01v8 m=4 w=0.65 l=0.15 mult=1 sa=0.265
+ sb=0.265 sd=0.28 topography=normal area=0.063 perim=1.14
.ENDS

.SUBCKT sky130_fd_sc_hd__and2_0 A B VGND VNB VPB VPWR X
MMP0 y A VPWR VPB pfet_01v8_hvt m=1 w=0.42 l=0.15 mult=1 sa=0.265
+ sb=0.265 sd=0.28 topography=normal area=0.063 perim=1.14
MMP1 y B VPWR VPB pfet_01v8_hvt m=1 w=0.42 l=0.15 mult=1 sa=0.265
+ sb=0.265 sd=0.28 topography=normal area=0.063 perim=1.14
MMIP0 X y VPWR VPB pfet_01v8_hvt m=1 w=0.64 l=0.15 mult=1 sa=0.265
+ sb=0.265 sd=0.28 topography=normal area=0.063 perim=1.14
MMN0 y A sndA VNB nfet_01v8 m=1 w=0.42 l=0.15 mult=1 sa=0.265 sb=0.265
+ sd=0.28 topography=normal area=0.063 perim=1.14
MMN1 sndA B VGND VNB nfet_01v8 m=1 w=0.42 l=0.15 mult=1 sa=0.265
+ sb=0.265 sd=0.28 topography=normal area=0.063 perim=1.14
MMIN0 X y VGND VNB nfet_01v8 m=1 w=0.42 l=0.15 mult=1 sa=0.265
+ sb=0.265 sd=0.28 topography=normal area=0.063 perim=1.14
.ENDS

.SUBCKT sky130_fd_sc_hd__and2_1 A B VGND VNB VPB VPWR X
MMP0 y A VPWR VPB pfet_01v8_hvt m=1 w=0.42 l=0.15 mult=1 sa=0.265
+ sb=0.265 sd=0.28 topography=normal area=0.063 perim=1.14
MMP1 y B VPWR VPB pfet_01v8_hvt m=1 w=0.42 l=0.15 mult=1 sa=0.265
+ sb=0.265 sd=0.28 topography=normal area=0.063 perim=1.14
MMIP0 X y VPWR VPB pfet_01v8_hvt m=1 w=1.0 l=0.15 mult=1 sa=0.265
+ sb=0.265 sd=0.28 topography=normal area=0.063 perim=1.14
MMN0 y A sndA VNB nfet_01v8 m=1 w=0.42 l=0.15 mult=1 sa=0.265 sb=0.265
+ sd=0.28 topography=normal area=0.063 perim=1.14
MMN1 sndA B VGND VNB nfet_01v8 m=1 w=0.42 l=0.15 mult=1 sa=0.265
+ sb=0.265 sd=0.28 topography=normal area=0.063 perim=1.14
MMIN0 X y VGND VNB nfet_01v8 m=1 w=0.65 l=0.15 mult=1 sa=0.265
+ sb=0.265 sd=0.28 topography=normal area=0.063 perim=1.14
.ENDS

.SUBCKT sky130_fd_sc_hd__and2_2 A B VGND VNB VPB VPWR X
MMP0 y A VPWR VPB pfet_01v8_hvt m=1 w=0.42 l=0.15 mult=1 sa=0.265
+ sb=0.265 sd=0.28 topography=normal area=0.063 perim=1.14
MMP1 y B VPWR VPB pfet_01v8_hvt m=1 w=0.42 l=0.15 mult=1 sa=0.265
+ sb=0.265 sd=0.28 topography=normal area=0.063 perim=1.14
MMIP0 X y VPWR VPB pfet_01v8_hvt m=2 w=1.0 l=0.15 mult=1 sa=0.265
+ sb=0.265 sd=0.28 topography=normal area=0.063 perim=1.14
MMN0 y A sndA VNB nfet_01v8 m=1 w=0.42 l=0.15 mult=1 sa=0.265 sb=0.265
+ sd=0.28 topography=normal area=0.063 perim=1.14
MMN1 sndA B VGND VNB nfet_01v8 m=1 w=0.42 l=0.15 mult=1 sa=0.265
+ sb=0.265 sd=0.28 topography=normal area=0.063 perim=1.14
MMIN0 X y VGND VNB nfet_01v8 m=2 w=0.65 l=0.15 mult=1 sa=0.265
+ sb=0.265 sd=0.28 topography=normal area=0.063 perim=1.14
.ENDS

.SUBCKT sky130_fd_sc_hd__and2_4 A B VGND VNB VPB VPWR X
MMP0 y A VPWR VPB pfet_01v8_hvt m=1 w=1.0 l=0.15 mult=1 sa=0.265
+ sb=0.265 sd=0.28 topography=normal area=0.063 perim=1.14
MMP1 y B VPWR VPB pfet_01v8_hvt m=1 w=1.0 l=0.15 mult=1 sa=0.265
+ sb=0.265 sd=0.28 topography=normal area=0.063 perim=1.14
MMIP0 X y VPWR VPB pfet_01v8_hvt m=4 w=1.0 l=0.15 mult=1 sa=0.265
+ sb=0.265 sd=0.28 topography=normal area=0.063 perim=1.14
MMN0 y A sndA VNB nfet_01v8 m=1 w=0.65 l=0.15 mult=1 sa=0.265 sb=0.265
+ sd=0.28 topography=normal area=0.063 perim=1.14
MMN1 sndA B VGND VNB nfet_01v8 m=1 w=0.65 l=0.15 mult=1 sa=0.265
+ sb=0.265 sd=0.28 topography=normal area=0.063 perim=1.14
MMIN0 X y VGND VNB nfet_01v8 m=4 w=0.65 l=0.15 mult=1 sa=0.265
+ sb=0.265 sd=0.28 topography=normal area=0.063 perim=1.14
.ENDS

.SUBCKT sky130_fd_sc_hd__and2b_1 A_N B VGND VNB VPB VPWR X
MMP0 y A VPWR VPB pfet_01v8_hvt m=1 w=0.42 l=0.15 mult=1 sa=0.265
+ sb=0.265 sd=0.28 topography=normal area=0.063 perim=1.14
MMP1 y B VPWR VPB pfet_01v8_hvt m=1 w=0.42 l=0.15 mult=1 sa=0.265
+ sb=0.265 sd=0.28 topography=normal area=0.063 perim=1.14
MMIP0 A A_N VPWR VPB pfet_01v8_hvt m=1 w=0.42 l=0.15 mult=1 sa=0.265
+ sb=0.265 sd=0.28 topography=normal area=0.063 perim=1.14
MMIP1 X y VPWR VPB pfet_01v8_hvt m=1 w=1.0 l=0.15 mult=1 sa=0.265
+ sb=0.265 sd=0.28 topography=normal area=0.063 perim=1.14
MMN0 y A sndA VNB nfet_01v8 m=1 w=0.42 l=0.15 mult=1 sa=0.265 sb=0.265
+ sd=0.28 topography=normal area=0.063 perim=1.14
MMN1 sndA B VGND VNB nfet_01v8 m=1 w=0.42 l=0.15 mult=1 sa=0.265
+ sb=0.265 sd=0.28 topography=normal area=0.063 perim=1.14
MMIN0 A A_N VGND VNB nfet_01v8 m=1 w=0.42 l=0.15 mult=1 sa=0.265
+ sb=0.265 sd=0.28 topography=normal area=0.063 perim=1.14
MMIN1 X y VGND VNB nfet_01v8 m=1 w=0.65 l=0.15 mult=1 sa=0.265
+ sb=0.265 sd=0.28 topography=normal area=0.063 perim=1.14
.ENDS

.SUBCKT sky130_fd_sc_hd__and2b_2 A_N B VGND VNB VPB VPWR X
MMP0 y A VPWR VPB pfet_01v8_hvt m=1 w=0.42 l=0.15 mult=1 sa=0.265
+ sb=0.265 sd=0.28 topography=normal area=0.063 perim=1.14
MMP1 y B VPWR VPB pfet_01v8_hvt m=1 w=0.42 l=0.15 mult=1 sa=0.265
+ sb=0.265 sd=0.28 topography=normal area=0.063 perim=1.14
MMIP0 A A_N VPWR VPB pfet_01v8_hvt m=1 w=0.42 l=0.15 mult=1 sa=0.265
+ sb=0.265 sd=0.28 topography=normal area=0.063 perim=1.14
MMIP1 X y VPWR VPB pfet_01v8_hvt m=2 w=1.0 l=0.15 mult=1 sa=0.265
+ sb=0.265 sd=0.28 topography=normal area=0.063 perim=1.14
MMN0 y A sndA VNB nfet_01v8 m=1 w=0.42 l=0.15 mult=1 sa=0.265 sb=0.265
+ sd=0.28 topography=normal area=0.063 perim=1.14
MMN1 sndA B VGND VNB nfet_01v8 m=1 w=0.42 l=0.15 mult=1 sa=0.265
+ sb=0.265 sd=0.28 topography=normal area=0.063 perim=1.14
MMIN0 A A_N VGND VNB nfet_01v8 m=1 w=0.42 l=0.15 mult=1 sa=0.265
+ sb=0.265 sd=0.28 topography=normal area=0.063 perim=1.14
MMIN1 X y VGND VNB nfet_01v8 m=2 w=0.65 l=0.15 mult=1 sa=0.265
+ sb=0.265 sd=0.28 topography=normal area=0.063 perim=1.14
.ENDS

.SUBCKT sky130_fd_sc_hd__and2b_4 A_N B VGND VNB VPB VPWR X
MMP0 y A VPWR VPB pfet_01v8_hvt m=1 w=1.0 l=0.15 mult=1 sa=0.265
+ sb=0.265 sd=0.28 topography=normal area=0.063 perim=1.14
MMP1 y B VPWR VPB pfet_01v8_hvt m=1 w=1.0 l=0.15 mult=1 sa=0.265
+ sb=0.265 sd=0.28 topography=normal area=0.063 perim=1.14
MMIP0 A A_N VPWR VPB pfet_01v8_hvt m=1 w=0.42 l=0.15 mult=1 sa=0.265
+ sb=0.265 sd=0.28 topography=normal area=0.063 perim=1.14
MMIP1 X y VPWR VPB pfet_01v8_hvt m=4 w=1.0 l=0.15 mult=1 sa=0.265
+ sb=0.265 sd=0.28 topography=normal area=0.063 perim=1.14
MMN0 y A sndA VNB nfet_01v8 m=1 w=0.65 l=0.15 mult=1 sa=0.265 sb=0.265
+ sd=0.28 topography=normal area=0.063 perim=1.14
MMN1 sndA B VGND VNB nfet_01v8 m=1 w=0.65 l=0.15 mult=1 sa=0.265
+ sb=0.265 sd=0.28 topography=normal area=0.063 perim=1.14
MMIN0 A A_N VGND VNB nfet_01v8 m=1 w=0.42 l=0.15 mult=1 sa=0.265
+ sb=0.265 sd=0.28 topography=normal area=0.063 perim=1.14
MMIN1 X y VGND VNB nfet_01v8 m=4 w=0.65 l=0.15 mult=1 sa=0.265
+ sb=0.265 sd=0.28 topography=normal area=0.063 perim=1.14
.ENDS

.SUBCKT sky130_fd_sc_hd__and3_1 A B C VGND VNB VPB VPWR X
MMP0 y A VPWR VPB pfet_01v8_hvt m=1 w=0.42 l=0.15 mult=1 sa=0.265
+ sb=0.265 sd=0.28 topography=normal area=0.063 perim=1.14
MMP1 y B VPWR VPB pfet_01v8_hvt m=1 w=0.42 l=0.15 mult=1 sa=0.265
+ sb=0.265 sd=0.28 topography=normal area=0.063 perim=1.14
MMP2 y C VPWR VPB pfet_01v8_hvt m=1 w=0.42 l=0.15 mult=1 sa=0.265
+ sb=0.265 sd=0.28 topography=normal area=0.063 perim=1.14
MMIP0 X y VPWR VPB pfet_01v8_hvt m=1 w=1.0 l=0.15 mult=1 sa=0.265
+ sb=0.265 sd=0.28 topography=normal area=0.063 perim=1.14
MMN0 y A sndA VNB nfet_01v8 m=1 w=0.42 l=0.15 mult=1 sa=0.265 sb=0.265
+ sd=0.28 topography=normal area=0.063 perim=1.14
MMN1 sndA B sndB VNB nfet_01v8 m=1 w=0.42 l=0.15 mult=1 sa=0.265
+ sb=0.265 sd=0.28 topography=normal area=0.063 perim=1.14
MMN2 sndB C VGND VNB nfet_01v8 m=1 w=0.42 l=0.15 mult=1 sa=0.265
+ sb=0.265 sd=0.28 topography=normal area=0.063 perim=1.14
MMIN0 X y VGND VNB nfet_01v8 m=1 w=0.65 l=0.15 mult=1 sa=0.265
+ sb=0.265 sd=0.28 topography=normal area=0.063 perim=1.14
.ENDS

.SUBCKT sky130_fd_sc_hd__and3_2 A B C VGND VNB VPB VPWR X
MMP0 y A VPWR VPB pfet_01v8_hvt m=1 w=0.42 l=0.15 mult=1 sa=0.265
+ sb=0.265 sd=0.28 topography=normal area=0.063 perim=1.14
MMP1 y B VPWR VPB pfet_01v8_hvt m=1 w=0.42 l=0.15 mult=1 sa=0.265
+ sb=0.265 sd=0.28 topography=normal area=0.063 perim=1.14
MMP2 y C VPWR VPB pfet_01v8_hvt m=1 w=0.42 l=0.15 mult=1 sa=0.265
+ sb=0.265 sd=0.28 topography=normal area=0.063 perim=1.14
MMIP0 X y VPWR VPB pfet_01v8_hvt m=2 w=1.0 l=0.15 mult=1 sa=0.265
+ sb=0.265 sd=0.28 topography=normal area=0.063 perim=1.14
MMN0 y A sndA VNB nfet_01v8 m=1 w=0.42 l=0.15 mult=1 sa=0.265 sb=0.265
+ sd=0.28 topography=normal area=0.063 perim=1.14
MMN1 sndA B sndB VNB nfet_01v8 m=1 w=0.42 l=0.15 mult=1 sa=0.265
+ sb=0.265 sd=0.28 topography=normal area=0.063 perim=1.14
MMN2 sndB C VGND VNB nfet_01v8 m=1 w=0.42 l=0.15 mult=1 sa=0.265
+ sb=0.265 sd=0.28 topography=normal area=0.063 perim=1.14
MMIN0 X y VGND VNB nfet_01v8 m=2 w=0.65 l=0.15 mult=1 sa=0.265
+ sb=0.265 sd=0.28 topography=normal area=0.063 perim=1.14
.ENDS

.SUBCKT sky130_fd_sc_hd__and3_4 A B C VGND VNB VPB VPWR X
MMP0 y A VPWR VPB pfet_01v8_hvt m=1 w=1.0 l=0.15 mult=1 sa=0.265
+ sb=0.265 sd=0.28 topography=normal area=0.063 perim=1.14
MMP1 y B VPWR VPB pfet_01v8_hvt m=1 w=1.0 l=0.15 mult=1 sa=0.265
+ sb=0.265 sd=0.28 topography=normal area=0.063 perim=1.14
MMP2 y C VPWR VPB pfet_01v8_hvt m=1 w=1.0 l=0.15 mult=1 sa=0.265
+ sb=0.265 sd=0.28 topography=normal area=0.063 perim=1.14
MMIP0 X y VPWR VPB pfet_01v8_hvt m=4 w=1.0 l=0.15 mult=1 sa=0.265
+ sb=0.265 sd=0.28 topography=normal area=0.063 perim=1.14
MMN0 y A sndA VNB nfet_01v8 m=1 w=0.65 l=0.15 mult=1 sa=0.265 sb=0.265
+ sd=0.28 topography=normal area=0.063 perim=1.14
MMN1 sndA B sndB VNB nfet_01v8 m=1 w=0.65 l=0.15 mult=1 sa=0.265
+ sb=0.265 sd=0.28 topography=normal area=0.063 perim=1.14
MMN2 sndB C VGND VNB nfet_01v8 m=1 w=0.65 l=0.15 mult=1 sa=0.265
+ sb=0.265 sd=0.28 topography=normal area=0.063 perim=1.14
MMIN0 X y VGND VNB nfet_01v8 m=4 w=0.65 l=0.15 mult=1 sa=0.265
+ sb=0.265 sd=0.28 topography=normal area=0.063 perim=1.14
.ENDS

.SUBCKT sky130_fd_sc_hd__and3b_1 A_N B C VGND VNB VPB VPWR X
MMP0 y A VPWR VPB pfet_01v8_hvt m=1 w=0.42 l=0.15 mult=1 sa=0.265
+ sb=0.265 sd=0.28 topography=normal area=0.063 perim=1.14
MMP1 y B VPWR VPB pfet_01v8_hvt m=1 w=0.42 l=0.15 mult=1 sa=0.265
+ sb=0.265 sd=0.28 topography=normal area=0.063 perim=1.14
MMP2 y C VPWR VPB pfet_01v8_hvt m=1 w=0.42 l=0.15 mult=1 sa=0.265
+ sb=0.265 sd=0.28 topography=normal area=0.063 perim=1.14
MMIP0 A A_N VPWR VPB pfet_01v8_hvt m=1 w=0.42 l=0.15 mult=1 sa=0.265
+ sb=0.265 sd=0.28 topography=normal area=0.063 perim=1.14
MMIP1 X y VPWR VPB pfet_01v8_hvt m=1 w=1.0 l=0.15 mult=1 sa=0.265
+ sb=0.265 sd=0.28 topography=normal area=0.063 perim=1.14
MMN0 y A sndA VNB nfet_01v8 m=1 w=0.42 l=0.15 mult=1 sa=0.265 sb=0.265
+ sd=0.28 topography=normal area=0.063 perim=1.14
MMN1 sndA B sndB VNB nfet_01v8 m=1 w=0.42 l=0.15 mult=1 sa=0.265
+ sb=0.265 sd=0.28 topography=normal area=0.063 perim=1.14
MMN2 sndB C VGND VNB nfet_01v8 m=1 w=0.42 l=0.15 mult=1 sa=0.265
+ sb=0.265 sd=0.28 topography=normal area=0.063 perim=1.14
MMIN0 A A_N VGND VNB nfet_01v8 m=1 w=0.42 l=0.15 mult=1 sa=0.265
+ sb=0.265 sd=0.28 topography=normal area=0.063 perim=1.14
MMIN1 X y VGND VNB nfet_01v8 m=1 w=0.65 l=0.15 mult=1 sa=0.265
+ sb=0.265 sd=0.28 topography=normal area=0.063 perim=1.14
.ENDS

.SUBCKT sky130_fd_sc_hd__and3b_2 A_N B C VGND VNB VPB VPWR X
MMP0 y A VPWR VPB pfet_01v8_hvt m=1 w=0.42 l=0.15 mult=1 sa=0.265
+ sb=0.265 sd=0.28 topography=normal area=0.063 perim=1.14
MMP1 y B VPWR VPB pfet_01v8_hvt m=1 w=0.42 l=0.15 mult=1 sa=0.265
+ sb=0.265 sd=0.28 topography=normal area=0.063 perim=1.14
MMP2 y C VPWR VPB pfet_01v8_hvt m=1 w=0.42 l=0.15 mult=1 sa=0.265
+ sb=0.265 sd=0.28 topography=normal area=0.063 perim=1.14
MMIP0 A A_N VPWR VPB pfet_01v8_hvt m=1 w=0.42 l=0.15 mult=1 sa=0.265
+ sb=0.265 sd=0.28 topography=normal area=0.063 perim=1.14
MMIP1 X y VPWR VPB pfet_01v8_hvt m=2 w=1.0 l=0.15 mult=1 sa=0.265
+ sb=0.265 sd=0.28 topography=normal area=0.063 perim=1.14
MMN0 y A sndA VNB nfet_01v8 m=1 w=0.42 l=0.15 mult=1 sa=0.265 sb=0.265
+ sd=0.28 topography=normal area=0.063 perim=1.14
MMN1 sndA B sndB VNB nfet_01v8 m=1 w=0.42 l=0.15 mult=1 sa=0.265
+ sb=0.265 sd=0.28 topography=normal area=0.063 perim=1.14
MMN2 sndB C VGND VNB nfet_01v8 m=1 w=0.42 l=0.15 mult=1 sa=0.265
+ sb=0.265 sd=0.28 topography=normal area=0.063 perim=1.14
MMIN0 A A_N VGND VNB nfet_01v8 m=1 w=0.42 l=0.15 mult=1 sa=0.265
+ sb=0.265 sd=0.28 topography=normal area=0.063 perim=1.14
MMIN1 X y VGND VNB nfet_01v8 m=2 w=0.65 l=0.15 mult=1 sa=0.265
+ sb=0.265 sd=0.28 topography=normal area=0.063 perim=1.14
.ENDS

.SUBCKT sky130_fd_sc_hd__and3b_4 A_N B C VGND VNB VPB VPWR X
MMP0 y A VPWR VPB pfet_01v8_hvt m=1 w=1.0 l=0.15 mult=1 sa=0.265
+ sb=0.265 sd=0.28 topography=normal area=0.063 perim=1.14
MMP1 y B VPWR VPB pfet_01v8_hvt m=1 w=1.0 l=0.15 mult=1 sa=0.265
+ sb=0.265 sd=0.28 topography=normal area=0.063 perim=1.14
MMP2 y C VPWR VPB pfet_01v8_hvt m=1 w=1.0 l=0.15 mult=1 sa=0.265
+ sb=0.265 sd=0.28 topography=normal area=0.063 perim=1.14
MMIP0 A A_N VPWR VPB pfet_01v8_hvt m=1 w=0.42 l=0.15 mult=1 sa=0.265
+ sb=0.265 sd=0.28 topography=normal area=0.063 perim=1.14
MMIP1 X y VPWR VPB pfet_01v8_hvt m=4 w=1.0 l=0.15 mult=1 sa=0.265
+ sb=0.265 sd=0.28 topography=normal area=0.063 perim=1.14
MMN0 y A sndA VNB nfet_01v8 m=1 w=0.65 l=0.15 mult=1 sa=0.265 sb=0.265
+ sd=0.28 topography=normal area=0.063 perim=1.14
MMN1 sndA B sndB VNB nfet_01v8 m=1 w=0.65 l=0.15 mult=1 sa=0.265
+ sb=0.265 sd=0.28 topography=normal area=0.063 perim=1.14
MMN2 sndB C VGND VNB nfet_01v8 m=1 w=0.65 l=0.15 mult=1 sa=0.265
+ sb=0.265 sd=0.28 topography=normal area=0.063 perim=1.14
MMIN0 A A_N VGND VNB nfet_01v8 m=1 w=0.42 l=0.15 mult=1 sa=0.265
+ sb=0.265 sd=0.28 topography=normal area=0.063 perim=1.14
MMIN1 X y VGND VNB nfet_01v8 m=4 w=0.65 l=0.15 mult=1 sa=0.265
+ sb=0.265 sd=0.28 topography=normal area=0.063 perim=1.14
.ENDS

.SUBCKT sky130_fd_sc_hd__and4_1 A B C D VGND VNB VPB VPWR X
MMP0 y A VPWR VPB pfet_01v8_hvt m=1 w=0.42 l=0.15 mult=1 sa=0.265
+ sb=0.265 sd=0.28 topography=normal area=0.063 perim=1.14
MMP1 y B VPWR VPB pfet_01v8_hvt m=1 w=0.42 l=0.15 mult=1 sa=0.265
+ sb=0.265 sd=0.28 topography=normal area=0.063 perim=1.14
MMP2 y C VPWR VPB pfet_01v8_hvt m=1 w=0.42 l=0.15 mult=1 sa=0.265
+ sb=0.265 sd=0.28 topography=normal area=0.063 perim=1.14
MMP3 y D VPWR VPB pfet_01v8_hvt m=1 w=0.42 l=0.15 mult=1 sa=0.265
+ sb=0.265 sd=0.28 topography=normal area=0.063 perim=1.14
MMIP0 X y VPWR VPB pfet_01v8_hvt m=1 w=1.0 l=0.15 mult=1 sa=0.265
+ sb=0.265 sd=0.28 topography=normal area=0.063 perim=1.14
MMN0 y A sndA VNB nfet_01v8 m=1 w=0.42 l=0.15 mult=1 sa=0.265 sb=0.265
+ sd=0.28 topography=normal area=0.063 perim=1.14
MMN1 sndA B sndB VNB nfet_01v8 m=1 w=0.42 l=0.15 mult=1 sa=0.265
+ sb=0.265 sd=0.28 topography=normal area=0.063 perim=1.14
MMN2 sndB C sndC VNB nfet_01v8 m=1 w=0.42 l=0.15 mult=1 sa=0.265
+ sb=0.265 sd=0.28 topography=normal area=0.063 perim=1.14
MMN3 sndC D VGND VNB nfet_01v8 m=1 w=0.42 l=0.15 mult=1 sa=0.265
+ sb=0.265 sd=0.28 topography=normal area=0.063 perim=1.14
MMIN0 X y VGND VNB nfet_01v8 m=1 w=0.65 l=0.15 mult=1 sa=0.265
+ sb=0.265 sd=0.28 topography=normal area=0.063 perim=1.14
.ENDS

.SUBCKT sky130_fd_sc_hd__and4_2 A B C D VGND VNB VPB VPWR X
MMP0 y A VPWR VPB pfet_01v8_hvt m=1 w=0.42 l=0.15 mult=1 sa=0.265
+ sb=0.265 sd=0.28 topography=normal area=0.063 perim=1.14
MMP1 y B VPWR VPB pfet_01v8_hvt m=1 w=0.42 l=0.15 mult=1 sa=0.265
+ sb=0.265 sd=0.28 topography=normal area=0.063 perim=1.14
MMP2 y C VPWR VPB pfet_01v8_hvt m=1 w=0.42 l=0.15 mult=1 sa=0.265
+ sb=0.265 sd=0.28 topography=normal area=0.063 perim=1.14
MMP3 y D VPWR VPB pfet_01v8_hvt m=1 w=0.42 l=0.15 mult=1 sa=0.265
+ sb=0.265 sd=0.28 topography=normal area=0.063 perim=1.14
MMIP0 X y VPWR VPB pfet_01v8_hvt m=2 w=1.0 l=0.15 mult=1 sa=0.265
+ sb=0.265 sd=0.28 topography=normal area=0.063 perim=1.14
MMN0 y A sndA VNB nfet_01v8 m=1 w=0.42 l=0.15 mult=1 sa=0.265 sb=0.265
+ sd=0.28 topography=normal area=0.063 perim=1.14
MMN1 sndA B sndB VNB nfet_01v8 m=1 w=0.42 l=0.15 mult=1 sa=0.265
+ sb=0.265 sd=0.28 topography=normal area=0.063 perim=1.14
MMN2 sndB C sndC VNB nfet_01v8 m=1 w=0.42 l=0.15 mult=1 sa=0.265
+ sb=0.265 sd=0.28 topography=normal area=0.063 perim=1.14
MMN3 sndC D VGND VNB nfet_01v8 m=1 w=0.42 l=0.15 mult=1 sa=0.265
+ sb=0.265 sd=0.28 topography=normal area=0.063 perim=1.14
MMIN0 X y VGND VNB nfet_01v8 m=2 w=0.65 l=0.15 mult=1 sa=0.265
+ sb=0.265 sd=0.28 topography=normal area=0.063 perim=1.14
.ENDS

.SUBCKT sky130_fd_sc_hd__and4_4 A B C D VGND VNB VPB VPWR X
MMP0 y A VPWR VPB pfet_01v8_hvt m=1 w=1.0 l=0.15 mult=1 sa=0.265
+ sb=0.265 sd=0.28 topography=normal area=0.063 perim=1.14
MMP1 y B VPWR VPB pfet_01v8_hvt m=1 w=1.0 l=0.15 mult=1 sa=0.265
+ sb=0.265 sd=0.28 topography=normal area=0.063 perim=1.14
MMP2 y C VPWR VPB pfet_01v8_hvt m=1 w=1.0 l=0.15 mult=1 sa=0.265
+ sb=0.265 sd=0.28 topography=normal area=0.063 perim=1.14
MMP3 y D VPWR VPB pfet_01v8_hvt m=1 w=1.0 l=0.15 mult=1 sa=0.265
+ sb=0.265 sd=0.28 topography=normal area=0.063 perim=1.14
MMIP0 X y VPWR VPB pfet_01v8_hvt m=4 w=1.0 l=0.15 mult=1 sa=0.265
+ sb=0.265 sd=0.28 topography=normal area=0.063 perim=1.14
MMN0 y A sndA VNB nfet_01v8 m=1 w=0.65 l=0.15 mult=1 sa=0.265 sb=0.265
+ sd=0.28 topography=normal area=0.063 perim=1.14
MMN1 sndA B sndB VNB nfet_01v8 m=1 w=0.65 l=0.15 mult=1 sa=0.265
+ sb=0.265 sd=0.28 topography=normal area=0.063 perim=1.14
MMN2 sndB C sndC VNB nfet_01v8 m=1 w=0.65 l=0.15 mult=1 sa=0.265
+ sb=0.265 sd=0.28 topography=normal area=0.063 perim=1.14
MMN3 sndC D VGND VNB nfet_01v8 m=1 w=0.65 l=0.15 mult=1 sa=0.265
+ sb=0.265 sd=0.28 topography=normal area=0.063 perim=1.14
MMIN0 X y VGND VNB nfet_01v8 m=4 w=0.65 l=0.15 mult=1 sa=0.265
+ sb=0.265 sd=0.28 topography=normal area=0.063 perim=1.14
.ENDS

.SUBCKT sky130_fd_sc_hd__and4b_1 A_N B C D VGND VNB VPB VPWR X
MMP0 y A VPWR VPB pfet_01v8_hvt m=1 w=0.42 l=0.15 mult=1 sa=0.265
+ sb=0.265 sd=0.28 topography=normal area=0.063 perim=1.14
MMP1 y B VPWR VPB pfet_01v8_hvt m=1 w=0.42 l=0.15 mult=1 sa=0.265
+ sb=0.265 sd=0.28 topography=normal area=0.063 perim=1.14
MMP2 y C VPWR VPB pfet_01v8_hvt m=1 w=0.42 l=0.15 mult=1 sa=0.265
+ sb=0.265 sd=0.28 topography=normal area=0.063 perim=1.14
MMP3 y D VPWR VPB pfet_01v8_hvt m=1 w=0.42 l=0.15 mult=1 sa=0.265
+ sb=0.265 sd=0.28 topography=normal area=0.063 perim=1.14
MMIP0 A A_N VPWR VPB pfet_01v8_hvt m=1 w=0.42 l=0.15 mult=1 sa=0.265
+ sb=0.265 sd=0.28 topography=normal area=0.063 perim=1.14
MMIP1 X y VPWR VPB pfet_01v8_hvt m=1 w=1.0 l=0.15 mult=1 sa=0.265
+ sb=0.265 sd=0.28 topography=normal area=0.063 perim=1.14
MMN0 y A sndA VNB nfet_01v8 m=1 w=0.42 l=0.15 mult=1 sa=0.265 sb=0.265
+ sd=0.28 topography=normal area=0.063 perim=1.14
MMN1 sndA B sndB VNB nfet_01v8 m=1 w=0.42 l=0.15 mult=1 sa=0.265
+ sb=0.265 sd=0.28 topography=normal area=0.063 perim=1.14
MMN2 sndB C sndC VNB nfet_01v8 m=1 w=0.42 l=0.15 mult=1 sa=0.265
+ sb=0.265 sd=0.28 topography=normal area=0.063 perim=1.14
MMN3 sndC D VGND VNB nfet_01v8 m=1 w=0.42 l=0.15 mult=1 sa=0.265
+ sb=0.265 sd=0.28 topography=normal area=0.063 perim=1.14
MMIN0 A A_N VGND VNB nfet_01v8 m=1 w=0.42 l=0.15 mult=1 sa=0.265
+ sb=0.265 sd=0.28 topography=normal area=0.063 perim=1.14
MMIN1 X y VGND VNB nfet_01v8 m=1 w=0.65 l=0.15 mult=1 sa=0.265
+ sb=0.265 sd=0.28 topography=normal area=0.063 perim=1.14
.ENDS

.SUBCKT sky130_fd_sc_hd__and4b_2 A_N B C D VGND VNB VPB VPWR X
MMP0 y A VPWR VPB pfet_01v8_hvt m=1 w=0.42 l=0.15 mult=1 sa=0.265
+ sb=0.265 sd=0.28 topography=normal area=0.063 perim=1.14
MMP1 y B VPWR VPB pfet_01v8_hvt m=1 w=0.42 l=0.15 mult=1 sa=0.265
+ sb=0.265 sd=0.28 topography=normal area=0.063 perim=1.14
MMP2 y C VPWR VPB pfet_01v8_hvt m=1 w=0.42 l=0.15 mult=1 sa=0.265
+ sb=0.265 sd=0.28 topography=normal area=0.063 perim=1.14
MMP3 y D VPWR VPB pfet_01v8_hvt m=1 w=0.42 l=0.15 mult=1 sa=0.265
+ sb=0.265 sd=0.28 topography=normal area=0.063 perim=1.14
MMIP0 A A_N VPWR VPB pfet_01v8_hvt m=1 w=0.42 l=0.15 mult=1 sa=0.265
+ sb=0.265 sd=0.28 topography=normal area=0.063 perim=1.14
MMIP1 X y VPWR VPB pfet_01v8_hvt m=2 w=1.0 l=0.15 mult=1 sa=0.265
+ sb=0.265 sd=0.28 topography=normal area=0.063 perim=1.14
MMN0 y A sndA VNB nfet_01v8 m=1 w=0.42 l=0.15 mult=1 sa=0.265 sb=0.265
+ sd=0.28 topography=normal area=0.063 perim=1.14
MMN1 sndA B sndB VNB nfet_01v8 m=1 w=0.42 l=0.15 mult=1 sa=0.265
+ sb=0.265 sd=0.28 topography=normal area=0.063 perim=1.14
MMN2 sndB C sndC VNB nfet_01v8 m=1 w=0.42 l=0.15 mult=1 sa=0.265
+ sb=0.265 sd=0.28 topography=normal area=0.063 perim=1.14
MMN3 sndC D VGND VNB nfet_01v8 m=1 w=0.42 l=0.15 mult=1 sa=0.265
+ sb=0.265 sd=0.28 topography=normal area=0.063 perim=1.14
MMIN0 A A_N VGND VNB nfet_01v8 m=1 w=0.42 l=0.15 mult=1 sa=0.265
+ sb=0.265 sd=0.28 topography=normal area=0.063 perim=1.14
MMIN1 X y VGND VNB nfet_01v8 m=2 w=0.65 l=0.15 mult=1 sa=0.265
+ sb=0.265 sd=0.28 topography=normal area=0.063 perim=1.14
.ENDS

.SUBCKT sky130_fd_sc_hd__and4b_4 A_N B C D VGND VNB VPB VPWR X
MMP0 y A VPWR VPB pfet_01v8_hvt m=1 w=1.0 l=0.15 mult=1 sa=0.265
+ sb=0.265 sd=0.28 topography=normal area=0.063 perim=1.14
MMP1 y B VPWR VPB pfet_01v8_hvt m=1 w=1.0 l=0.15 mult=1 sa=0.265
+ sb=0.265 sd=0.28 topography=normal area=0.063 perim=1.14
MMP2 y C VPWR VPB pfet_01v8_hvt m=1 w=1.0 l=0.15 mult=1 sa=0.265
+ sb=0.265 sd=0.28 topography=normal area=0.063 perim=1.14
MMP3 y D VPWR VPB pfet_01v8_hvt m=1 w=1.0 l=0.15 mult=1 sa=0.265
+ sb=0.265 sd=0.28 topography=normal area=0.063 perim=1.14
MMIP0 A A_N VPWR VPB pfet_01v8_hvt m=1 w=0.42 l=0.15 mult=1 sa=0.265
+ sb=0.265 sd=0.28 topography=normal area=0.063 perim=1.14
MMIP1 X y VPWR VPB pfet_01v8_hvt m=4 w=1.0 l=0.15 mult=1 sa=0.265
+ sb=0.265 sd=0.28 topography=normal area=0.063 perim=1.14
MMN0 y A sndA VNB nfet_01v8 m=1 w=0.65 l=0.15 mult=1 sa=0.265 sb=0.265
+ sd=0.28 topography=normal area=0.063 perim=1.14
MMN1 sndA B sndB VNB nfet_01v8 m=1 w=0.65 l=0.15 mult=1 sa=0.265
+ sb=0.265 sd=0.28 topography=normal area=0.063 perim=1.14
MMN2 sndB C sndC VNB nfet_01v8 m=1 w=0.65 l=0.15 mult=1 sa=0.265
+ sb=0.265 sd=0.28 topography=normal area=0.063 perim=1.14
MMN3 sndC D VGND VNB nfet_01v8 m=1 w=0.65 l=0.15 mult=1 sa=0.265
+ sb=0.265 sd=0.28 topography=normal area=0.063 perim=1.14
MMIN0 A A_N VGND VNB nfet_01v8 m=1 w=0.42 l=0.15 mult=1 sa=0.265
+ sb=0.265 sd=0.28 topography=normal area=0.063 perim=1.14
MMIN1 X y VGND VNB nfet_01v8 m=4 w=0.65 l=0.15 mult=1 sa=0.265
+ sb=0.265 sd=0.28 topography=normal area=0.063 perim=1.14
.ENDS

.SUBCKT sky130_fd_sc_hd__and4bb_1 A_N B_N C D VGND VNB VPB VPWR X
MMP0 y A VPWR VPB pfet_01v8_hvt m=1 w=0.42 l=0.15 mult=1 sa=0.265
+ sb=0.265 sd=0.28 topography=normal area=0.063 perim=1.14
MMP1 y B VPWR VPB pfet_01v8_hvt m=1 w=0.42 l=0.15 mult=1 sa=0.265
+ sb=0.265 sd=0.28 topography=normal area=0.063 perim=1.14
MMP2 y C VPWR VPB pfet_01v8_hvt m=1 w=0.42 l=0.15 mult=1 sa=0.265
+ sb=0.265 sd=0.28 topography=normal area=0.063 perim=1.14
MMP3 y D VPWR VPB pfet_01v8_hvt m=1 w=0.42 l=0.15 mult=1 sa=0.265
+ sb=0.265 sd=0.28 topography=normal area=0.063 perim=1.14
MMIP0 A A_N VPWR VPB pfet_01v8_hvt m=1 w=0.42 l=0.15 mult=1 sa=0.265
+ sb=0.265 sd=0.28 topography=normal area=0.063 perim=1.14
MMIP1 B B_N VPWR VPB pfet_01v8_hvt m=1 w=0.42 l=0.15 mult=1 sa=0.265
+ sb=0.265 sd=0.28 topography=normal area=0.063 perim=1.14
MMIP2 X y VPWR VPB pfet_01v8_hvt m=1 w=1.0 l=0.15 mult=1 sa=0.265
+ sb=0.265 sd=0.28 topography=normal area=0.063 perim=1.14
MMN0 y A sndA VNB nfet_01v8 m=1 w=0.42 l=0.15 mult=1 sa=0.265 sb=0.265
+ sd=0.28 topography=normal area=0.063 perim=1.14
MMN1 sndA B sndB VNB nfet_01v8 m=1 w=0.42 l=0.15 mult=1 sa=0.265
+ sb=0.265 sd=0.28 topography=normal area=0.063 perim=1.14
MMN2 sndB C sndC VNB nfet_01v8 m=1 w=0.42 l=0.15 mult=1 sa=0.265
+ sb=0.265 sd=0.28 topography=normal area=0.063 perim=1.14
MMN3 sndC D VGND VNB nfet_01v8 m=1 w=0.42 l=0.15 mult=1 sa=0.265
+ sb=0.265 sd=0.28 topography=normal area=0.063 perim=1.14
MMIN0 A A_N VGND VNB nfet_01v8 m=1 w=0.42 l=0.15 mult=1 sa=0.265
+ sb=0.265 sd=0.28 topography=normal area=0.063 perim=1.14
MMIN1 B B_N VGND VNB nfet_01v8 m=1 w=0.42 l=0.15 mult=1 sa=0.265
+ sb=0.265 sd=0.28 topography=normal area=0.063 perim=1.14
MMIN2 X y VGND VNB nfet_01v8 m=1 w=0.65 l=0.15 mult=1 sa=0.265
+ sb=0.265 sd=0.28 topography=normal area=0.063 perim=1.14
.ENDS

.SUBCKT sky130_fd_sc_hd__and4bb_2 A_N B_N C D VGND VNB VPB VPWR X
MMP0 y A VPWR VPB pfet_01v8_hvt m=1 w=0.42 l=0.15 mult=1 sa=0.265
+ sb=0.265 sd=0.28 topography=normal area=0.063 perim=1.14
MMP1 y B VPWR VPB pfet_01v8_hvt m=1 w=0.42 l=0.15 mult=1 sa=0.265
+ sb=0.265 sd=0.28 topography=normal area=0.063 perim=1.14
MMP2 y C VPWR VPB pfet_01v8_hvt m=1 w=0.42 l=0.15 mult=1 sa=0.265
+ sb=0.265 sd=0.28 topography=normal area=0.063 perim=1.14
MMP3 y D VPWR VPB pfet_01v8_hvt m=1 w=0.42 l=0.15 mult=1 sa=0.265
+ sb=0.265 sd=0.28 topography=normal area=0.063 perim=1.14
MMIP0 A A_N VPWR VPB pfet_01v8_hvt m=1 w=0.42 l=0.15 mult=1 sa=0.265
+ sb=0.265 sd=0.28 topography=normal area=0.063 perim=1.14
MMIP1 B B_N VPWR VPB pfet_01v8_hvt m=1 w=0.42 l=0.15 mult=1 sa=0.265
+ sb=0.265 sd=0.28 topography=normal area=0.063 perim=1.14
MMIP2 X y VPWR VPB pfet_01v8_hvt m=2 w=1.0 l=0.15 mult=1 sa=0.265
+ sb=0.265 sd=0.28 topography=normal area=0.063 perim=1.14
MMN0 y A sndA VNB nfet_01v8 m=1 w=0.42 l=0.15 mult=1 sa=0.265 sb=0.265
+ sd=0.28 topography=normal area=0.063 perim=1.14
MMN1 sndA B sndB VNB nfet_01v8 m=1 w=0.42 l=0.15 mult=1 sa=0.265
+ sb=0.265 sd=0.28 topography=normal area=0.063 perim=1.14
MMN2 sndB C sndC VNB nfet_01v8 m=1 w=0.42 l=0.15 mult=1 sa=0.265
+ sb=0.265 sd=0.28 topography=normal area=0.063 perim=1.14
MMN3 sndC D VGND VNB nfet_01v8 m=1 w=0.42 l=0.15 mult=1 sa=0.265
+ sb=0.265 sd=0.28 topography=normal area=0.063 perim=1.14
MMIN0 A A_N VGND VNB nfet_01v8 m=1 w=0.42 l=0.15 mult=1 sa=0.265
+ sb=0.265 sd=0.28 topography=normal area=0.063 perim=1.14
MMIN1 B B_N VGND VNB nfet_01v8 m=1 w=0.42 l=0.15 mult=1 sa=0.265
+ sb=0.265 sd=0.28 topography=normal area=0.063 perim=1.14
MMIN2 X y VGND VNB nfet_01v8 m=2 w=0.65 l=0.15 mult=1 sa=0.265
+ sb=0.265 sd=0.28 topography=normal area=0.063 perim=1.14
.ENDS

.SUBCKT sky130_fd_sc_hd__and4bb_4 A_N B_N C D VGND VNB VPB VPWR X
MMP0 y A VPWR VPB pfet_01v8_hvt m=1 w=1.0 l=0.15 mult=1 sa=0.265
+ sb=0.265 sd=0.28 topography=normal area=0.063 perim=1.14
MMP1 y B VPWR VPB pfet_01v8_hvt m=1 w=1.0 l=0.15 mult=1 sa=0.265
+ sb=0.265 sd=0.28 topography=normal area=0.063 perim=1.14
MMP2 y C VPWR VPB pfet_01v8_hvt m=1 w=1.0 l=0.15 mult=1 sa=0.265
+ sb=0.265 sd=0.28 topography=normal area=0.063 perim=1.14
MMP3 y D VPWR VPB pfet_01v8_hvt m=1 w=1.0 l=0.15 mult=1 sa=0.265
+ sb=0.265 sd=0.28 topography=normal area=0.063 perim=1.14
MMIP0 A A_N VPWR VPB pfet_01v8_hvt m=1 w=0.42 l=0.15 mult=1 sa=0.265
+ sb=0.265 sd=0.28 topography=normal area=0.063 perim=1.14
MMIP1 B B_N VPWR VPB pfet_01v8_hvt m=1 w=0.42 l=0.15 mult=1 sa=0.265
+ sb=0.265 sd=0.28 topography=normal area=0.063 perim=1.14
MMIP2 X y VPWR VPB pfet_01v8_hvt m=4 w=1.0 l=0.15 mult=1 sa=0.265
+ sb=0.265 sd=0.28 topography=normal area=0.063 perim=1.14
MMN0 y A sndA VNB nfet_01v8 m=1 w=0.65 l=0.15 mult=1 sa=0.265 sb=0.265
+ sd=0.28 topography=normal area=0.063 perim=1.14
MMN1 sndA B sndB VNB nfet_01v8 m=1 w=0.65 l=0.15 mult=1 sa=0.265
+ sb=0.265 sd=0.28 topography=normal area=0.063 perim=1.14
MMN2 sndB C sndC VNB nfet_01v8 m=1 w=0.65 l=0.15 mult=1 sa=0.265
+ sb=0.265 sd=0.28 topography=normal area=0.063 perim=1.14
MMN3 sndC D VGND VNB nfet_01v8 m=1 w=0.65 l=0.15 mult=1 sa=0.265
+ sb=0.265 sd=0.28 topography=normal area=0.063 perim=1.14
MMIN0 A A_N VGND VNB nfet_01v8 m=1 w=0.42 l=0.15 mult=1 sa=0.265
+ sb=0.265 sd=0.28 topography=normal area=0.063 perim=1.14
MMIN1 B B_N VGND VNB nfet_01v8 m=1 w=0.42 l=0.15 mult=1 sa=0.265
+ sb=0.265 sd=0.28 topography=normal area=0.063 perim=1.14
MMIN2 X y VGND VNB nfet_01v8 m=4 w=0.65 l=0.15 mult=1 sa=0.265
+ sb=0.265 sd=0.28 topography=normal area=0.063 perim=1.14
.ENDS

.SUBCKT sky130_fd_sc_hd__buf_1 A VGND VNB VPB VPWR X
MMIN1 Ab A VGND VNB nfet_01v8 m=1 w=0.52 l=0.15 mult=1 sa=0.265
+ sb=0.265 sd=0.28 topography=normal area=0.063 perim=1.14
MMIN2 X Ab VGND VNB nfet_01v8 m=1 w=0.52 l=0.15 mult=1 sa=0.265
+ sb=0.265 sd=0.28 topography=normal area=0.063 perim=1.14
MMIP1 Ab A VPWR VPB pfet_01v8_hvt m=1 w=0.79 l=0.15 mult=1 sa=0.265
+ sb=0.265 sd=0.28 topography=normal area=0.063 perim=1.14
MMIP2 X Ab VPWR VPB pfet_01v8_hvt m=1 w=0.79 l=0.15 mult=1 sa=0.265
+ sb=0.265 sd=0.28 topography=normal area=0.063 perim=1.14
.ENDS

.SUBCKT sky130_fd_sc_hd__buf_2 A VGND VNB VPB VPWR X
MMIN1 Ab A VGND VNB nfet_01v8 m=1 w=0.42 l=0.15 mult=1 sa=0.265
+ sb=0.265 sd=0.28 topography=normal area=0.063 perim=1.14
MMIN2 X Ab VGND VNB nfet_01v8 m=2 w=0.65 l=0.15 mult=1 sa=0.265
+ sb=0.265 sd=0.28 topography=normal area=0.063 perim=1.14
MMIP1 Ab A VPWR VPB pfet_01v8_hvt m=1 w=0.64 l=0.15 mult=1 sa=0.265
+ sb=0.265 sd=0.28 topography=normal area=0.063 perim=1.14
MMIP2 X Ab VPWR VPB pfet_01v8_hvt m=2 w=1.0 l=0.15 mult=1 sa=0.265
+ sb=0.265 sd=0.28 topography=normal area=0.063 perim=1.14
.ENDS

.SUBCKT sky130_fd_sc_hd__buf_4 A VGND VNB VPB VPWR X
MMIN1 Ab A VGND VNB nfet_01v8 m=1 w=0.65 l=0.15 mult=1 sa=0.265
+ sb=0.265 sd=0.28 topography=normal area=0.063 perim=1.14
MMIN2 X Ab VGND VNB nfet_01v8 m=4 w=0.65 l=0.15 mult=1 sa=0.265
+ sb=0.265 sd=0.28 topography=normal area=0.063 perim=1.14
MMIP1 Ab A VPWR VPB pfet_01v8_hvt m=1 w=1.0 l=0.15 mult=1 sa=0.265
+ sb=0.265 sd=0.28 topography=normal area=0.063 perim=1.14
MMIP2 X Ab VPWR VPB pfet_01v8_hvt m=4 w=1.0 l=0.15 mult=1 sa=0.265
+ sb=0.265 sd=0.28 topography=normal area=0.063 perim=1.14
.ENDS

.SUBCKT sky130_fd_sc_hd__buf_6 A VGND VNB VPB VPWR X
MMIN1 Ab A VGND VNB nfet_01v8 m=2 w=0.65 l=0.15 mult=1 sa=0.265
+ sb=0.265 sd=0.28 topography=normal area=0.063 perim=1.14
MMIN2 X Ab VGND VNB nfet_01v8 m=6 w=0.65 l=0.15 mult=1 sa=0.265
+ sb=0.265 sd=0.28 topography=normal area=0.063 perim=1.14
MMIP1 Ab A VPWR VPB pfet_01v8_hvt m=2 w=1.0 l=0.15 mult=1 sa=0.265
+ sb=0.265 sd=0.28 topography=normal area=0.063 perim=1.14
MMIP2 X Ab VPWR VPB pfet_01v8_hvt m=6 w=1.0 l=0.15 mult=1 sa=0.265
+ sb=0.265 sd=0.28 topography=normal area=0.063 perim=1.14
.ENDS

.SUBCKT sky130_fd_sc_hd__buf_8 A VGND VNB VPB VPWR X
MMIN1 Ab A VGND VNB nfet_01v8 m=3 w=0.65 l=0.15 mult=1 sa=0.265
+ sb=0.265 sd=0.28 topography=normal area=0.063 perim=1.14
MMIN2 X Ab VGND VNB nfet_01v8 m=8 w=0.65 l=0.15 mult=1 sa=0.265
+ sb=0.265 sd=0.28 topography=normal area=0.063 perim=1.14
MMIP1 Ab A VPWR VPB pfet_01v8_hvt m=3 w=1.0 l=0.15 mult=1 sa=0.265
+ sb=0.265 sd=0.28 topography=normal area=0.063 perim=1.14
MMIP2 X Ab VPWR VPB pfet_01v8_hvt m=8 w=1.0 l=0.15 mult=1 sa=0.265
+ sb=0.265 sd=0.28 topography=normal area=0.063 perim=1.14
.ENDS

.SUBCKT sky130_fd_sc_hd__buf_12 A VGND VNB VPB VPWR X
MMIN1 Ab A VGND VNB nfet_01v8 m=4 w=0.65 l=0.15 mult=1 sa=0.265
+ sb=0.265 sd=0.28 topography=normal area=0.063 perim=1.14
MMIN2 X Ab VGND VNB nfet_01v8 m=12 w=0.65 l=0.15 mult=1 sa=0.265
+ sb=0.265 sd=0.28 topography=normal area=0.063 perim=1.14
MMIP1 Ab A VPWR VPB pfet_01v8_hvt m=4 w=1.0 l=0.15 mult=1 sa=0.265
+ sb=0.265 sd=0.28 topography=normal area=0.063 perim=1.14
MMIP2 X Ab VPWR VPB pfet_01v8_hvt m=12 w=1.0 l=0.15 mult=1 sa=0.265
+ sb=0.265 sd=0.28 topography=normal area=0.063 perim=1.14
.ENDS

.SUBCKT sky130_fd_sc_hd__buf_16 A VGND VNB VPB VPWR X
MMIN1 Ab A VGND VNB nfet_01v8 m=6 w=0.65 l=0.15 mult=1 sa=0.265
+ sb=0.265 sd=0.28 topography=normal area=0.063 perim=1.14
MMIN2 X Ab VGND VNB nfet_01v8 m=16 w=0.65 l=0.15 mult=1 sa=0.265
+ sb=0.265 sd=0.28 topography=normal area=0.063 perim=1.14
MMIP1 Ab A VPWR VPB pfet_01v8_hvt m=6 w=1.0 l=0.15 mult=1 sa=0.265
+ sb=0.265 sd=0.28 topography=normal area=0.063 perim=1.14
MMIP2 X Ab VPWR VPB pfet_01v8_hvt m=16 w=1.0 l=0.15 mult=1 sa=0.265
+ sb=0.265 sd=0.28 topography=normal area=0.063 perim=1.14
.ENDS

.SUBCKT sky130_fd_sc_hd__bufbuf_8 A VGND VNB VPB VPWR X
MMIN1 Ab A VGND VNB nfet_01v8 m=1 w=0.42 l=0.15 mult=1 sa=0.265
+ sb=0.265 sd=0.28 topography=normal area=0.063 perim=1.14
MMIN2 Abb Ab VGND VNB nfet_01v8 m=1 w=0.65 l=0.15 mult=1 sa=0.265
+ sb=0.265 sd=0.28 topography=normal area=0.063 perim=1.14
MMIN3 Abbb Abb VGND VNB nfet_01v8 m=3 w=0.65 l=0.15 mult=1 sa=0.265
+ sb=0.265 sd=0.28 topography=normal area=0.063 perim=1.14
MMIN4 X Abbb VGND VNB nfet_01v8 m=8 w=0.65 l=0.15 mult=1 sa=0.265
+ sb=0.265 sd=0.28 topography=normal area=0.063 perim=1.14
MMIP4 X Abbb VPWR VPB pfet_01v8_hvt m=8 w=1.0 l=0.15 mult=1 sa=0.265
+ sb=0.265 sd=0.28 topography=normal area=0.063 perim=1.14
MMIP1 Ab A VPWR VPB pfet_01v8_hvt m=1 w=0.64 l=0.15 mult=1 sa=0.265
+ sb=0.265 sd=0.28 topography=normal area=0.063 perim=1.14
MMIP2 Abb Ab VPWR VPB pfet_01v8_hvt m=1 w=1.0 l=0.15 mult=1 sa=0.265
+ sb=0.265 sd=0.28 topography=normal area=0.063 perim=1.14
MI5 Abbb Abb VPWR VPB pfet_01v8_hvt m=3 w=1.0 l=0.15 mult=1 sa=0.265
+ sb=0.265 sd=0.28 topography=normal area=0.063 perim=1.14
.ENDS

.SUBCKT sky130_fd_sc_hd__bufbuf_16 A VGND VNB VPB VPWR X
MMIN1 Ab A VGND VNB nfet_01v8 m=1 w=0.65 l=0.15 mult=1 sa=0.265
+ sb=0.265 sd=0.28 topography=normal area=0.063 perim=1.14
MMIN2 Abb Ab VGND VNB nfet_01v8 m=3 w=0.65 l=0.15 mult=1 sa=0.265
+ sb=0.265 sd=0.28 topography=normal area=0.063 perim=1.14
MMIN3 Abbb Abb VGND VNB nfet_01v8 m=6 w=0.65 l=0.15 mult=1 sa=0.265
+ sb=0.265 sd=0.28 topography=normal area=0.063 perim=1.14
MMIN4 X Abbb VGND VNB nfet_01v8 m=16 w=0.65 l=0.15 mult=1 sa=0.265
+ sb=0.265 sd=0.28 topography=normal area=0.063 perim=1.14
MMIP4 X Abbb VPWR VPB pfet_01v8_hvt m=16 w=1.0 l=0.15 mult=1 sa=0.265
+ sb=0.265 sd=0.28 topography=normal area=0.063 perim=1.14
MMIP1 Ab A VPWR VPB pfet_01v8_hvt m=1 w=1.0 l=0.15 mult=1 sa=0.265
+ sb=0.265 sd=0.28 topography=normal area=0.063 perim=1.14
MMIP2 Abb Ab VPWR VPB pfet_01v8_hvt m=3 w=1.0 l=0.15 mult=1 sa=0.265
+ sb=0.265 sd=0.28 topography=normal area=0.063 perim=1.14
MI5 Abbb Abb VPWR VPB pfet_01v8_hvt m=6 w=1.0 l=0.15 mult=1 sa=0.265
+ sb=0.265 sd=0.28 topography=normal area=0.063 perim=1.14
.ENDS

.SUBCKT sky130_fd_sc_hd__bufinv_8 A VGND VNB VPB VPWR Y
MMIN1 Ab A VGND VNB nfet_01v8 m=1 w=0.65 l=0.15 mult=1 sa=0.265
+ sb=0.265 sd=0.28 topography=normal area=0.063 perim=1.14
MMIN2 Abb Ab VGND VNB nfet_01v8 m=3 w=0.65 l=0.15 mult=1 sa=0.265
+ sb=0.265 sd=0.28 topography=normal area=0.063 perim=1.14
MMIN3 Y Abb VGND VNB nfet_01v8 m=8 w=0.65 l=0.15 mult=1 sa=0.265
+ sb=0.265 sd=0.28 topography=normal area=0.063 perim=1.14
MMIP1 Ab A VPWR VPB pfet_01v8_hvt m=1 w=1.0 l=0.15 mult=1 sa=0.265
+ sb=0.265 sd=0.28 topography=normal area=0.063 perim=1.14
MMIP2 Abb Ab VPWR VPB pfet_01v8_hvt m=3 w=1.0 l=0.15 mult=1 sa=0.265
+ sb=0.265 sd=0.28 topography=normal area=0.063 perim=1.14
MMIP3 Y Abb VPWR VPB pfet_01v8_hvt m=8 w=1.0 l=0.15 mult=1 sa=0.265
+ sb=0.265 sd=0.28 topography=normal area=0.063 perim=1.14
.ENDS

.SUBCKT sky130_fd_sc_hd__bufinv_16 A VGND VNB VPB VPWR Y
MMIN1 Ab A VGND VNB nfet_01v8 m=3 w=0.65 l=0.15 mult=1 sa=0.265
+ sb=0.265 sd=0.28 topography=normal area=0.063 perim=1.14
MMIN2 Abb Ab VGND VNB nfet_01v8 m=6 w=0.65 l=0.15 mult=1 sa=0.265
+ sb=0.265 sd=0.28 topography=normal area=0.063 perim=1.14
MMIN3 Y Abb VGND VNB nfet_01v8 m=16 w=0.65 l=0.15 mult=1 sa=0.265
+ sb=0.265 sd=0.28 topography=normal area=0.063 perim=1.14
MMIP1 Ab A VPWR VPB pfet_01v8_hvt m=3 w=1.0 l=0.15 mult=1 sa=0.265
+ sb=0.265 sd=0.28 topography=normal area=0.063 perim=1.14
MMIP2 Abb Ab VPWR VPB pfet_01v8_hvt m=6 w=1.0 l=0.15 mult=1 sa=0.265
+ sb=0.265 sd=0.28 topography=normal area=0.063 perim=1.14
MMIP3 Y Abb VPWR VPB pfet_01v8_hvt m=16 w=1.0 l=0.15 mult=1 sa=0.265
+ sb=0.265 sd=0.28 topography=normal area=0.063 perim=1.14
.ENDS

.SUBCKT sky130_fd_sc_hd__clkbuf_1 A VGND VNB VPB VPWR X
MMIN0 Ab A VGND VNB nfet_01v8 m=1 w=0.52 l=0.15 mult=1 sa=0.265
+ sb=0.265 sd=0.28 topography=normal area=0.063 perim=1.14
MMIN1 X Ab VGND VNB nfet_01v8 m=1 w=0.52 l=0.15 mult=1 sa=0.265
+ sb=0.265 sd=0.28 topography=normal area=0.063 perim=1.14
MMIP0 Ab A VPWR VPB pfet_01v8_hvt m=1 w=0.79 l=0.15 mult=1 sa=0.265
+ sb=0.265 sd=0.28 topography=normal area=0.063 perim=1.14
MMIP1 X Ab VPWR VPB pfet_01v8_hvt m=1 w=0.79 l=0.15 mult=1 sa=0.265
+ sb=0.265 sd=0.28 topography=normal area=0.063 perim=1.14
.ENDS

.SUBCKT sky130_fd_sc_hd__clkbuf_2 A VGND VNB VPB VPWR X
MMIN0 Ab A VGND VNB nfet_01v8 m=1 w=0.42 l=0.15 mult=1 sa=0.265
+ sb=0.265 sd=0.28 topography=normal area=0.063 perim=1.14
MMIN1 X Ab VGND VNB nfet_01v8 m=2 w=0.42 l=0.15 mult=1 sa=0.265
+ sb=0.265 sd=0.28 topography=normal area=0.063 perim=1.14
MMIP0 Ab A VPWR VPB pfet_01v8_hvt m=1 w=1.0 l=0.15 mult=1 sa=0.265
+ sb=0.265 sd=0.28 topography=normal area=0.063 perim=1.14
MMIP1 X Ab VPWR VPB pfet_01v8_hvt m=2 w=1.0 l=0.15 mult=1 sa=0.265
+ sb=0.265 sd=0.28 topography=normal area=0.063 perim=1.14
.ENDS

.SUBCKT sky130_fd_sc_hd__clkbuf_4 A VGND VNB VPB VPWR X
MMIN0 Ab A VGND VNB nfet_01v8 m=1 w=0.42 l=0.15 mult=1 sa=0.265
+ sb=0.265 sd=0.28 topography=normal area=0.063 perim=1.14
MMIN1 X Ab VGND VNB nfet_01v8 m=4 w=0.42 l=0.15 mult=1 sa=0.265
+ sb=0.265 sd=0.28 topography=normal area=0.063 perim=1.14
MMIP0 Ab A VPWR VPB pfet_01v8_hvt m=1 w=1.0 l=0.15 mult=1 sa=0.265
+ sb=0.265 sd=0.28 topography=normal area=0.063 perim=1.14
MMIP1 X Ab VPWR VPB pfet_01v8_hvt m=4 w=1.0 l=0.15 mult=1 sa=0.265
+ sb=0.265 sd=0.28 topography=normal area=0.063 perim=1.14
.ENDS

.SUBCKT sky130_fd_sc_hd__clkbuf_8 A VGND VNB VPB VPWR X
MMIN0 Ab A VGND VNB nfet_01v8 m=2 w=0.42 l=0.15 mult=1 sa=0.265
+ sb=0.265 sd=0.28 topography=normal area=0.063 perim=1.14
MMIN1 X Ab VGND VNB nfet_01v8 m=8 w=0.42 l=0.15 mult=1 sa=0.265
+ sb=0.265 sd=0.28 topography=normal area=0.063 perim=1.14
MMIP0 Ab A VPWR VPB pfet_01v8_hvt m=2 w=1.0 l=0.15 mult=1 sa=0.265
+ sb=0.265 sd=0.28 topography=normal area=0.063 perim=1.14
MMIP1 X Ab VPWR VPB pfet_01v8_hvt m=8 w=1.0 l=0.15 mult=1 sa=0.265
+ sb=0.265 sd=0.28 topography=normal area=0.063 perim=1.14
.ENDS

.SUBCKT sky130_fd_sc_hd__clkbuf_16 A VGND VNB VPB VPWR X
MMIN0 Ab A VGND VNB nfet_01v8 m=4 w=0.42 l=0.15 mult=1 sa=0.265
+ sb=0.265 sd=0.28 topography=normal area=0.063 perim=1.14
MMIN1 X Ab VGND VNB nfet_01v8 m=16 w=0.42 l=0.15 mult=1 sa=0.265
+ sb=0.265 sd=0.28 topography=normal area=0.063 perim=1.14
MMIP0 Ab A VPWR VPB pfet_01v8_hvt m=4 w=1.0 l=0.15 mult=1 sa=0.265
+ sb=0.265 sd=0.28 topography=normal area=0.063 perim=1.14
MMIP1 X Ab VPWR VPB pfet_01v8_hvt m=16 w=1.0 l=0.15 mult=1 sa=0.265
+ sb=0.265 sd=0.28 topography=normal area=0.063 perim=1.14
.ENDS

.SUBCKT sky130_fd_sc_hd__clkdlybuf4s15_1 A VGND VNB VPB VPWR X
MMIN1 Ab A VGND VNB nfet_01v8 m=1 w=0.42 l=0.15 mult=1 sa=0.265
+ sb=0.265 sd=0.28 topography=normal area=0.063 perim=1.14
MMIN2 A2 Ab VGND VNB nfet_01v8 m=1 w=0.65 l=0.15 mult=1 sa=0.265
+ sb=0.265 sd=0.28 topography=normal area=0.063 perim=1.14
MI5 Ab2 A2 VGND VNB nfet_01v8 m=1 w=0.65 l=0.15 mult=1 sa=0.265
+ sb=0.265 sd=0.28 topography=normal area=0.063 perim=1.14
MI4 X Ab2 VGND VNB nfet_01v8 m=1 w=0.42 l=0.15 mult=1 sa=0.265
+ sb=0.265 sd=0.28 topography=normal area=0.063 perim=1.14
MMIP1 Ab A VPWR VPB pfet_01v8_hvt m=1 w=1.0 l=0.15 mult=1 sa=0.265
+ sb=0.265 sd=0.28 topography=normal area=0.063 perim=1.14
MMIP2 A2 Ab VPWR VPB pfet_01v8_hvt m=1 w=0.82 l=0.15 mult=1 sa=0.265
+ sb=0.265 sd=0.28 topography=normal area=0.063 perim=1.14
MI7 Ab2 A2 VPWR VPB pfet_01v8_hvt m=1 w=0.82 l=0.15 mult=1 sa=0.265
+ sb=0.265 sd=0.28 topography=normal area=0.063 perim=1.14
MI6 X Ab2 VPWR VPB pfet_01v8_hvt m=1 w=1.0 l=0.15 mult=1 sa=0.265
+ sb=0.265 sd=0.28 topography=normal area=0.063 perim=1.14
.ENDS

.SUBCKT sky130_fd_sc_hd__clkdlybuf4s15_2 A VGND VNB VPB VPWR X
MMIN1 Ab A VGND VNB nfet_01v8 m=1 w=0.42 l=0.15 mult=1 sa=0.265
+ sb=0.265 sd=0.28 topography=normal area=0.063 perim=1.14
MMIN2 A2 Ab VGND VNB nfet_01v8 m=1 w=0.65 l=0.15 mult=1 sa=0.265
+ sb=0.265 sd=0.28 topography=normal area=0.063 perim=1.14
MI5 Ab2 A2 VGND VNB nfet_01v8 m=1 w=0.65 l=0.15 mult=1 sa=0.265
+ sb=0.265 sd=0.28 topography=normal area=0.063 perim=1.14
MI4 X Ab2 VGND VNB nfet_01v8 m=2 w=0.42 l=0.15 mult=1 sa=0.265
+ sb=0.265 sd=0.28 topography=normal area=0.063 perim=1.14
MMIP1 Ab A VPWR VPB pfet_01v8_hvt m=1 w=1.0 l=0.15 mult=1 sa=0.265
+ sb=0.265 sd=0.28 topography=normal area=0.063 perim=1.14
MMIP2 A2 Ab VPWR VPB pfet_01v8_hvt m=1 w=0.82 l=0.15 mult=1 sa=0.265
+ sb=0.265 sd=0.28 topography=normal area=0.063 perim=1.14
MI7 Ab2 A2 VPWR VPB pfet_01v8_hvt m=1 w=0.82 l=0.15 mult=1 sa=0.265
+ sb=0.265 sd=0.28 topography=normal area=0.063 perim=1.14
MI6 X Ab2 VPWR VPB pfet_01v8_hvt m=2 w=1.0 l=0.15 mult=1 sa=0.265
+ sb=0.265 sd=0.28 topography=normal area=0.063 perim=1.14
.ENDS

.SUBCKT sky130_fd_sc_hd__clkdlybuf4s18_1 A VGND VNB VPB VPWR X
MMIN1 Ab A VGND VNB nfet_01v8 m=1 w=0.42 l=0.15 mult=1 sa=0.265
+ sb=0.265 sd=0.28 topography=normal area=0.063 perim=1.14
MMIN2 A2 Ab VGND VNB nfet_01v8 m=1 w=0.65 l=0.18 mult=1 sa=0.265
+ sb=0.265 sd=0.28 topography=normal area=0.063 perim=1.14
MI5 Ab2 A2 VGND VNB nfet_01v8 m=1 w=0.65 l=0.18 mult=1 sa=0.265
+ sb=0.265 sd=0.28 topography=normal area=0.063 perim=1.14
MI4 X Ab2 VGND VNB nfet_01v8 m=1 w=0.42 l=0.15 mult=1 sa=0.265
+ sb=0.265 sd=0.28 topography=normal area=0.063 perim=1.14
MMIP1 Ab A VPWR VPB pfet_01v8_hvt m=1 w=1.0 l=0.15 mult=1 sa=0.265
+ sb=0.265 sd=0.28 topography=normal area=0.063 perim=1.14
MMIP2 A2 Ab VPWR VPB pfet_01v8_hvt m=1 w=0.82 l=0.18 mult=1 sa=0.265
+ sb=0.265 sd=0.28 topography=normal area=0.063 perim=1.14
MI7 Ab2 A2 VPWR VPB pfet_01v8_hvt m=1 w=0.82 l=0.18 mult=1 sa=0.265
+ sb=0.265 sd=0.28 topography=normal area=0.063 perim=1.14
MI6 X Ab2 VPWR VPB pfet_01v8_hvt m=1 w=1.0 l=0.15 mult=1 sa=0.265
+ sb=0.265 sd=0.28 topography=normal area=0.063 perim=1.14
.ENDS

.SUBCKT sky130_fd_sc_hd__clkdlybuf4s18_2 A VGND VNB VPB VPWR X
MMIN1 Ab A VGND VNB nfet_01v8 m=1 w=0.42 l=0.15 mult=1 sa=0.265
+ sb=0.265 sd=0.28 topography=normal area=0.063 perim=1.14
MMIN2 A2 Ab VGND VNB nfet_01v8 m=1 w=0.65 l=0.18 mult=1 sa=0.265
+ sb=0.265 sd=0.28 topography=normal area=0.063 perim=1.14
MI5 Ab2 A2 VGND VNB nfet_01v8 m=1 w=0.65 l=0.18 mult=1 sa=0.265
+ sb=0.265 sd=0.28 topography=normal area=0.063 perim=1.14
MI4 X Ab2 VGND VNB nfet_01v8 m=2 w=0.42 l=0.15 mult=1 sa=0.265
+ sb=0.265 sd=0.28 topography=normal area=0.063 perim=1.14
MMIP1 Ab A VPWR VPB pfet_01v8_hvt m=1 w=1.0 l=0.15 mult=1 sa=0.265
+ sb=0.265 sd=0.28 topography=normal area=0.063 perim=1.14
MMIP2 A2 Ab VPWR VPB pfet_01v8_hvt m=1 w=0.82 l=0.18 mult=1 sa=0.265
+ sb=0.265 sd=0.28 topography=normal area=0.063 perim=1.14
MI7 Ab2 A2 VPWR VPB pfet_01v8_hvt m=1 w=0.82 l=0.18 mult=1 sa=0.265
+ sb=0.265 sd=0.28 topography=normal area=0.063 perim=1.14
MI6 X Ab2 VPWR VPB pfet_01v8_hvt m=2 w=1.0 l=0.15 mult=1 sa=0.265
+ sb=0.265 sd=0.28 topography=normal area=0.063 perim=1.14
.ENDS

.SUBCKT sky130_fd_sc_hd__clkdlybuf4s25_1 A VGND VNB VPB VPWR X
MMIN1 Ab A VGND VNB nfet_01v8 m=1 w=0.42 l=0.15 mult=1 sa=0.265
+ sb=0.265 sd=0.28 topography=normal area=0.063 perim=1.14
MMIN2 A2 Ab VGND VNB nfet_01v8 m=1 w=0.65 l=0.25 mult=1 sa=0.265
+ sb=0.265 sd=0.28 topography=normal area=0.063 perim=1.14
MI5 Ab2 A2 VGND VNB nfet_01v8 m=1 w=0.65 l=0.25 mult=1 sa=0.265
+ sb=0.265 sd=0.28 topography=normal area=0.063 perim=1.14
MI4 X Ab2 VGND VNB nfet_01v8 m=1 w=0.42 l=0.15 mult=1 sa=0.265
+ sb=0.265 sd=0.28 topography=normal area=0.063 perim=1.14
MMIP1 Ab A VPWR VPB pfet_01v8_hvt m=1 w=1.0 l=0.15 mult=1 sa=0.265
+ sb=0.265 sd=0.28 topography=normal area=0.063 perim=1.14
MMIP2 A2 Ab VPWR VPB pfet_01v8_hvt m=1 w=0.82 l=0.25 mult=1 sa=0.265
+ sb=0.265 sd=0.28 topography=normal area=0.063 perim=1.14
MI7 Ab2 A2 VPWR VPB pfet_01v8_hvt m=1 w=0.82 l=0.25 mult=1 sa=0.265
+ sb=0.265 sd=0.28 topography=normal area=0.063 perim=1.14
MI6 X Ab2 VPWR VPB pfet_01v8_hvt m=1 w=1.0 l=0.15 mult=1 sa=0.265
+ sb=0.265 sd=0.28 topography=normal area=0.063 perim=1.14
.ENDS

.SUBCKT sky130_fd_sc_hd__clkdlybuf4s25_2 A VGND VNB VPB VPWR X
MMIN1 Ab A VGND VNB nfet_01v8 m=1 w=0.42 l=0.15 mult=1 sa=0.265
+ sb=0.265 sd=0.28 topography=normal area=0.063 perim=1.14
MMIN2 A2 Ab VGND VNB nfet_01v8 m=1 w=0.65 l=0.25 mult=1 sa=0.265
+ sb=0.265 sd=0.28 topography=normal area=0.063 perim=1.14
MI5 Ab2 A2 VGND VNB nfet_01v8 m=1 w=0.65 l=0.25 mult=1 sa=0.265
+ sb=0.265 sd=0.28 topography=normal area=0.063 perim=1.14
MI4 X Ab2 VGND VNB nfet_01v8 m=2 w=0.42 l=0.15 mult=1 sa=0.265
+ sb=0.265 sd=0.28 topography=normal area=0.063 perim=1.14
MMIP1 Ab A VPWR VPB pfet_01v8_hvt m=1 w=1.0 l=0.15 mult=1 sa=0.265
+ sb=0.265 sd=0.28 topography=normal area=0.063 perim=1.14
MMIP2 A2 Ab VPWR VPB pfet_01v8_hvt m=1 w=0.82 l=0.25 mult=1 sa=0.265
+ sb=0.265 sd=0.28 topography=normal area=0.063 perim=1.14
MI7 Ab2 A2 VPWR VPB pfet_01v8_hvt m=1 w=0.82 l=0.25 mult=1 sa=0.265
+ sb=0.265 sd=0.28 topography=normal area=0.063 perim=1.14
MI6 X Ab2 VPWR VPB pfet_01v8_hvt m=2 w=1.0 l=0.15 mult=1 sa=0.265
+ sb=0.265 sd=0.28 topography=normal area=0.063 perim=1.14
.ENDS

.SUBCKT sky130_fd_sc_hd__clkdlybuf4s50_1 A VGND VNB VPB VPWR X
MMIN1 Ab A VGND VNB nfet_01v8 m=1 w=0.42 l=0.15 mult=1 sa=0.265
+ sb=0.265 sd=0.28 topography=normal area=0.063 perim=1.14
MMIN2 A2 Ab VGND VNB nfet_01v8 m=1 w=0.65 l=0.5 mult=1 sa=0.265
+ sb=0.265 sd=0.28 topography=normal area=0.063 perim=1.14
MI5 Ab2 A2 VGND VNB nfet_01v8 m=1 w=0.65 l=0.5 mult=1 sa=0.265
+ sb=0.265 sd=0.28 topography=normal area=0.063 perim=1.14
MI4 X Ab2 VGND VNB nfet_01v8 m=1 w=0.42 l=0.15 mult=1 sa=0.265
+ sb=0.265 sd=0.28 topography=normal area=0.063 perim=1.14
MMIP1 Ab A VPWR VPB pfet_01v8_hvt m=1 w=1.0 l=0.15 mult=1 sa=0.265
+ sb=0.265 sd=0.28 topography=normal area=0.063 perim=1.14
MMIP2 A2 Ab VPWR VPB pfet_01v8_hvt m=1 w=0.82 l=0.5 mult=1 sa=0.265
+ sb=0.265 sd=0.28 topography=normal area=0.063 perim=1.14
MI7 Ab2 A2 VPWR VPB pfet_01v8_hvt m=1 w=0.82 l=0.5 mult=1 sa=0.265
+ sb=0.265 sd=0.28 topography=normal area=0.063 perim=1.14
MI6 X Ab2 VPWR VPB pfet_01v8_hvt m=1 w=1.0 l=0.15 mult=1 sa=0.265
+ sb=0.265 sd=0.28 topography=normal area=0.063 perim=1.14
.ENDS

.SUBCKT sky130_fd_sc_hd__clkdlybuf4s50_2 A VGND VNB VPB VPWR X
MMIN1 Ab A VGND VNB nfet_01v8 m=1 w=0.42 l=0.15 mult=1 sa=0.265
+ sb=0.265 sd=0.28 topography=normal area=0.063 perim=1.14
MMIN2 A2 Ab VGND VNB nfet_01v8 m=1 w=0.65 l=0.5 mult=1 sa=0.265
+ sb=0.265 sd=0.28 topography=normal area=0.063 perim=1.14
MI5 Ab2 A2 VGND VNB nfet_01v8 m=1 w=0.65 l=0.5 mult=1 sa=0.265
+ sb=0.265 sd=0.28 topography=normal area=0.063 perim=1.14
MI4 X Ab2 VGND VNB nfet_01v8 m=2 w=0.42 l=0.15 mult=1 sa=0.265
+ sb=0.265 sd=0.28 topography=normal area=0.063 perim=1.14
MMIP1 Ab A VPWR VPB pfet_01v8_hvt m=1 w=1.0 l=0.15 mult=1 sa=0.265
+ sb=0.265 sd=0.28 topography=normal area=0.063 perim=1.14
MMIP2 A2 Ab VPWR VPB pfet_01v8_hvt m=1 w=0.82 l=0.5 mult=1 sa=0.265
+ sb=0.265 sd=0.28 topography=normal area=0.063 perim=1.14
MI7 Ab2 A2 VPWR VPB pfet_01v8_hvt m=1 w=0.82 l=0.5 mult=1 sa=0.265
+ sb=0.265 sd=0.28 topography=normal area=0.063 perim=1.14
MI6 X Ab2 VPWR VPB pfet_01v8_hvt m=2 w=1.0 l=0.15 mult=1 sa=0.265
+ sb=0.265 sd=0.28 topography=normal area=0.063 perim=1.14
.ENDS

.SUBCKT sky130_fd_sc_hd__clkinv_1 A VGND VNB VPB VPWR Y
MMIN0 Y A VGND VNB nfet_01v8 m=1 w=0.42 l=0.15 mult=1 sa=0.265
+ sb=0.265 sd=0.28 topography=normal area=0.063 perim=1.14
MMIP0 Y A VPWR VPB pfet_01v8_hvt m=2 w=0.84 l=0.15 mult=1 sa=0.265
+ sb=0.265 sd=0.28 topography=normal area=0.063 perim=1.14
.ENDS

.SUBCKT sky130_fd_sc_hd__clkinv_2 A VGND VNB VPB VPWR Y
MMIN0 Y A VGND VNB nfet_01v8 m=2 w=0.42 l=0.15 mult=1 sa=0.265
+ sb=0.265 sd=0.28 topography=normal area=0.063 perim=1.14
MMIP0 Y A VPWR VPB pfet_01v8_hvt m=3 w=1.0 l=0.15 mult=1 sa=0.265
+ sb=0.265 sd=0.28 topography=normal area=0.063 perim=1.14
.ENDS

.SUBCKT sky130_fd_sc_hd__clkinv_4 A VGND VNB VPB VPWR Y
MMIN0 Y A VGND VNB nfet_01v8 m=4 w=0.42 l=0.15 mult=1 sa=0.265
+ sb=0.265 sd=0.28 topography=normal area=0.063 perim=1.14
MMIP0 Y A VPWR VPB pfet_01v8_hvt m=6 w=1.0 l=0.15 mult=1 sa=0.265
+ sb=0.265 sd=0.28 topography=normal area=0.063 perim=1.14
.ENDS

.SUBCKT sky130_fd_sc_hd__clkinv_8 A VGND VNB VPB VPWR Y
MMIN0 Y A VGND VNB nfet_01v8 m=8 w=0.42 l=0.15 mult=1 sa=0.265
+ sb=0.265 sd=0.28 topography=normal area=0.063 perim=1.14
MMIP0 Y A VPWR VPB pfet_01v8_hvt m=12 w=1.0 l=0.15 mult=1 sa=0.265
+ sb=0.265 sd=0.28 topography=normal area=0.063 perim=1.14
.ENDS

.SUBCKT sky130_fd_sc_hd__clkinv_16 A VGND VNB VPB VPWR Y
MMIN0 Y A VGND VNB nfet_01v8 m=16 w=0.42 l=0.15 mult=1 sa=0.265
+ sb=0.265 sd=0.28 topography=normal area=0.063 perim=1.14
MMIP0 Y A VPWR VPB pfet_01v8_hvt m=24 w=1.0 l=0.15 mult=1 sa=0.265
+ sb=0.265 sd=0.28 topography=normal area=0.063 perim=1.14
.ENDS

.SUBCKT sky130_fd_sc_hd__clkinvlp_2 A VGND VNB VPB VPWR Y
MMIP0 Y A VPWR VPB pfet_01v8_hvt m=2 w=1.0 l=0.25 mult=1 sa=0.265
+ sb=0.265 sd=0.28 topography=normal area=0.063 perim=1.14
MI5 net36 A VGND VNB nfet_01v8 m=1 w=0.55 l=0.15 mult=1 sa=0.265
+ sb=0.265 sd=0.28 topography=normal area=0.063 perim=1.14
MMIN0 Y A net36 VNB nfet_01v8 m=1 w=0.55 l=0.15 mult=1 sa=0.265
+ sb=0.265 sd=0.28 topography=normal area=0.063 perim=1.14
.ENDS

.SUBCKT sky130_fd_sc_hd__clkinvlp_4 A VGND VNB VPB VPWR Y
MMIP0 Y A VPWR VPB pfet_01v8_hvt m=4 w=1.0 l=0.25 mult=1 sa=0.265
+ sb=0.265 sd=0.28 topography=normal area=0.063 perim=1.14
MMIN0 Y A net31 VNB nfet_01v8 m=1 w=0.55 l=0.15 mult=1 sa=0.265
+ sb=0.265 sd=0.28 topography=normal area=0.063 perim=1.14
MI7 net35 A VGND VNB nfet_01v8 m=1 w=0.55 l=0.15 mult=1 sa=0.265
+ sb=0.265 sd=0.28 topography=normal area=0.063 perim=1.14
MI6 net31 A VGND VNB nfet_01v8 m=1 w=0.55 l=0.15 mult=1 sa=0.265
+ sb=0.265 sd=0.28 topography=normal area=0.063 perim=1.14
MI5 Y A net35 VNB nfet_01v8 m=1 w=0.55 l=0.15 mult=1 sa=0.265 sb=0.265
+ sd=0.28 topography=normal area=0.063 perim=1.14
.ENDS

.SUBCKT sky130_fd_sc_hd__conb_1 VGND VNB VPB VPWR HI LO
rI12 VGND LO sky130_fd_pr__res_generic_po
rI11 HI VPWR sky130_fd_pr__res_generic_po
.ENDS

.SUBCKT sky130_fd_sc_hd__decap_3 VGND VNB VPB VPWR
MI1 VGND VPWR VGND VNB nfet_01v8 m=1 w=0.55 l=0.59 mult=1 sa=0.265
+ sb=0.265 sd=0.28 topography=normal area=0.063 perim=1.14
MI2 VPWR VGND VPWR VPB pfet_01v8_hvt m=1 w=0.87 l=0.59 mult=1 sa=0.265
+ sb=0.265 sd=0.28 topography=normal area=0.063 perim=1.14
.ENDS

.SUBCKT sky130_fd_sc_hd__decap_4 VGND VNB VPB VPWR
MI2 VPWR VGND VPWR VPB pfet_01v8_hvt m=1 w=0.87 l=1.05 mult=1 sa=0.265
+ sb=0.265 sd=0.28 topography=normal area=0.063 perim=1.14
MI1 VGND VPWR VGND VNB nfet_01v8 m=1 w=0.55 l=1.05 mult=1 sa=0.265
+ sb=0.265 sd=0.28 topography=normal area=0.063 perim=1.14
.ENDS

.SUBCKT sky130_fd_sc_hd__decap_6 VGND VNB VPB VPWR
MI1 VGND VPWR VGND VNB nfet_01v8 m=1 w=0.55 l=1.97 mult=1 sa=0.265
+ sb=0.265 sd=0.28 topography=normal area=0.063 perim=1.14
MI2 VPWR VGND VPWR VPB pfet_01v8_hvt m=1 w=0.87 l=1.97 mult=1 sa=0.265
+ sb=0.265 sd=0.28 topography=normal area=0.063 perim=1.14
.ENDS

.SUBCKT sky130_fd_sc_hd__decap_8 VGND VNB VPB VPWR
MI1 VGND VPWR VGND VNB nfet_01v8 m=1 w=0.55 l=2.89 mult=1 sa=0.265
+ sb=0.265 sd=0.28 topography=normal area=0.063 perim=1.14
MI2 VPWR VGND VPWR VPB pfet_01v8_hvt m=1 w=0.87 l=2.89 mult=1 sa=0.265
+ sb=0.265 sd=0.28 topography=normal area=0.063 perim=1.14
.ENDS

.SUBCKT sky130_fd_sc_hd__decap_12 VGND VNB VPB VPWR
MI1 VGND VPWR VGND VNB nfet_01v8 m=1 w=0.55 l=4.73 mult=1 sa=0.265
+ sb=0.265 sd=0.28 topography=normal area=0.063 perim=1.14
MI2 VPWR VGND VPWR VPB pfet_01v8_hvt m=1 w=0.87 l=4.73 mult=1 sa=0.265
+ sb=0.265 sd=0.28 topography=normal area=0.063 perim=1.14
.ENDS

.SUBCKT sky130_fd_sc_hd__dfbbn_1 CLK_N D RESET_B SET_B VGND VNB VPB VPWR Q Q_N
MI46 clkneg clkpos VGND VNB nfet_01v8 m=1 w=0.42 l=0.15 mult=1
+ sa=0.265 sb=0.265 sd=0.28 topography=normal area=0.063 perim=1.14
MI659 db D VGND VNB nfet_01v8 m=1 w=0.42 l=0.15 mult=1 sa=0.265
+ sb=0.265 sd=0.28 topography=normal area=0.063 perim=1.14
MI642 RESET RESET_B VGND VNB nfet_01v8 m=1 w=0.42 l=0.15 mult=1
+ sa=0.265 sb=0.265 sd=0.28 topography=normal area=0.063 perim=1.14
MI676 M1 M0 net141 VNB nfet_01v8 m=1 w=0.64 l=0.15 mult=1 sa=0.265
+ sb=0.265 sd=0.28 topography=normal area=0.063 perim=1.14
MI675 net141 SET_B VGND VNB nfet_01v8 m=1 w=0.42 l=0.15 mult=1
+ sa=0.265 sb=0.265 sd=0.28 topography=normal area=0.063 perim=1.14
MI653 Q net162 VGND VNB nfet_01v8 m=1 w=0.65 l=0.15 mult=1 sa=0.265
+ sb=0.265 sd=0.28 topography=normal area=0.063 perim=1.14
MI677 M1 RESET net141 VNB nfet_01v8 m=1 w=0.64 l=0.15 mult=1 sa=0.265
+ sb=0.265 sd=0.28 topography=normal area=0.063 perim=1.14
MI648 M0 clkpos net125 VNB nfet_01v8 m=1 w=0.36 l=0.15 mult=1 sa=0.265
+ sb=0.265 sd=0.28 topography=normal area=0.063 perim=1.14
MI44 clkpos CLK_N VGND VNB nfet_01v8 m=1 w=0.42 l=0.15 mult=1 sa=0.265
+ sb=0.265 sd=0.28 topography=normal area=0.063 perim=1.14
MI649 net125 M1 VGND VNB nfet_01v8 m=1 w=0.42 l=0.15 mult=1 sa=0.265
+ sb=0.265 sd=0.28 topography=normal area=0.063 perim=1.14
MI655 S0 clkneg net110 VNB nfet_01v8 m=1 w=0.36 l=0.15 mult=1 sa=0.265
+ sb=0.265 sd=0.28 topography=normal area=0.063 perim=1.14
MI654 net110 net82 VGND VNB nfet_01v8 m=1 w=0.42 l=0.15 mult=1
+ sa=0.265 sb=0.265 sd=0.28 topography=normal area=0.063 perim=1.14
MI651 Q_N net82 VGND VNB nfet_01v8 m=1 w=0.65 l=0.15 mult=1 sa=0.265
+ sb=0.265 sd=0.28 topography=normal area=0.063 perim=1.14
MI652 net162 net82 VGND VNB nfet_01v8 m=1 w=0.42 l=0.15 mult=1
+ sa=0.265 sb=0.265 sd=0.28 topography=normal area=0.063 perim=1.14
MI42 db clkneg M0 VNB nfet_01v8 m=1 w=0.36 l=0.15 mult=1 sa=0.265
+ sb=0.265 sd=0.28 topography=normal area=0.063 perim=1.14
MI668 S0 clkpos net93 VNB nfet_01v8 m=1 w=0.36 l=0.15 mult=1 sa=0.265
+ sb=0.265 sd=0.28 topography=normal area=0.063 perim=1.14
MI667 net93 M1 VGND VNB nfet_01v8 m=1 w=0.64 l=0.15 mult=1 sa=0.265
+ sb=0.265 sd=0.28 topography=normal area=0.063 perim=1.14
MI630 net82 RESET net81 VNB nfet_01v8 m=1 w=0.64 l=0.15 mult=1
+ sa=0.265 sb=0.265 sd=0.28 topography=normal area=0.063 perim=1.14
MI3 net82 S0 net81 VNB nfet_01v8 m=1 w=0.64 l=0.15 mult=1 sa=0.265
+ sb=0.265 sd=0.28 topography=normal area=0.063 perim=1.14
MI7 net81 SET_B VGND VNB nfet_01v8 m=1 w=0.42 l=0.15 mult=1 sa=0.265
+ sb=0.265 sd=0.28 topography=normal area=0.063 perim=1.14
MI679 M1 SET_B VPWR VPB pfet_01v8_hvt m=1 w=0.42 l=0.15 mult=1
+ sa=0.265 sb=0.265 sd=0.28 topography=normal area=0.063 perim=1.14
MI669 S0 clkneg net218 VPB pfet_01v8_hvt m=1 w=0.42 l=0.15 mult=1
+ sa=0.265 sb=0.265 sd=0.28 topography=normal area=0.063 perim=1.14
MI660 Q net162 VPWR VPB pfet_01v8_hvt m=1 w=1.0 l=0.15 mult=1 sa=0.265
+ sb=0.265 sd=0.28 topography=normal area=0.063 perim=1.14
MI9 net82 S0 net221 VPB pfet_01v8_hvt m=1 w=0.84 l=0.15 mult=1
+ sa=0.265 sb=0.265 sd=0.28 topography=normal area=0.063 perim=1.14
MI670 net218 M1 VPWR VPB pfet_01v8_hvt m=1 w=0.84 l=0.15 mult=1
+ sa=0.265 sb=0.265 sd=0.28 topography=normal area=0.063 perim=1.14
MI678 net165 RESET VPWR VPB pfet_01v8_hvt m=1 w=0.84 l=0.15 mult=1
+ sa=0.265 sb=0.265 sd=0.28 topography=normal area=0.063 perim=1.14
MI662 net210 net82 VPWR VPB pfet_01v8_hvt m=1 w=0.42 l=0.15 mult=1
+ sa=0.265 sb=0.265 sd=0.28 topography=normal area=0.063 perim=1.14
MI664 S0 clkpos net210 VPB pfet_01v8_hvt m=1 w=0.42 l=0.15 mult=1
+ sa=0.265 sb=0.265 sd=0.28 topography=normal area=0.063 perim=1.14
MI10 net82 SET_B VPWR VPB pfet_01v8_hvt m=1 w=0.42 l=0.15 mult=1
+ sa=0.265 sb=0.265 sd=0.28 topography=normal area=0.063 perim=1.14
MI11 net221 RESET VPWR VPB pfet_01v8_hvt m=1 w=0.84 l=0.15 mult=1
+ sa=0.265 sb=0.265 sd=0.28 topography=normal area=0.063 perim=1.14
MI650 net194 M1 VPWR VPB pfet_01v8_hvt m=1 w=0.42 l=0.15 mult=1
+ sa=0.265 sb=0.265 sd=0.28 topography=normal area=0.063 perim=1.14
MI665 db D VPWR VPB pfet_01v8_hvt m=1 w=0.42 l=0.15 mult=1 sa=0.265
+ sb=0.265 sd=0.28 topography=normal area=0.063 perim=1.14
MI43 db clkpos M0 VPB pfet_01v8_hvt m=1 w=0.42 l=0.15 mult=1 sa=0.265
+ sb=0.265 sd=0.28 topography=normal area=0.063 perim=1.14
MI656 M0 clkneg net194 VPB pfet_01v8_hvt m=1 w=0.42 l=0.15 mult=1
+ sa=0.265 sb=0.265 sd=0.28 topography=normal area=0.063 perim=1.14
MI643 RESET RESET_B VPWR VPB pfet_01v8_hvt m=1 w=0.64 l=0.15 mult=1
+ sa=0.265 sb=0.265 sd=0.28 topography=normal area=0.063 perim=1.14
MI47 clkneg clkpos VPWR VPB pfet_01v8_hvt m=1 w=0.64 l=0.15 mult=1
+ sa=0.265 sb=0.265 sd=0.28 topography=normal area=0.063 perim=1.14
MI45 clkpos CLK_N VPWR VPB pfet_01v8_hvt m=1 w=0.64 l=0.15 mult=1
+ sa=0.265 sb=0.265 sd=0.28 topography=normal area=0.063 perim=1.14
MI680 M1 M0 net165 VPB pfet_01v8_hvt m=1 w=0.84 l=0.15 mult=1 sa=0.265
+ sb=0.265 sd=0.28 topography=normal area=0.063 perim=1.14
MI663 net162 net82 VPWR VPB pfet_01v8_hvt m=1 w=0.64 l=0.15 mult=1
+ sa=0.265 sb=0.265 sd=0.28 topography=normal area=0.063 perim=1.14
MI661 Q_N net82 VPWR VPB pfet_01v8_hvt m=1 w=1.0 l=0.15 mult=1
+ sa=0.265 sb=0.265 sd=0.28 topography=normal area=0.063 perim=1.14
.ENDS

.SUBCKT sky130_fd_sc_hd__dfbbn_2 CLK_N D RESET_B SET_B VGND VNB VPB VPWR Q Q_N
MI46 clkneg clkpos VGND VNB nfet_01v8 m=1 w=0.42 l=0.15 mult=1
+ sa=0.265 sb=0.265 sd=0.28 topography=normal area=0.063 perim=1.14
MI659 db D VGND VNB nfet_01v8 m=1 w=0.42 l=0.15 mult=1 sa=0.265
+ sb=0.265 sd=0.28 topography=normal area=0.063 perim=1.14
MI642 RESET RESET_B VGND VNB nfet_01v8 m=1 w=0.42 l=0.15 mult=1
+ sa=0.265 sb=0.265 sd=0.28 topography=normal area=0.063 perim=1.14
MI676 M1 M0 net141 VNB nfet_01v8 m=1 w=0.64 l=0.15 mult=1 sa=0.265
+ sb=0.265 sd=0.28 topography=normal area=0.063 perim=1.14
MI675 net141 SET_B VGND VNB nfet_01v8 m=1 w=0.42 l=0.15 mult=1
+ sa=0.265 sb=0.265 sd=0.28 topography=normal area=0.063 perim=1.14
MI653 Q net162 VGND VNB nfet_01v8 m=2 w=0.65 l=0.15 mult=1 sa=0.265
+ sb=0.265 sd=0.28 topography=normal area=0.063 perim=1.14
MI677 M1 RESET net141 VNB nfet_01v8 m=1 w=0.64 l=0.15 mult=1 sa=0.265
+ sb=0.265 sd=0.28 topography=normal area=0.063 perim=1.14
MI648 M0 clkpos net125 VNB nfet_01v8 m=1 w=0.36 l=0.15 mult=1 sa=0.265
+ sb=0.265 sd=0.28 topography=normal area=0.063 perim=1.14
MI44 clkpos CLK_N VGND VNB nfet_01v8 m=1 w=0.42 l=0.15 mult=1 sa=0.265
+ sb=0.265 sd=0.28 topography=normal area=0.063 perim=1.14
MI649 net125 M1 VGND VNB nfet_01v8 m=1 w=0.42 l=0.15 mult=1 sa=0.265
+ sb=0.265 sd=0.28 topography=normal area=0.063 perim=1.14
MI655 S0 clkneg net110 VNB nfet_01v8 m=1 w=0.36 l=0.15 mult=1 sa=0.265
+ sb=0.265 sd=0.28 topography=normal area=0.063 perim=1.14
MI654 net110 net82 VGND VNB nfet_01v8 m=1 w=0.42 l=0.15 mult=1
+ sa=0.265 sb=0.265 sd=0.28 topography=normal area=0.063 perim=1.14
MI651 Q_N net82 VGND VNB nfet_01v8 m=2 w=0.65 l=0.15 mult=1 sa=0.265
+ sb=0.265 sd=0.28 topography=normal area=0.063 perim=1.14
MI652 net162 net82 VGND VNB nfet_01v8 m=1 w=0.42 l=0.15 mult=1
+ sa=0.265 sb=0.265 sd=0.28 topography=normal area=0.063 perim=1.14
MI42 db clkneg M0 VNB nfet_01v8 m=1 w=0.36 l=0.15 mult=1 sa=0.265
+ sb=0.265 sd=0.28 topography=normal area=0.063 perim=1.14
MI668 S0 clkpos net93 VNB nfet_01v8 m=1 w=0.36 l=0.15 mult=1 sa=0.265
+ sb=0.265 sd=0.28 topography=normal area=0.063 perim=1.14
MI667 net93 M1 VGND VNB nfet_01v8 m=1 w=0.64 l=0.15 mult=1 sa=0.265
+ sb=0.265 sd=0.28 topography=normal area=0.063 perim=1.14
MI630 net82 RESET net81 VNB nfet_01v8 m=1 w=0.64 l=0.15 mult=1
+ sa=0.265 sb=0.265 sd=0.28 topography=normal area=0.063 perim=1.14
MI3 net82 S0 net81 VNB nfet_01v8 m=1 w=0.64 l=0.15 mult=1 sa=0.265
+ sb=0.265 sd=0.28 topography=normal area=0.063 perim=1.14
MI7 net81 SET_B VGND VNB nfet_01v8 m=1 w=0.42 l=0.15 mult=1 sa=0.265
+ sb=0.265 sd=0.28 topography=normal area=0.063 perim=1.14
MI679 M1 SET_B VPWR VPB pfet_01v8_hvt m=1 w=0.42 l=0.15 mult=1
+ sa=0.265 sb=0.265 sd=0.28 topography=normal area=0.063 perim=1.14
MI669 S0 clkneg net218 VPB pfet_01v8_hvt m=1 w=0.42 l=0.15 mult=1
+ sa=0.265 sb=0.265 sd=0.28 topography=normal area=0.063 perim=1.14
MI660 Q net162 VPWR VPB pfet_01v8_hvt m=2 w=1.0 l=0.15 mult=1 sa=0.265
+ sb=0.265 sd=0.28 topography=normal area=0.063 perim=1.14
MI9 net82 S0 net221 VPB pfet_01v8_hvt m=1 w=0.84 l=0.15 mult=1
+ sa=0.265 sb=0.265 sd=0.28 topography=normal area=0.063 perim=1.14
MI670 net218 M1 VPWR VPB pfet_01v8_hvt m=1 w=0.84 l=0.15 mult=1
+ sa=0.265 sb=0.265 sd=0.28 topography=normal area=0.063 perim=1.14
MI678 net165 RESET VPWR VPB pfet_01v8_hvt m=1 w=0.84 l=0.15 mult=1
+ sa=0.265 sb=0.265 sd=0.28 topography=normal area=0.063 perim=1.14
MI662 net210 net82 VPWR VPB pfet_01v8_hvt m=1 w=0.42 l=0.15 mult=1
+ sa=0.265 sb=0.265 sd=0.28 topography=normal area=0.063 perim=1.14
MI664 S0 clkpos net210 VPB pfet_01v8_hvt m=1 w=0.42 l=0.15 mult=1
+ sa=0.265 sb=0.265 sd=0.28 topography=normal area=0.063 perim=1.14
MI10 net82 SET_B VPWR VPB pfet_01v8_hvt m=1 w=0.42 l=0.15 mult=1
+ sa=0.265 sb=0.265 sd=0.28 topography=normal area=0.063 perim=1.14
MI11 net221 RESET VPWR VPB pfet_01v8_hvt m=1 w=0.84 l=0.15 mult=1
+ sa=0.265 sb=0.265 sd=0.28 topography=normal area=0.063 perim=1.14
MI650 net194 M1 VPWR VPB pfet_01v8_hvt m=1 w=0.42 l=0.15 mult=1
+ sa=0.265 sb=0.265 sd=0.28 topography=normal area=0.063 perim=1.14
MI665 db D VPWR VPB pfet_01v8_hvt m=1 w=0.42 l=0.15 mult=1 sa=0.265
+ sb=0.265 sd=0.28 topography=normal area=0.063 perim=1.14
MI43 db clkpos M0 VPB pfet_01v8_hvt m=1 w=0.42 l=0.15 mult=1 sa=0.265
+ sb=0.265 sd=0.28 topography=normal area=0.063 perim=1.14
MI656 M0 clkneg net194 VPB pfet_01v8_hvt m=1 w=0.42 l=0.15 mult=1
+ sa=0.265 sb=0.265 sd=0.28 topography=normal area=0.063 perim=1.14
MI643 RESET RESET_B VPWR VPB pfet_01v8_hvt m=1 w=0.64 l=0.15 mult=1
+ sa=0.265 sb=0.265 sd=0.28 topography=normal area=0.063 perim=1.14
MI47 clkneg clkpos VPWR VPB pfet_01v8_hvt m=1 w=0.64 l=0.15 mult=1
+ sa=0.265 sb=0.265 sd=0.28 topography=normal area=0.063 perim=1.14
MI45 clkpos CLK_N VPWR VPB pfet_01v8_hvt m=1 w=0.64 l=0.15 mult=1
+ sa=0.265 sb=0.265 sd=0.28 topography=normal area=0.063 perim=1.14
MI680 M1 M0 net165 VPB pfet_01v8_hvt m=1 w=0.84 l=0.15 mult=1 sa=0.265
+ sb=0.265 sd=0.28 topography=normal area=0.063 perim=1.14
MI663 net162 net82 VPWR VPB pfet_01v8_hvt m=1 w=0.64 l=0.15 mult=1
+ sa=0.265 sb=0.265 sd=0.28 topography=normal area=0.063 perim=1.14
MI661 Q_N net82 VPWR VPB pfet_01v8_hvt m=2 w=1.0 l=0.15 mult=1
+ sa=0.265 sb=0.265 sd=0.28 topography=normal area=0.063 perim=1.14
.ENDS

.SUBCKT sky130_fd_sc_hd__dfbbp_1 CLK D RESET_B SET_B VGND VNB VPB VPWR Q Q_N
MI46 clkpos clkneg VGND VNB nfet_01v8 m=1 w=0.42 l=0.15 mult=1
+ sa=0.265 sb=0.265 sd=0.28 topography=normal area=0.063 perim=1.14
MI659 db D VGND VNB nfet_01v8 m=1 w=0.42 l=0.15 mult=1 sa=0.265
+ sb=0.265 sd=0.28 topography=normal area=0.063 perim=1.14
MI642 RESET RESET_B VGND VNB nfet_01v8 m=1 w=0.42 l=0.15 mult=1
+ sa=0.265 sb=0.265 sd=0.28 topography=normal area=0.063 perim=1.14
MI676 M1 M0 net141 VNB nfet_01v8 m=1 w=0.64 l=0.15 mult=1 sa=0.265
+ sb=0.265 sd=0.28 topography=normal area=0.063 perim=1.14
MI675 net141 SET_B VGND VNB nfet_01v8 m=1 w=0.42 l=0.15 mult=1
+ sa=0.265 sb=0.265 sd=0.28 topography=normal area=0.063 perim=1.14
MI653 Q net162 VGND VNB nfet_01v8 m=1 w=0.65 l=0.15 mult=1 sa=0.265
+ sb=0.265 sd=0.28 topography=normal area=0.063 perim=1.14
MI677 M1 RESET net141 VNB nfet_01v8 m=1 w=0.64 l=0.15 mult=1 sa=0.265
+ sb=0.265 sd=0.28 topography=normal area=0.063 perim=1.14
MI648 M0 clkpos net118 VNB nfet_01v8 m=1 w=0.36 l=0.15 mult=1 sa=0.265
+ sb=0.265 sd=0.28 topography=normal area=0.063 perim=1.14
MI44 clkneg CLK VGND VNB nfet_01v8 m=1 w=0.42 l=0.15 mult=1 sa=0.265
+ sb=0.265 sd=0.28 topography=normal area=0.063 perim=1.14
MI649 net118 M1 VGND VNB nfet_01v8 m=1 w=0.42 l=0.15 mult=1 sa=0.265
+ sb=0.265 sd=0.28 topography=normal area=0.063 perim=1.14
MI655 S0 clkneg net110 VNB nfet_01v8 m=1 w=0.36 l=0.15 mult=1 sa=0.265
+ sb=0.265 sd=0.28 topography=normal area=0.063 perim=1.14
MI654 net110 net82 VGND VNB nfet_01v8 m=1 w=0.42 l=0.15 mult=1
+ sa=0.265 sb=0.265 sd=0.28 topography=normal area=0.063 perim=1.14
MI651 Q_N net82 VGND VNB nfet_01v8 m=1 w=0.65 l=0.15 mult=1 sa=0.265
+ sb=0.265 sd=0.28 topography=normal area=0.063 perim=1.14
MI652 net162 net82 VGND VNB nfet_01v8 m=1 w=0.42 l=0.15 mult=1
+ sa=0.265 sb=0.265 sd=0.28 topography=normal area=0.063 perim=1.14
MI42 db clkneg M0 VNB nfet_01v8 m=1 w=0.36 l=0.15 mult=1 sa=0.265
+ sb=0.265 sd=0.28 topography=normal area=0.063 perim=1.14
MI668 S0 clkpos net93 VNB nfet_01v8 m=1 w=0.36 l=0.15 mult=1 sa=0.265
+ sb=0.265 sd=0.28 topography=normal area=0.063 perim=1.14
MI667 net93 M1 VGND VNB nfet_01v8 m=1 w=0.64 l=0.15 mult=1 sa=0.265
+ sb=0.265 sd=0.28 topography=normal area=0.063 perim=1.14
MI630 net82 RESET net81 VNB nfet_01v8 m=1 w=0.64 l=0.15 mult=1
+ sa=0.265 sb=0.265 sd=0.28 topography=normal area=0.063 perim=1.14
MI3 net82 S0 net81 VNB nfet_01v8 m=1 w=0.64 l=0.15 mult=1 sa=0.265
+ sb=0.265 sd=0.28 topography=normal area=0.063 perim=1.14
MI7 net81 SET_B VGND VNB nfet_01v8 m=1 w=0.42 l=0.15 mult=1 sa=0.265
+ sb=0.265 sd=0.28 topography=normal area=0.063 perim=1.14
MI679 M1 SET_B VPWR VPB pfet_01v8_hvt m=1 w=0.42 l=0.15 mult=1
+ sa=0.265 sb=0.265 sd=0.28 topography=normal area=0.063 perim=1.14
MI669 S0 clkneg net218 VPB pfet_01v8_hvt m=1 w=0.42 l=0.15 mult=1
+ sa=0.265 sb=0.265 sd=0.28 topography=normal area=0.063 perim=1.14
MI660 Q net162 VPWR VPB pfet_01v8_hvt m=1 w=1.0 l=0.15 mult=1 sa=0.265
+ sb=0.265 sd=0.28 topography=normal area=0.063 perim=1.14
MI9 net82 S0 net221 VPB pfet_01v8_hvt m=1 w=0.84 l=0.15 mult=1
+ sa=0.265 sb=0.265 sd=0.28 topography=normal area=0.063 perim=1.14
MI670 net218 M1 VPWR VPB pfet_01v8_hvt m=1 w=0.84 l=0.15 mult=1
+ sa=0.265 sb=0.265 sd=0.28 topography=normal area=0.063 perim=1.14
MI678 net165 RESET VPWR VPB pfet_01v8_hvt m=1 w=0.84 l=0.15 mult=1
+ sa=0.265 sb=0.265 sd=0.28 topography=normal area=0.063 perim=1.14
MI662 net210 net82 VPWR VPB pfet_01v8_hvt m=1 w=0.42 l=0.15 mult=1
+ sa=0.265 sb=0.265 sd=0.28 topography=normal area=0.063 perim=1.14
MI664 S0 clkpos net210 VPB pfet_01v8_hvt m=1 w=0.42 l=0.15 mult=1
+ sa=0.265 sb=0.265 sd=0.28 topography=normal area=0.063 perim=1.14
MI10 net82 SET_B VPWR VPB pfet_01v8_hvt m=1 w=0.42 l=0.15 mult=1
+ sa=0.265 sb=0.265 sd=0.28 topography=normal area=0.063 perim=1.14
MI11 net221 RESET VPWR VPB pfet_01v8_hvt m=1 w=0.84 l=0.15 mult=1
+ sa=0.265 sb=0.265 sd=0.28 topography=normal area=0.063 perim=1.14
MI650 net194 M1 VPWR VPB pfet_01v8_hvt m=1 w=0.42 l=0.15 mult=1
+ sa=0.265 sb=0.265 sd=0.28 topography=normal area=0.063 perim=1.14
MI665 db D VPWR VPB pfet_01v8_hvt m=1 w=0.42 l=0.15 mult=1 sa=0.265
+ sb=0.265 sd=0.28 topography=normal area=0.063 perim=1.14
MI43 db clkpos M0 VPB pfet_01v8_hvt m=1 w=0.42 l=0.15 mult=1 sa=0.265
+ sb=0.265 sd=0.28 topography=normal area=0.063 perim=1.14
MI656 M0 clkneg net194 VPB pfet_01v8_hvt m=1 w=0.42 l=0.15 mult=1
+ sa=0.265 sb=0.265 sd=0.28 topography=normal area=0.063 perim=1.14
MI643 RESET RESET_B VPWR VPB pfet_01v8_hvt m=1 w=0.64 l=0.15 mult=1
+ sa=0.265 sb=0.265 sd=0.28 topography=normal area=0.063 perim=1.14
MI47 clkpos clkneg VPWR VPB pfet_01v8_hvt m=1 w=0.64 l=0.15 mult=1
+ sa=0.265 sb=0.265 sd=0.28 topography=normal area=0.063 perim=1.14
MI45 clkneg CLK VPWR VPB pfet_01v8_hvt m=1 w=0.64 l=0.15 mult=1
+ sa=0.265 sb=0.265 sd=0.28 topography=normal area=0.063 perim=1.14
MI680 M1 M0 net165 VPB pfet_01v8_hvt m=1 w=0.84 l=0.15 mult=1 sa=0.265
+ sb=0.265 sd=0.28 topography=normal area=0.063 perim=1.14
MI663 net162 net82 VPWR VPB pfet_01v8_hvt m=1 w=0.64 l=0.15 mult=1
+ sa=0.265 sb=0.265 sd=0.28 topography=normal area=0.063 perim=1.14
MI661 Q_N net82 VPWR VPB pfet_01v8_hvt m=1 w=1.0 l=0.15 mult=1
+ sa=0.265 sb=0.265 sd=0.28 topography=normal area=0.063 perim=1.14
.ENDS

.SUBCKT sky130_fd_sc_hd__dfrbp_1 CLK D RESET_B VGND VNB VPB VPWR Q Q_N
MI46 clkpos clkneg VGND VNB nfet_01v8 m=1 w=0.42 l=0.15 mult=1
+ sa=0.265 sb=0.265 sd=0.28 topography=normal area=0.063 perim=1.14
MI42 db clkneg M0 VNB nfet_01v8 m=1 w=0.36 l=0.15 mult=1 sa=0.265
+ sb=0.265 sd=0.28 topography=normal area=0.063 perim=1.14
MI656 net99 s0 net125 VNB nfet_01v8 m=1 w=0.42 l=0.15 mult=1 sa=0.265
+ sb=0.265 sd=0.28 topography=normal area=0.063 perim=1.14
MI657 net125 RESET_B VGND VNB nfet_01v8 m=1 w=0.42 l=0.15 mult=1
+ sa=0.265 sb=0.265 sd=0.28 topography=normal area=0.063 perim=1.14
MI33 net118 RESET_B VGND VNB nfet_01v8 m=1 w=0.42 l=0.15 mult=1
+ sa=0.265 sb=0.265 sd=0.28 topography=normal area=0.063 perim=1.14
MI4 M0 clkpos net110 VNB nfet_01v8 m=1 w=0.36 l=0.15 mult=1 sa=0.265
+ sb=0.265 sd=0.28 topography=normal area=0.063 perim=1.14
MI34 net110 M1 net118 VNB nfet_01v8 m=1 w=0.42 l=0.15 mult=1 sa=0.265
+ sb=0.265 sd=0.28 topography=normal area=0.063 perim=1.14
MI655 s0 clkneg net98 VNB nfet_01v8 m=1 w=0.36 l=0.15 mult=1 sa=0.265
+ sb=0.265 sd=0.28 topography=normal area=0.063 perim=1.14
MI653 Q net99 VGND VNB nfet_01v8 m=1 w=0.65 l=0.15 mult=1 sa=0.265
+ sb=0.265 sd=0.28 topography=normal area=0.063 perim=1.14
MI654 net98 net99 VGND VNB nfet_01v8 m=1 w=0.42 l=0.15 mult=1 sa=0.265
+ sb=0.265 sd=0.28 topography=normal area=0.063 perim=1.14
MI44 clkneg CLK VGND VNB nfet_01v8 m=1 w=0.42 l=0.15 mult=1 sa=0.265
+ sb=0.265 sd=0.28 topography=normal area=0.063 perim=1.14
MI647 M1 M0 VGND VNB nfet_01v8 m=1 w=0.64 l=0.15 mult=1 sa=0.265
+ sb=0.265 sd=0.28 topography=normal area=0.063 perim=1.14
MI39 db D VGND VNB nfet_01v8 m=1 w=0.42 l=0.15 mult=1 sa=0.265
+ sb=0.265 sd=0.28 topography=normal area=0.063 perim=1.14
MI649 M1 clkpos s0 VNB nfet_01v8 m=1 w=0.36 l=0.15 mult=1 sa=0.265
+ sb=0.265 sd=0.28 topography=normal area=0.063 perim=1.14
MI53 net142 net99 VGND VNB nfet_01v8 m=1 w=0.42 l=0.15 mult=1 sa=0.265
+ sb=0.265 sd=0.28 topography=normal area=0.063 perim=1.14
MI50 Q_N net142 VGND VNB nfet_01v8 m=1 w=0.65 l=0.15 mult=1 sa=0.265
+ sb=0.265 sd=0.28 topography=normal area=0.063 perim=1.14
MI47 clkpos clkneg VPWR VPB pfet_01v8_hvt m=1 w=0.64 l=0.15 mult=1
+ sa=0.265 sb=0.265 sd=0.28 topography=normal area=0.063 perim=1.14
MI43 db clkpos M0 VPB pfet_01v8_hvt m=1 w=0.42 l=0.15 mult=1 sa=0.265
+ sb=0.265 sd=0.28 topography=normal area=0.063 perim=1.14
MI662 net190 net99 VPWR VPB pfet_01v8_hvt m=1 w=0.42 l=0.15 mult=1
+ sa=0.265 sb=0.265 sd=0.28 topography=normal area=0.063 perim=1.14
MI659 net99 RESET_B VPWR VPB pfet_01v8_hvt m=1 w=0.42 l=0.15 mult=1
+ sa=0.265 sb=0.265 sd=0.28 topography=normal area=0.063 perim=1.14
MI664 s0 clkpos net190 VPB pfet_01v8_hvt m=1 w=0.42 l=0.15 mult=1
+ sa=0.265 sb=0.265 sd=0.28 topography=normal area=0.063 perim=1.14
MI658 net99 s0 VPWR VPB pfet_01v8_hvt m=1 w=0.42 l=0.15 mult=1
+ sa=0.265 sb=0.265 sd=0.28 topography=normal area=0.063 perim=1.14
MI30 net169 M1 VPWR VPB pfet_01v8_hvt m=1 w=0.42 l=0.15 mult=1
+ sa=0.265 sb=0.265 sd=0.28 topography=normal area=0.063 perim=1.14
MI31 M0 clkneg net169 VPB pfet_01v8_hvt m=1 w=0.42 l=0.15 mult=1
+ sa=0.265 sb=0.265 sd=0.28 topography=normal area=0.063 perim=1.14
MI32 net169 RESET_B VPWR VPB pfet_01v8_hvt m=1 w=0.42 l=0.15 mult=1
+ sa=0.265 sb=0.265 sd=0.28 topography=normal area=0.063 perim=1.14
MI660 Q net99 VPWR VPB pfet_01v8_hvt m=1 w=1.0 l=0.15 mult=1 sa=0.265
+ sb=0.265 sd=0.28 topography=normal area=0.063 perim=1.14
MI45 clkneg CLK VPWR VPB pfet_01v8_hvt m=1 w=0.64 l=0.15 mult=1
+ sa=0.265 sb=0.265 sd=0.28 topography=normal area=0.063 perim=1.14
MI648 M1 M0 VPWR VPB pfet_01v8_hvt m=1 w=0.84 l=0.15 mult=1 sa=0.265
+ sb=0.265 sd=0.28 topography=normal area=0.063 perim=1.14
MI40 db D VPWR VPB pfet_01v8_hvt m=1 w=0.42 l=0.15 mult=1 sa=0.265
+ sb=0.265 sd=0.28 topography=normal area=0.063 perim=1.14
MI650 M1 clkneg s0 VPB pfet_01v8_hvt m=1 w=0.42 l=0.15 mult=1 sa=0.265
+ sb=0.265 sd=0.28 topography=normal area=0.063 perim=1.14
MI52 net142 net99 VPWR VPB pfet_01v8_hvt m=1 w=0.64 l=0.15 mult=1
+ sa=0.265 sb=0.265 sd=0.28 topography=normal area=0.063 perim=1.14
MI51 Q_N net142 VPWR VPB pfet_01v8_hvt m=1 w=1.0 l=0.15 mult=1
+ sa=0.265 sb=0.265 sd=0.28 topography=normal area=0.063 perim=1.14
.ENDS

.SUBCKT sky130_fd_sc_hd__dfrbp_2 CLK D RESET_B VGND VNB VPB VPWR Q Q_N
MI46 clkpos clkneg VGND VNB nfet_01v8 m=1 w=0.42 l=0.15 mult=1
+ sa=0.265 sb=0.265 sd=0.28 topography=normal area=0.063 perim=1.14
MI42 db clkneg M0 VNB nfet_01v8 m=1 w=0.36 l=0.15 mult=1 sa=0.265
+ sb=0.265 sd=0.28 topography=normal area=0.063 perim=1.14
MI656 net99 s0 net125 VNB nfet_01v8 m=1 w=0.42 l=0.15 mult=1 sa=0.265
+ sb=0.265 sd=0.28 topography=normal area=0.063 perim=1.14
MI657 net125 RESET_B VGND VNB nfet_01v8 m=1 w=0.42 l=0.15 mult=1
+ sa=0.265 sb=0.265 sd=0.28 topography=normal area=0.063 perim=1.14
MI33 net118 RESET_B VGND VNB nfet_01v8 m=1 w=0.42 l=0.15 mult=1
+ sa=0.265 sb=0.265 sd=0.28 topography=normal area=0.063 perim=1.14
MI4 M0 clkpos net110 VNB nfet_01v8 m=1 w=0.36 l=0.15 mult=1 sa=0.265
+ sb=0.265 sd=0.28 topography=normal area=0.063 perim=1.14
MI34 net110 M1 net118 VNB nfet_01v8 m=1 w=0.42 l=0.15 mult=1 sa=0.265
+ sb=0.265 sd=0.28 topography=normal area=0.063 perim=1.14
MI655 s0 clkneg net98 VNB nfet_01v8 m=1 w=0.36 l=0.15 mult=1 sa=0.265
+ sb=0.265 sd=0.28 topography=normal area=0.063 perim=1.14
MI653 Q net99 VGND VNB nfet_01v8 m=2 w=0.65 l=0.15 mult=1 sa=0.265
+ sb=0.265 sd=0.28 topography=normal area=0.063 perim=1.14
MI654 net98 net99 VGND VNB nfet_01v8 m=1 w=0.42 l=0.15 mult=1 sa=0.265
+ sb=0.265 sd=0.28 topography=normal area=0.063 perim=1.14
MI44 clkneg CLK VGND VNB nfet_01v8 m=1 w=0.42 l=0.15 mult=1 sa=0.265
+ sb=0.265 sd=0.28 topography=normal area=0.063 perim=1.14
MI647 M1 M0 VGND VNB nfet_01v8 m=1 w=0.64 l=0.15 mult=1 sa=0.265
+ sb=0.265 sd=0.28 topography=normal area=0.063 perim=1.14
MI39 db D VGND VNB nfet_01v8 m=1 w=0.42 l=0.15 mult=1 sa=0.265
+ sb=0.265 sd=0.28 topography=normal area=0.063 perim=1.14
MI649 M1 clkpos s0 VNB nfet_01v8 m=1 w=0.36 l=0.15 mult=1 sa=0.265
+ sb=0.265 sd=0.28 topography=normal area=0.063 perim=1.14
MI53 net142 net99 VGND VNB nfet_01v8 m=1 w=0.42 l=0.15 mult=1 sa=0.265
+ sb=0.265 sd=0.28 topography=normal area=0.063 perim=1.14
MI50 Q_N net142 VGND VNB nfet_01v8 m=2 w=0.65 l=0.15 mult=1 sa=0.265
+ sb=0.265 sd=0.28 topography=normal area=0.063 perim=1.14
MI47 clkpos clkneg VPWR VPB pfet_01v8_hvt m=1 w=0.64 l=0.15 mult=1
+ sa=0.265 sb=0.265 sd=0.28 topography=normal area=0.063 perim=1.14
MI43 db clkpos M0 VPB pfet_01v8_hvt m=1 w=0.42 l=0.15 mult=1 sa=0.265
+ sb=0.265 sd=0.28 topography=normal area=0.063 perim=1.14
MI662 net181 net99 VPWR VPB pfet_01v8_hvt m=1 w=0.42 l=0.15 mult=1
+ sa=0.265 sb=0.265 sd=0.28 topography=normal area=0.063 perim=1.14
MI659 net99 RESET_B VPWR VPB pfet_01v8_hvt m=1 w=0.42 l=0.15 mult=1
+ sa=0.265 sb=0.265 sd=0.28 topography=normal area=0.063 perim=1.14
MI664 s0 clkpos net181 VPB pfet_01v8_hvt m=1 w=0.42 l=0.15 mult=1
+ sa=0.265 sb=0.265 sd=0.28 topography=normal area=0.063 perim=1.14
MI658 net99 s0 VPWR VPB pfet_01v8_hvt m=1 w=0.42 l=0.15 mult=1
+ sa=0.265 sb=0.265 sd=0.28 topography=normal area=0.063 perim=1.14
MI30 net169 M1 VPWR VPB pfet_01v8_hvt m=1 w=0.42 l=0.15 mult=1
+ sa=0.265 sb=0.265 sd=0.28 topography=normal area=0.063 perim=1.14
MI31 M0 clkneg net169 VPB pfet_01v8_hvt m=1 w=0.42 l=0.15 mult=1
+ sa=0.265 sb=0.265 sd=0.28 topography=normal area=0.063 perim=1.14
MI32 net169 RESET_B VPWR VPB pfet_01v8_hvt m=1 w=0.42 l=0.15 mult=1
+ sa=0.265 sb=0.265 sd=0.28 topography=normal area=0.063 perim=1.14
MI660 Q net99 VPWR VPB pfet_01v8_hvt m=2 w=1.0 l=0.15 mult=1 sa=0.265
+ sb=0.265 sd=0.28 topography=normal area=0.063 perim=1.14
MI45 clkneg CLK VPWR VPB pfet_01v8_hvt m=1 w=0.64 l=0.15 mult=1
+ sa=0.265 sb=0.265 sd=0.28 topography=normal area=0.063 perim=1.14
MI648 M1 M0 VPWR VPB pfet_01v8_hvt m=1 w=0.84 l=0.15 mult=1 sa=0.265
+ sb=0.265 sd=0.28 topography=normal area=0.063 perim=1.14
MI40 db D VPWR VPB pfet_01v8_hvt m=1 w=0.42 l=0.15 mult=1 sa=0.265
+ sb=0.265 sd=0.28 topography=normal area=0.063 perim=1.14
MI650 M1 clkneg s0 VPB pfet_01v8_hvt m=1 w=0.42 l=0.15 mult=1 sa=0.265
+ sb=0.265 sd=0.28 topography=normal area=0.063 perim=1.14
MI52 net142 net99 VPWR VPB pfet_01v8_hvt m=1 w=0.64 l=0.15 mult=1
+ sa=0.265 sb=0.265 sd=0.28 topography=normal area=0.063 perim=1.14
MI51 Q_N net142 VPWR VPB pfet_01v8_hvt m=2 w=1.0 l=0.15 mult=1
+ sa=0.265 sb=0.265 sd=0.28 topography=normal area=0.063 perim=1.14
.ENDS

.SUBCKT sky130_fd_sc_hd__dfrtn_1 CLK_N D RESET_B VGND VNB VPB VPWR Q
MI46 clkneg clkpos VGND VNB nfet_01v8 m=1 w=0.42 l=0.15 mult=1
+ sa=0.265 sb=0.265 sd=0.28 topography=normal area=0.063 perim=1.14
MI42 db clkneg M0 VNB nfet_01v8 m=1 w=0.36 l=0.15 mult=1 sa=0.265
+ sb=0.265 sd=0.28 topography=normal area=0.063 perim=1.14
MI656 net83 net121 net109 VNB nfet_01v8 m=1 w=0.42 l=0.15 mult=1
+ sa=0.265 sb=0.265 sd=0.28 topography=normal area=0.063 perim=1.14
MI657 net109 RESET_B VGND VNB nfet_01v8 m=1 w=0.42 l=0.15 mult=1
+ sa=0.265 sb=0.265 sd=0.28 topography=normal area=0.063 perim=1.14
MI33 net102 RESET_B VGND VNB nfet_01v8 m=1 w=0.42 l=0.15 mult=1
+ sa=0.265 sb=0.265 sd=0.28 topography=normal area=0.063 perim=1.14
MI4 M0 clkpos net94 VNB nfet_01v8 m=1 w=0.36 l=0.15 mult=1 sa=0.265
+ sb=0.265 sd=0.28 topography=normal area=0.063 perim=1.14
MI34 net94 M1 net102 VNB nfet_01v8 m=1 w=0.42 l=0.15 mult=1 sa=0.265
+ sb=0.265 sd=0.28 topography=normal area=0.063 perim=1.14
MI655 net121 clkneg net82 VNB nfet_01v8 m=1 w=0.36 l=0.15 mult=1
+ sa=0.265 sb=0.265 sd=0.28 topography=normal area=0.063 perim=1.14
MI653 Q net83 VGND VNB nfet_01v8 m=1 w=0.65 l=0.15 mult=1 sa=0.265
+ sb=0.265 sd=0.28 topography=normal area=0.063 perim=1.14
MI654 net82 net83 VGND VNB nfet_01v8 m=1 w=0.42 l=0.15 mult=1 sa=0.265
+ sb=0.265 sd=0.28 topography=normal area=0.063 perim=1.14
MI44 clkpos CLK_N VGND VNB nfet_01v8 m=1 w=0.42 l=0.15 mult=1 sa=0.265
+ sb=0.265 sd=0.28 topography=normal area=0.063 perim=1.14
MI647 M1 M0 VGND VNB nfet_01v8 m=1 w=0.64 l=0.15 mult=1 sa=0.265
+ sb=0.265 sd=0.28 topography=normal area=0.063 perim=1.14
MI39 db D VGND VNB nfet_01v8 m=1 w=0.42 l=0.15 mult=1 sa=0.265
+ sb=0.265 sd=0.28 topography=normal area=0.063 perim=1.14
MI649 M1 clkpos net121 VNB nfet_01v8 m=1 w=0.36 l=0.15 mult=1 sa=0.265
+ sb=0.265 sd=0.28 topography=normal area=0.063 perim=1.14
MI47 clkneg clkpos VPWR VPB pfet_01v8_hvt m=1 w=0.64 l=0.15 mult=1
+ sa=0.265 sb=0.265 sd=0.28 topography=normal area=0.063 perim=1.14
MI43 db clkpos M0 VPB pfet_01v8_hvt m=1 w=0.42 l=0.15 mult=1 sa=0.265
+ sb=0.265 sd=0.28 topography=normal area=0.063 perim=1.14
MI662 net166 net83 VPWR VPB pfet_01v8_hvt m=1 w=0.42 l=0.15 mult=1
+ sa=0.265 sb=0.265 sd=0.28 topography=normal area=0.063 perim=1.14
MI659 net83 RESET_B VPWR VPB pfet_01v8_hvt m=1 w=0.42 l=0.15 mult=1
+ sa=0.265 sb=0.265 sd=0.28 topography=normal area=0.063 perim=1.14
MI664 net121 clkpos net166 VPB pfet_01v8_hvt m=1 w=0.42 l=0.15 mult=1
+ sa=0.265 sb=0.265 sd=0.28 topography=normal area=0.063 perim=1.14
MI658 net83 net121 VPWR VPB pfet_01v8_hvt m=1 w=0.42 l=0.15 mult=1
+ sa=0.265 sb=0.265 sd=0.28 topography=normal area=0.063 perim=1.14
MI30 net145 M1 VPWR VPB pfet_01v8_hvt m=1 w=0.42 l=0.15 mult=1
+ sa=0.265 sb=0.265 sd=0.28 topography=normal area=0.063 perim=1.14
MI31 M0 clkneg net145 VPB pfet_01v8_hvt m=1 w=0.42 l=0.15 mult=1
+ sa=0.265 sb=0.265 sd=0.28 topography=normal area=0.063 perim=1.14
MI32 net145 RESET_B VPWR VPB pfet_01v8_hvt m=1 w=0.42 l=0.15 mult=1
+ sa=0.265 sb=0.265 sd=0.28 topography=normal area=0.063 perim=1.14
MI660 Q net83 VPWR VPB pfet_01v8_hvt m=1 w=1.0 l=0.15 mult=1 sa=0.265
+ sb=0.265 sd=0.28 topography=normal area=0.063 perim=1.14
MI45 clkpos CLK_N VPWR VPB pfet_01v8_hvt m=1 w=0.64 l=0.15 mult=1
+ sa=0.265 sb=0.265 sd=0.28 topography=normal area=0.063 perim=1.14
MI648 M1 M0 VPWR VPB pfet_01v8_hvt m=1 w=0.84 l=0.15 mult=1 sa=0.265
+ sb=0.265 sd=0.28 topography=normal area=0.063 perim=1.14
MI40 db D VPWR VPB pfet_01v8_hvt m=1 w=0.42 l=0.15 mult=1 sa=0.265
+ sb=0.265 sd=0.28 topography=normal area=0.063 perim=1.14
MI650 M1 clkneg net121 VPB pfet_01v8_hvt m=1 w=0.42 l=0.15 mult=1
+ sa=0.265 sb=0.265 sd=0.28 topography=normal area=0.063 perim=1.14
.ENDS

.SUBCKT sky130_fd_sc_hd__dfrtp_1 CLK D RESET_B VGND VNB VPB VPWR Q
MI46 clkpos clkneg VGND VNB nfet_01v8 m=1 w=0.42 l=0.15 mult=1
+ sa=0.265 sb=0.265 sd=0.28 topography=normal area=0.063 perim=1.14
MI42 db clkneg M0 VNB nfet_01v8 m=1 w=0.36 l=0.15 mult=1 sa=0.265
+ sb=0.265 sd=0.28 topography=normal area=0.063 perim=1.14
MI656 net82 s0 net108 VNB nfet_01v8 m=1 w=0.42 l=0.15 mult=1 sa=0.265
+ sb=0.265 sd=0.28 topography=normal area=0.063 perim=1.14
MI657 net108 RESET_B VGND VNB nfet_01v8 m=1 w=0.42 l=0.15 mult=1
+ sa=0.265 sb=0.265 sd=0.28 topography=normal area=0.063 perim=1.14
MI33 net101 RESET_B VGND VNB nfet_01v8 m=1 w=0.42 l=0.15 mult=1
+ sa=0.265 sb=0.265 sd=0.28 topography=normal area=0.063 perim=1.14
MI4 M0 clkpos net93 VNB nfet_01v8 m=1 w=0.36 l=0.15 mult=1 sa=0.265
+ sb=0.265 sd=0.28 topography=normal area=0.063 perim=1.14
MI34 net93 M1 net101 VNB nfet_01v8 m=1 w=0.42 l=0.15 mult=1 sa=0.265
+ sb=0.265 sd=0.28 topography=normal area=0.063 perim=1.14
MI655 s0 clkneg net81 VNB nfet_01v8 m=1 w=0.36 l=0.15 mult=1 sa=0.265
+ sb=0.265 sd=0.28 topography=normal area=0.063 perim=1.14
MI653 Q net82 VGND VNB nfet_01v8 m=1 w=0.65 l=0.15 mult=1 sa=0.265
+ sb=0.265 sd=0.28 topography=normal area=0.063 perim=1.14
MI654 net81 net82 VGND VNB nfet_01v8 m=1 w=0.42 l=0.15 mult=1 sa=0.265
+ sb=0.265 sd=0.28 topography=normal area=0.063 perim=1.14
MI44 clkneg CLK VGND VNB nfet_01v8 m=1 w=0.42 l=0.15 mult=1 sa=0.265
+ sb=0.265 sd=0.28 topography=normal area=0.063 perim=1.14
MI647 M1 M0 VGND VNB nfet_01v8 m=1 w=0.64 l=0.15 mult=1 sa=0.265
+ sb=0.265 sd=0.28 topography=normal area=0.063 perim=1.14
MI39 db D VGND VNB nfet_01v8 m=1 w=0.42 l=0.15 mult=1 sa=0.265
+ sb=0.265 sd=0.28 topography=normal area=0.063 perim=1.14
MI649 M1 clkpos s0 VNB nfet_01v8 m=1 w=0.36 l=0.15 mult=1 sa=0.265
+ sb=0.265 sd=0.28 topography=normal area=0.063 perim=1.14
MI47 clkpos clkneg VPWR VPB pfet_01v8_hvt m=1 w=0.64 l=0.15 mult=1
+ sa=0.265 sb=0.265 sd=0.28 topography=normal area=0.063 perim=1.14
MI43 db clkpos M0 VPB pfet_01v8_hvt m=1 w=0.42 l=0.15 mult=1 sa=0.265
+ sb=0.265 sd=0.28 topography=normal area=0.063 perim=1.14
MI662 net165 net82 VPWR VPB pfet_01v8_hvt m=1 w=0.42 l=0.15 mult=1
+ sa=0.265 sb=0.265 sd=0.28 topography=normal area=0.063 perim=1.14
MI659 net82 RESET_B VPWR VPB pfet_01v8_hvt m=1 w=0.42 l=0.15 mult=1
+ sa=0.265 sb=0.265 sd=0.28 topography=normal area=0.063 perim=1.14
MI664 s0 clkpos net165 VPB pfet_01v8_hvt m=1 w=0.42 l=0.15 mult=1
+ sa=0.265 sb=0.265 sd=0.28 topography=normal area=0.063 perim=1.14
MI658 net82 s0 VPWR VPB pfet_01v8_hvt m=1 w=0.42 l=0.15 mult=1
+ sa=0.265 sb=0.265 sd=0.28 topography=normal area=0.063 perim=1.14
MI30 net144 M1 VPWR VPB pfet_01v8_hvt m=1 w=0.42 l=0.15 mult=1
+ sa=0.265 sb=0.265 sd=0.28 topography=normal area=0.063 perim=1.14
MI31 M0 clkneg net144 VPB pfet_01v8_hvt m=1 w=0.42 l=0.15 mult=1
+ sa=0.265 sb=0.265 sd=0.28 topography=normal area=0.063 perim=1.14
MI32 net144 RESET_B VPWR VPB pfet_01v8_hvt m=1 w=0.42 l=0.15 mult=1
+ sa=0.265 sb=0.265 sd=0.28 topography=normal area=0.063 perim=1.14
MI660 Q net82 VPWR VPB pfet_01v8_hvt m=1 w=1.0 l=0.15 mult=1 sa=0.265
+ sb=0.265 sd=0.28 topography=normal area=0.063 perim=1.14
MI45 clkneg CLK VPWR VPB pfet_01v8_hvt m=1 w=0.64 l=0.15 mult=1
+ sa=0.265 sb=0.265 sd=0.28 topography=normal area=0.063 perim=1.14
MI648 M1 M0 VPWR VPB pfet_01v8_hvt m=1 w=0.84 l=0.15 mult=1 sa=0.265
+ sb=0.265 sd=0.28 topography=normal area=0.063 perim=1.14
MI40 db D VPWR VPB pfet_01v8_hvt m=1 w=0.42 l=0.15 mult=1 sa=0.265
+ sb=0.265 sd=0.28 topography=normal area=0.063 perim=1.14
MI650 M1 clkneg s0 VPB pfet_01v8_hvt m=1 w=0.42 l=0.15 mult=1 sa=0.265
+ sb=0.265 sd=0.28 topography=normal area=0.063 perim=1.14
.ENDS

.SUBCKT sky130_fd_sc_hd__dfrtp_2 CLK D RESET_B VGND VNB VPB VPWR Q
MI46 clkpos clkneg VGND VNB nfet_01v8 m=1 w=0.42 l=0.15 mult=1
+ sa=0.265 sb=0.265 sd=0.28 topography=normal area=0.063 perim=1.14
MI42 db clkneg M0 VNB nfet_01v8 m=1 w=0.36 l=0.15 mult=1 sa=0.265
+ sb=0.265 sd=0.28 topography=normal area=0.063 perim=1.14
MI656 net82 s0 net108 VNB nfet_01v8 m=1 w=0.42 l=0.15 mult=1 sa=0.265
+ sb=0.265 sd=0.28 topography=normal area=0.063 perim=1.14
MI657 net108 RESET_B VGND VNB nfet_01v8 m=1 w=0.42 l=0.15 mult=1
+ sa=0.265 sb=0.265 sd=0.28 topography=normal area=0.063 perim=1.14
MI33 net101 RESET_B VGND VNB nfet_01v8 m=1 w=0.42 l=0.15 mult=1
+ sa=0.265 sb=0.265 sd=0.28 topography=normal area=0.063 perim=1.14
MI4 M0 clkpos net93 VNB nfet_01v8 m=1 w=0.36 l=0.15 mult=1 sa=0.265
+ sb=0.265 sd=0.28 topography=normal area=0.063 perim=1.14
MI34 net93 M1 net101 VNB nfet_01v8 m=1 w=0.42 l=0.15 mult=1 sa=0.265
+ sb=0.265 sd=0.28 topography=normal area=0.063 perim=1.14
MI655 s0 clkneg net81 VNB nfet_01v8 m=1 w=0.36 l=0.15 mult=1 sa=0.265
+ sb=0.265 sd=0.28 topography=normal area=0.063 perim=1.14
MI653 Q net82 VGND VNB nfet_01v8 m=2 w=0.65 l=0.15 mult=1 sa=0.265
+ sb=0.265 sd=0.28 topography=normal area=0.063 perim=1.14
MI654 net81 net82 VGND VNB nfet_01v8 m=1 w=0.42 l=0.15 mult=1 sa=0.265
+ sb=0.265 sd=0.28 topography=normal area=0.063 perim=1.14
MI44 clkneg CLK VGND VNB nfet_01v8 m=1 w=0.42 l=0.15 mult=1 sa=0.265
+ sb=0.265 sd=0.28 topography=normal area=0.063 perim=1.14
MI647 M1 M0 VGND VNB nfet_01v8 m=1 w=0.64 l=0.15 mult=1 sa=0.265
+ sb=0.265 sd=0.28 topography=normal area=0.063 perim=1.14
MI39 db D VGND VNB nfet_01v8 m=1 w=0.42 l=0.15 mult=1 sa=0.265
+ sb=0.265 sd=0.28 topography=normal area=0.063 perim=1.14
MI649 M1 clkpos s0 VNB nfet_01v8 m=1 w=0.36 l=0.15 mult=1 sa=0.265
+ sb=0.265 sd=0.28 topography=normal area=0.063 perim=1.14
MI47 clkpos clkneg VPWR VPB pfet_01v8_hvt m=1 w=0.64 l=0.15 mult=1
+ sa=0.265 sb=0.265 sd=0.28 topography=normal area=0.063 perim=1.14
MI43 db clkpos M0 VPB pfet_01v8_hvt m=1 w=0.42 l=0.15 mult=1 sa=0.265
+ sb=0.265 sd=0.28 topography=normal area=0.063 perim=1.14
MI662 net156 net82 VPWR VPB pfet_01v8_hvt m=1 w=0.42 l=0.15 mult=1
+ sa=0.265 sb=0.265 sd=0.28 topography=normal area=0.063 perim=1.14
MI659 net82 RESET_B VPWR VPB pfet_01v8_hvt m=1 w=0.42 l=0.15 mult=1
+ sa=0.265 sb=0.265 sd=0.28 topography=normal area=0.063 perim=1.14
MI664 s0 clkpos net156 VPB pfet_01v8_hvt m=1 w=0.42 l=0.15 mult=1
+ sa=0.265 sb=0.265 sd=0.28 topography=normal area=0.063 perim=1.14
MI658 net82 s0 VPWR VPB pfet_01v8_hvt m=1 w=0.42 l=0.15 mult=1
+ sa=0.265 sb=0.265 sd=0.28 topography=normal area=0.063 perim=1.14
MI30 net144 M1 VPWR VPB pfet_01v8_hvt m=1 w=0.42 l=0.15 mult=1
+ sa=0.265 sb=0.265 sd=0.28 topography=normal area=0.063 perim=1.14
MI31 M0 clkneg net144 VPB pfet_01v8_hvt m=1 w=0.42 l=0.15 mult=1
+ sa=0.265 sb=0.265 sd=0.28 topography=normal area=0.063 perim=1.14
MI32 net144 RESET_B VPWR VPB pfet_01v8_hvt m=1 w=0.42 l=0.15 mult=1
+ sa=0.265 sb=0.265 sd=0.28 topography=normal area=0.063 perim=1.14
MI660 Q net82 VPWR VPB pfet_01v8_hvt m=2 w=1.0 l=0.15 mult=1 sa=0.265
+ sb=0.265 sd=0.28 topography=normal area=0.063 perim=1.14
MI45 clkneg CLK VPWR VPB pfet_01v8_hvt m=1 w=0.64 l=0.15 mult=1
+ sa=0.265 sb=0.265 sd=0.28 topography=normal area=0.063 perim=1.14
MI648 M1 M0 VPWR VPB pfet_01v8_hvt m=1 w=0.84 l=0.15 mult=1 sa=0.265
+ sb=0.265 sd=0.28 topography=normal area=0.063 perim=1.14
MI40 db D VPWR VPB pfet_01v8_hvt m=1 w=0.42 l=0.15 mult=1 sa=0.265
+ sb=0.265 sd=0.28 topography=normal area=0.063 perim=1.14
MI650 M1 clkneg s0 VPB pfet_01v8_hvt m=1 w=0.42 l=0.15 mult=1 sa=0.265
+ sb=0.265 sd=0.28 topography=normal area=0.063 perim=1.14
.ENDS

.SUBCKT sky130_fd_sc_hd__dfrtp_4 CLK D RESET_B VGND VNB VPB VPWR Q
MI46 clkpos clkneg VGND VNB nfet_01v8 m=1 w=0.42 l=0.15 mult=1
+ sa=0.265 sb=0.265 sd=0.28 topography=normal area=0.063 perim=1.14
MI42 db clkneg M0 VNB nfet_01v8 m=1 w=0.36 l=0.15 mult=1 sa=0.265
+ sb=0.265 sd=0.28 topography=normal area=0.063 perim=1.14
MI656 net82 s0 net108 VNB nfet_01v8 m=1 w=0.42 l=0.15 mult=1 sa=0.265
+ sb=0.265 sd=0.28 topography=normal area=0.063 perim=1.14
MI657 net108 RESET_B VGND VNB nfet_01v8 m=1 w=0.42 l=0.15 mult=1
+ sa=0.265 sb=0.265 sd=0.28 topography=normal area=0.063 perim=1.14
MI33 net101 RESET_B VGND VNB nfet_01v8 m=1 w=0.42 l=0.15 mult=1
+ sa=0.265 sb=0.265 sd=0.28 topography=normal area=0.063 perim=1.14
MI4 M0 clkpos net93 VNB nfet_01v8 m=1 w=0.36 l=0.15 mult=1 sa=0.265
+ sb=0.265 sd=0.28 topography=normal area=0.063 perim=1.14
MI34 net93 M1 net101 VNB nfet_01v8 m=1 w=0.42 l=0.15 mult=1 sa=0.265
+ sb=0.265 sd=0.28 topography=normal area=0.063 perim=1.14
MI655 s0 clkneg net81 VNB nfet_01v8 m=1 w=0.36 l=0.15 mult=1 sa=0.265
+ sb=0.265 sd=0.28 topography=normal area=0.063 perim=1.14
MI653 Q net82 VGND VNB nfet_01v8 m=4 w=0.65 l=0.15 mult=1 sa=0.265
+ sb=0.265 sd=0.28 topography=normal area=0.063 perim=1.14
MI654 net81 net82 VGND VNB nfet_01v8 m=1 w=0.42 l=0.15 mult=1 sa=0.265
+ sb=0.265 sd=0.28 topography=normal area=0.063 perim=1.14
MI44 clkneg CLK VGND VNB nfet_01v8 m=1 w=0.42 l=0.15 mult=1 sa=0.265
+ sb=0.265 sd=0.28 topography=normal area=0.063 perim=1.14
MI647 M1 M0 VGND VNB nfet_01v8 m=1 w=0.64 l=0.15 mult=1 sa=0.265
+ sb=0.265 sd=0.28 topography=normal area=0.063 perim=1.14
MI39 db D VGND VNB nfet_01v8 m=1 w=0.42 l=0.15 mult=1 sa=0.265
+ sb=0.265 sd=0.28 topography=normal area=0.063 perim=1.14
MI649 M1 clkpos s0 VNB nfet_01v8 m=1 w=0.36 l=0.15 mult=1 sa=0.265
+ sb=0.265 sd=0.28 topography=normal area=0.063 perim=1.14
MI47 clkpos clkneg VPWR VPB pfet_01v8_hvt m=1 w=0.64 l=0.15 mult=1
+ sa=0.265 sb=0.265 sd=0.28 topography=normal area=0.063 perim=1.14
MI43 db clkpos M0 VPB pfet_01v8_hvt m=1 w=0.42 l=0.15 mult=1 sa=0.265
+ sb=0.265 sd=0.28 topography=normal area=0.063 perim=1.14
MI662 net165 net82 VPWR VPB pfet_01v8_hvt m=1 w=0.42 l=0.15 mult=1
+ sa=0.265 sb=0.265 sd=0.28 topography=normal area=0.063 perim=1.14
MI659 net82 RESET_B VPWR VPB pfet_01v8_hvt m=1 w=0.42 l=0.15 mult=1
+ sa=0.265 sb=0.265 sd=0.28 topography=normal area=0.063 perim=1.14
MI664 s0 clkpos net165 VPB pfet_01v8_hvt m=1 w=0.42 l=0.15 mult=1
+ sa=0.265 sb=0.265 sd=0.28 topography=normal area=0.063 perim=1.14
MI658 net82 s0 VPWR VPB pfet_01v8_hvt m=1 w=0.42 l=0.15 mult=1
+ sa=0.265 sb=0.265 sd=0.28 topography=normal area=0.063 perim=1.14
MI30 net144 M1 VPWR VPB pfet_01v8_hvt m=1 w=0.42 l=0.15 mult=1
+ sa=0.265 sb=0.265 sd=0.28 topography=normal area=0.063 perim=1.14
MI31 M0 clkneg net144 VPB pfet_01v8_hvt m=1 w=0.42 l=0.15 mult=1
+ sa=0.265 sb=0.265 sd=0.28 topography=normal area=0.063 perim=1.14
MI32 net144 RESET_B VPWR VPB pfet_01v8_hvt m=1 w=0.42 l=0.15 mult=1
+ sa=0.265 sb=0.265 sd=0.28 topography=normal area=0.063 perim=1.14
MI660 Q net82 VPWR VPB pfet_01v8_hvt m=4 w=1.0 l=0.15 mult=1 sa=0.265
+ sb=0.265 sd=0.28 topography=normal area=0.063 perim=1.14
MI45 clkneg CLK VPWR VPB pfet_01v8_hvt m=1 w=0.64 l=0.15 mult=1
+ sa=0.265 sb=0.265 sd=0.28 topography=normal area=0.063 perim=1.14
MI648 M1 M0 VPWR VPB pfet_01v8_hvt m=1 w=0.84 l=0.15 mult=1 sa=0.265
+ sb=0.265 sd=0.28 topography=normal area=0.063 perim=1.14
MI40 db D VPWR VPB pfet_01v8_hvt m=1 w=0.42 l=0.15 mult=1 sa=0.265
+ sb=0.265 sd=0.28 topography=normal area=0.063 perim=1.14
MI650 M1 clkneg s0 VPB pfet_01v8_hvt m=1 w=0.42 l=0.15 mult=1 sa=0.265
+ sb=0.265 sd=0.28 topography=normal area=0.063 perim=1.14
.ENDS

.SUBCKT sky130_fd_sc_hd__dfsbp_1 CLK D SET_B VGND VNB VPB VPWR Q Q_N
MI36 net129 M0 VGND VNB nfet_01v8 m=1 w=0.42 l=0.15 mult=1 sa=0.265
+ sb=0.265 sd=0.28 topography=normal area=0.063 perim=1.14
MI42 db clkneg M0 VNB nfet_01v8 m=1 w=0.36 l=0.15 mult=1 sa=0.265
+ sb=0.265 sd=0.28 topography=normal area=0.063 perim=1.14
MI44 clkneg CLK VGND VNB nfet_01v8 m=1 w=0.42 l=0.15 mult=1 sa=0.265
+ sb=0.265 sd=0.28 topography=normal area=0.063 perim=1.14
MI39 db D VGND VNB nfet_01v8 m=1 w=0.64 l=0.15 mult=1 sa=0.265
+ sb=0.265 sd=0.28 topography=normal area=0.063 perim=1.14
MI656 M1 M0 net112 VNB nfet_01v8 m=1 w=0.42 l=0.15 mult=1 sa=0.265
+ sb=0.265 sd=0.28 topography=normal area=0.063 perim=1.14
MI654 net80 M1 VGND VNB nfet_01v8 m=1 w=0.42 l=0.15 mult=1 sa=0.265
+ sb=0.265 sd=0.28 topography=normal area=0.063 perim=1.14
MI34 S0 clkpos net129 VNB nfet_01v8 m=1 w=0.42 l=0.15 mult=1 sa=0.265
+ sb=0.265 sd=0.28 topography=normal area=0.063 perim=1.14
MI46 clkpos clkneg VGND VNB nfet_01v8 m=1 w=0.42 l=0.15 mult=1
+ sa=0.265 sb=0.265 sd=0.28 topography=normal area=0.063 perim=1.14
MI25 net97 SET_B VGND VNB nfet_01v8 m=1 w=0.42 l=0.15 mult=1 sa=0.265
+ sb=0.265 sd=0.28 topography=normal area=0.063 perim=1.14
MI26 S0 clkneg net89 VNB nfet_01v8 m=1 w=0.42 l=0.15 mult=1 sa=0.265
+ sb=0.265 sd=0.28 topography=normal area=0.063 perim=1.14
MI27 net89 S1 net97 VNB nfet_01v8 m=1 w=0.42 l=0.15 mult=1 sa=0.265
+ sb=0.265 sd=0.28 topography=normal area=0.063 perim=1.14
MI647 S1 S0 VGND VNB nfet_01v8 m=1 w=0.54 l=0.15 mult=1 sa=0.265
+ sb=0.265 sd=0.28 topography=normal area=0.063 perim=1.14
MI655 M0 clkpos net80 VNB nfet_01v8 m=1 w=0.36 l=0.15 mult=1 sa=0.265
+ sb=0.265 sd=0.28 topography=normal area=0.063 perim=1.14
MI657 net112 SET_B VGND VNB nfet_01v8 m=1 w=0.42 l=0.15 mult=1
+ sa=0.265 sb=0.265 sd=0.28 topography=normal area=0.063 perim=1.14
MI652 net141 S0 VGND VNB nfet_01v8 m=1 w=0.42 l=0.15 mult=1 sa=0.265
+ sb=0.265 sd=0.28 topography=normal area=0.063 perim=1.14
MI653 Q net141 VGND VNB nfet_01v8 m=1 w=0.65 l=0.15 mult=1 sa=0.265
+ sb=0.265 sd=0.28 topography=normal area=0.063 perim=1.14
MI49 Q_N S0 VGND VNB nfet_01v8 m=1 w=0.65 l=0.15 mult=1 sa=0.265
+ sb=0.265 sd=0.28 topography=normal area=0.063 perim=1.14
MI40 db D VPWR VPB pfet_01v8_hvt m=1 w=0.84 l=0.15 mult=1 sa=0.265
+ sb=0.265 sd=0.28 topography=normal area=0.063 perim=1.14
MI38 S0 clkneg net192 VPB pfet_01v8_hvt m=1 w=0.42 l=0.15 mult=1
+ sa=0.265 sb=0.265 sd=0.28 topography=normal area=0.063 perim=1.14
MI37 net192 M0 VPWR VPB pfet_01v8_hvt m=1 w=0.42 l=0.15 mult=1
+ sa=0.265 sb=0.265 sd=0.28 topography=normal area=0.063 perim=1.14
MI43 db clkpos M0 VPB pfet_01v8_hvt m=1 w=0.42 l=0.15 mult=1 sa=0.265
+ sb=0.265 sd=0.28 topography=normal area=0.063 perim=1.14
MI45 clkneg CLK VPWR VPB pfet_01v8_hvt m=1 w=0.64 l=0.15 mult=1
+ sa=0.265 sb=0.265 sd=0.28 topography=normal area=0.063 perim=1.14
MI47 clkpos clkneg VPWR VPB pfet_01v8_hvt m=1 w=0.64 l=0.15 mult=1
+ sa=0.265 sb=0.265 sd=0.28 topography=normal area=0.063 perim=1.14
MI659 M1 SET_B VPWR VPB pfet_01v8_hvt m=1 w=0.42 l=0.15 mult=1
+ sa=0.265 sb=0.265 sd=0.28 topography=normal area=0.063 perim=1.14
MI662 net169 M1 VPWR VPB pfet_01v8_hvt m=1 w=0.42 l=0.15 mult=1
+ sa=0.265 sb=0.265 sd=0.28 topography=normal area=0.063 perim=1.14
MI664 M0 clkneg net169 VPB pfet_01v8_hvt m=1 w=0.42 l=0.15 mult=1
+ sa=0.265 sb=0.265 sd=0.28 topography=normal area=0.063 perim=1.14
MI6 net156 S1 VPWR VPB pfet_01v8_hvt m=1 w=0.42 l=0.15 mult=1 sa=0.265
+ sb=0.265 sd=0.28 topography=normal area=0.063 perim=1.14
MI5 S0 clkpos net156 VPB pfet_01v8_hvt m=1 w=0.42 l=0.15 mult=1
+ sa=0.265 sb=0.265 sd=0.28 topography=normal area=0.063 perim=1.14
MI24 S0 SET_B VPWR VPB pfet_01v8_hvt m=1 w=0.42 l=0.15 mult=1 sa=0.265
+ sb=0.265 sd=0.28 topography=normal area=0.063 perim=1.14
MI648 S1 S0 VPWR VPB pfet_01v8_hvt m=1 w=0.84 l=0.15 mult=1 sa=0.265
+ sb=0.265 sd=0.28 topography=normal area=0.063 perim=1.14
MI658 M1 M0 VPWR VPB pfet_01v8_hvt m=1 w=0.42 l=0.15 mult=1 sa=0.265
+ sb=0.265 sd=0.28 topography=normal area=0.063 perim=1.14
MI663 net141 S0 VPWR VPB pfet_01v8_hvt m=1 w=0.64 l=0.15 mult=1
+ sa=0.265 sb=0.265 sd=0.28 topography=normal area=0.063 perim=1.14
MI660 Q net141 VPWR VPB pfet_01v8_hvt m=1 w=1.0 l=0.15 mult=1 sa=0.265
+ sb=0.265 sd=0.28 topography=normal area=0.063 perim=1.14
MI50 Q_N S0 VPWR VPB pfet_01v8_hvt m=1 w=1.0 l=0.15 mult=1 sa=0.265
+ sb=0.265 sd=0.28 topography=normal area=0.063 perim=1.14
.ENDS

.SUBCKT sky130_fd_sc_hd__dfsbp_2 CLK D SET_B VGND VNB VPB VPWR Q Q_N
MI36 net128 M0 VGND VNB nfet_01v8 m=1 w=0.42 l=0.15 mult=1 sa=0.265
+ sb=0.265 sd=0.28 topography=normal area=0.063 perim=1.14
MI42 db clkneg M0 VNB nfet_01v8 m=1 w=0.36 l=0.15 mult=1 sa=0.265
+ sb=0.265 sd=0.28 topography=normal area=0.063 perim=1.14
MI44 clkneg CLK VGND VNB nfet_01v8 m=1 w=0.42 l=0.15 mult=1 sa=0.265
+ sb=0.265 sd=0.28 topography=normal area=0.063 perim=1.14
MI39 db D VGND VNB nfet_01v8 m=1 w=0.64 l=0.15 mult=1 sa=0.265
+ sb=0.265 sd=0.28 topography=normal area=0.063 perim=1.14
MI656 M1 M0 net111 VNB nfet_01v8 m=1 w=0.42 l=0.15 mult=1 sa=0.265
+ sb=0.265 sd=0.28 topography=normal area=0.063 perim=1.14
MI654 net79 M1 VGND VNB nfet_01v8 m=1 w=0.42 l=0.15 mult=1 sa=0.265
+ sb=0.265 sd=0.28 topography=normal area=0.063 perim=1.14
MI34 S0 clkpos net128 VNB nfet_01v8 m=1 w=0.42 l=0.15 mult=1 sa=0.265
+ sb=0.265 sd=0.28 topography=normal area=0.063 perim=1.14
MI46 clkpos clkneg VGND VNB nfet_01v8 m=1 w=0.42 l=0.15 mult=1
+ sa=0.265 sb=0.265 sd=0.28 topography=normal area=0.063 perim=1.14
MI25 net96 SET_B VGND VNB nfet_01v8 m=1 w=0.42 l=0.15 mult=1 sa=0.265
+ sb=0.265 sd=0.28 topography=normal area=0.063 perim=1.14
MI26 S0 clkneg net88 VNB nfet_01v8 m=1 w=0.42 l=0.15 mult=1 sa=0.265
+ sb=0.265 sd=0.28 topography=normal area=0.063 perim=1.14
MI27 net88 S1 net96 VNB nfet_01v8 m=1 w=0.42 l=0.15 mult=1 sa=0.265
+ sb=0.265 sd=0.28 topography=normal area=0.063 perim=1.14
MI647 S1 S0 VGND VNB nfet_01v8 m=1 w=0.54 l=0.15 mult=1 sa=0.265
+ sb=0.265 sd=0.28 topography=normal area=0.063 perim=1.14
MI655 M0 clkpos net79 VNB nfet_01v8 m=1 w=0.36 l=0.15 mult=1 sa=0.265
+ sb=0.265 sd=0.28 topography=normal area=0.063 perim=1.14
MI657 net111 SET_B VGND VNB nfet_01v8 m=1 w=0.42 l=0.15 mult=1
+ sa=0.265 sb=0.265 sd=0.28 topography=normal area=0.063 perim=1.14
MI652 net140 S0 VGND VNB nfet_01v8 m=1 w=0.65 l=0.15 mult=1 sa=0.265
+ sb=0.265 sd=0.28 topography=normal area=0.063 perim=1.14
MI653 Q net140 VGND VNB nfet_01v8 m=2 w=0.65 l=0.15 mult=1 sa=0.265
+ sb=0.265 sd=0.28 topography=normal area=0.063 perim=1.14
MI49 Q_N S0 VGND VNB nfet_01v8 m=2 w=0.65 l=0.15 mult=1 sa=0.265
+ sb=0.265 sd=0.28 topography=normal area=0.063 perim=1.14
MI40 db D VPWR VPB pfet_01v8_hvt m=1 w=0.84 l=0.15 mult=1 sa=0.265
+ sb=0.265 sd=0.28 topography=normal area=0.063 perim=1.14
MI38 S0 clkneg net191 VPB pfet_01v8_hvt m=1 w=0.42 l=0.15 mult=1
+ sa=0.265 sb=0.265 sd=0.28 topography=normal area=0.063 perim=1.14
MI37 net191 M0 VPWR VPB pfet_01v8_hvt m=1 w=0.42 l=0.15 mult=1
+ sa=0.265 sb=0.265 sd=0.28 topography=normal area=0.063 perim=1.14
MI43 db clkpos M0 VPB pfet_01v8_hvt m=1 w=0.42 l=0.15 mult=1 sa=0.265
+ sb=0.265 sd=0.28 topography=normal area=0.063 perim=1.14
MI45 clkneg CLK VPWR VPB pfet_01v8_hvt m=1 w=0.64 l=0.15 mult=1
+ sa=0.265 sb=0.265 sd=0.28 topography=normal area=0.063 perim=1.14
MI47 clkpos clkneg VPWR VPB pfet_01v8_hvt m=1 w=0.64 l=0.15 mult=1
+ sa=0.265 sb=0.265 sd=0.28 topography=normal area=0.063 perim=1.14
MI659 M1 SET_B VPWR VPB pfet_01v8_hvt m=1 w=0.42 l=0.15 mult=1
+ sa=0.265 sb=0.265 sd=0.28 topography=normal area=0.063 perim=1.14
MI662 net168 M1 VPWR VPB pfet_01v8_hvt m=1 w=0.42 l=0.15 mult=1
+ sa=0.265 sb=0.265 sd=0.28 topography=normal area=0.063 perim=1.14
MI664 M0 clkneg net168 VPB pfet_01v8_hvt m=1 w=0.42 l=0.15 mult=1
+ sa=0.265 sb=0.265 sd=0.28 topography=normal area=0.063 perim=1.14
MI6 net155 S1 VPWR VPB pfet_01v8_hvt m=1 w=0.42 l=0.15 mult=1 sa=0.265
+ sb=0.265 sd=0.28 topography=normal area=0.063 perim=1.14
MI5 S0 clkpos net155 VPB pfet_01v8_hvt m=1 w=0.42 l=0.15 mult=1
+ sa=0.265 sb=0.265 sd=0.28 topography=normal area=0.063 perim=1.14
MI24 S0 SET_B VPWR VPB pfet_01v8_hvt m=1 w=0.42 l=0.15 mult=1 sa=0.265
+ sb=0.265 sd=0.28 topography=normal area=0.063 perim=1.14
MI648 S1 S0 VPWR VPB pfet_01v8_hvt m=1 w=0.84 l=0.15 mult=1 sa=0.265
+ sb=0.265 sd=0.28 topography=normal area=0.063 perim=1.14
MI658 M1 M0 VPWR VPB pfet_01v8_hvt m=1 w=0.42 l=0.15 mult=1 sa=0.265
+ sb=0.265 sd=0.28 topography=normal area=0.063 perim=1.14
MI663 net140 S0 VPWR VPB pfet_01v8_hvt m=1 w=1.0 l=0.15 mult=1
+ sa=0.265 sb=0.265 sd=0.28 topography=normal area=0.063 perim=1.14
MI660 Q net140 VPWR VPB pfet_01v8_hvt m=2 w=1.0 l=0.15 mult=1 sa=0.265
+ sb=0.265 sd=0.28 topography=normal area=0.063 perim=1.14
MI50 Q_N S0 VPWR VPB pfet_01v8_hvt m=2 w=1.0 l=0.15 mult=1 sa=0.265
+ sb=0.265 sd=0.28 topography=normal area=0.063 perim=1.14
.ENDS

.SUBCKT sky130_fd_sc_hd__dfstp_1 CLK D SET_B VGND VNB VPB VPWR Q
MI36 net120 M0 VGND VNB nfet_01v8 m=1 w=0.42 l=0.15 mult=1 sa=0.265
+ sb=0.265 sd=0.28 topography=normal area=0.063 perim=1.14
MI42 db clkneg M0 VNB nfet_01v8 m=1 w=0.36 l=0.15 mult=1 sa=0.265
+ sb=0.265 sd=0.28 topography=normal area=0.063 perim=1.14
MI44 clkneg CLK VGND VNB nfet_01v8 m=1 w=0.42 l=0.15 mult=1 sa=0.265
+ sb=0.265 sd=0.28 topography=normal area=0.063 perim=1.14
MI39 db D VGND VNB nfet_01v8 m=1 w=0.64 l=0.15 mult=1 sa=0.265
+ sb=0.265 sd=0.28 topography=normal area=0.063 perim=1.14
MI656 M1 M0 net103 VNB nfet_01v8 m=1 w=0.42 l=0.15 mult=1 sa=0.265
+ sb=0.265 sd=0.28 topography=normal area=0.063 perim=1.14
MI654 net71 M1 VGND VNB nfet_01v8 m=1 w=0.42 l=0.15 mult=1 sa=0.265
+ sb=0.265 sd=0.28 topography=normal area=0.063 perim=1.14
MI34 S0 clkpos net120 VNB nfet_01v8 m=1 w=0.42 l=0.15 mult=1 sa=0.265
+ sb=0.265 sd=0.28 topography=normal area=0.063 perim=1.14
MI46 clkpos clkneg VGND VNB nfet_01v8 m=1 w=0.42 l=0.15 mult=1
+ sa=0.265 sb=0.265 sd=0.28 topography=normal area=0.063 perim=1.14
MI25 net88 SET_B VGND VNB nfet_01v8 m=1 w=0.42 l=0.15 mult=1 sa=0.265
+ sb=0.265 sd=0.28 topography=normal area=0.063 perim=1.14
MI26 S0 clkneg net80 VNB nfet_01v8 m=1 w=0.42 l=0.15 mult=1 sa=0.265
+ sb=0.265 sd=0.28 topography=normal area=0.063 perim=1.14
MI27 net80 S1 net88 VNB nfet_01v8 m=1 w=0.42 l=0.15 mult=1 sa=0.265
+ sb=0.265 sd=0.28 topography=normal area=0.063 perim=1.14
MI647 S1 S0 VGND VNB nfet_01v8 m=1 w=0.54 l=0.15 mult=1 sa=0.265
+ sb=0.265 sd=0.28 topography=normal area=0.063 perim=1.14
MI655 M0 clkpos net71 VNB nfet_01v8 m=1 w=0.36 l=0.15 mult=1 sa=0.265
+ sb=0.265 sd=0.28 topography=normal area=0.063 perim=1.14
MI657 net103 SET_B VGND VNB nfet_01v8 m=1 w=0.42 l=0.15 mult=1
+ sa=0.265 sb=0.265 sd=0.28 topography=normal area=0.063 perim=1.14
MI652 net128 S0 VGND VNB nfet_01v8 m=1 w=0.42 l=0.15 mult=1 sa=0.265
+ sb=0.265 sd=0.28 topography=normal area=0.063 perim=1.14
MI653 Q net128 VGND VNB nfet_01v8 m=1 w=0.65 l=0.15 mult=1 sa=0.265
+ sb=0.265 sd=0.28 topography=normal area=0.063 perim=1.14
MI40 db D VPWR VPB pfet_01v8_hvt m=1 w=0.84 l=0.15 mult=1 sa=0.265
+ sb=0.265 sd=0.28 topography=normal area=0.063 perim=1.14
MI38 S0 clkneg net179 VPB pfet_01v8_hvt m=1 w=0.42 l=0.15 mult=1
+ sa=0.265 sb=0.265 sd=0.28 topography=normal area=0.063 perim=1.14
MI37 net179 M0 VPWR VPB pfet_01v8_hvt m=1 w=0.42 l=0.15 mult=1
+ sa=0.265 sb=0.265 sd=0.28 topography=normal area=0.063 perim=1.14
MI43 db clkpos M0 VPB pfet_01v8_hvt m=1 w=0.42 l=0.15 mult=1 sa=0.265
+ sb=0.265 sd=0.28 topography=normal area=0.063 perim=1.14
MI45 clkneg CLK VPWR VPB pfet_01v8_hvt m=1 w=0.64 l=0.15 mult=1
+ sa=0.265 sb=0.265 sd=0.28 topography=normal area=0.063 perim=1.14
MI47 clkpos clkneg VPWR VPB pfet_01v8_hvt m=1 w=0.64 l=0.15 mult=1
+ sa=0.265 sb=0.265 sd=0.28 topography=normal area=0.063 perim=1.14
MI659 M1 SET_B VPWR VPB pfet_01v8_hvt m=1 w=0.42 l=0.15 mult=1
+ sa=0.265 sb=0.265 sd=0.28 topography=normal area=0.063 perim=1.14
MI662 net156 M1 VPWR VPB pfet_01v8_hvt m=1 w=0.42 l=0.15 mult=1
+ sa=0.265 sb=0.265 sd=0.28 topography=normal area=0.063 perim=1.14
MI664 M0 clkneg net156 VPB pfet_01v8_hvt m=1 w=0.42 l=0.15 mult=1
+ sa=0.265 sb=0.265 sd=0.28 topography=normal area=0.063 perim=1.14
MI6 net143 S1 VPWR VPB pfet_01v8_hvt m=1 w=0.42 l=0.15 mult=1 sa=0.265
+ sb=0.265 sd=0.28 topography=normal area=0.063 perim=1.14
MI5 S0 clkpos net143 VPB pfet_01v8_hvt m=1 w=0.42 l=0.15 mult=1
+ sa=0.265 sb=0.265 sd=0.28 topography=normal area=0.063 perim=1.14
MI24 S0 SET_B VPWR VPB pfet_01v8_hvt m=1 w=0.42 l=0.15 mult=1 sa=0.265
+ sb=0.265 sd=0.28 topography=normal area=0.063 perim=1.14
MI648 S1 S0 VPWR VPB pfet_01v8_hvt m=1 w=0.84 l=0.15 mult=1 sa=0.265
+ sb=0.265 sd=0.28 topography=normal area=0.063 perim=1.14
MI658 M1 M0 VPWR VPB pfet_01v8_hvt m=1 w=0.42 l=0.15 mult=1 sa=0.265
+ sb=0.265 sd=0.28 topography=normal area=0.063 perim=1.14
MI663 net128 S0 VPWR VPB pfet_01v8_hvt m=1 w=0.64 l=0.15 mult=1
+ sa=0.265 sb=0.265 sd=0.28 topography=normal area=0.063 perim=1.14
MI660 Q net128 VPWR VPB pfet_01v8_hvt m=1 w=1.0 l=0.15 mult=1 sa=0.265
+ sb=0.265 sd=0.28 topography=normal area=0.063 perim=1.14
.ENDS

.SUBCKT sky130_fd_sc_hd__dfstp_2 CLK D SET_B VGND VNB VPB VPWR Q
MI36 net120 M0 VGND VNB nfet_01v8 m=1 w=0.42 l=0.15 mult=1 sa=0.265
+ sb=0.265 sd=0.28 topography=normal area=0.063 perim=1.14
MI42 db clkneg M0 VNB nfet_01v8 m=1 w=0.36 l=0.15 mult=1 sa=0.265
+ sb=0.265 sd=0.28 topography=normal area=0.063 perim=1.14
MI44 clkneg CLK VGND VNB nfet_01v8 m=1 w=0.42 l=0.15 mult=1 sa=0.265
+ sb=0.265 sd=0.28 topography=normal area=0.063 perim=1.14
MI39 db D VGND VNB nfet_01v8 m=1 w=0.64 l=0.15 mult=1 sa=0.265
+ sb=0.265 sd=0.28 topography=normal area=0.063 perim=1.14
MI656 M1 M0 net103 VNB nfet_01v8 m=1 w=0.42 l=0.15 mult=1 sa=0.265
+ sb=0.265 sd=0.28 topography=normal area=0.063 perim=1.14
MI654 net71 M1 VGND VNB nfet_01v8 m=1 w=0.42 l=0.15 mult=1 sa=0.265
+ sb=0.265 sd=0.28 topography=normal area=0.063 perim=1.14
MI34 S0 clkpos net120 VNB nfet_01v8 m=1 w=0.42 l=0.15 mult=1 sa=0.265
+ sb=0.265 sd=0.28 topography=normal area=0.063 perim=1.14
MI46 clkpos clkneg VGND VNB nfet_01v8 m=1 w=0.42 l=0.15 mult=1
+ sa=0.265 sb=0.265 sd=0.28 topography=normal area=0.063 perim=1.14
MI25 net88 SET_B VGND VNB nfet_01v8 m=1 w=0.42 l=0.15 mult=1 sa=0.265
+ sb=0.265 sd=0.28 topography=normal area=0.063 perim=1.14
MI26 S0 clkneg net80 VNB nfet_01v8 m=1 w=0.42 l=0.15 mult=1 sa=0.265
+ sb=0.265 sd=0.28 topography=normal area=0.063 perim=1.14
MI27 net80 S1 net88 VNB nfet_01v8 m=1 w=0.42 l=0.15 mult=1 sa=0.265
+ sb=0.265 sd=0.28 topography=normal area=0.063 perim=1.14
MI647 S1 S0 VGND VNB nfet_01v8 m=1 w=0.54 l=0.15 mult=1 sa=0.265
+ sb=0.265 sd=0.28 topography=normal area=0.063 perim=1.14
MI655 M0 clkpos net71 VNB nfet_01v8 m=1 w=0.36 l=0.15 mult=1 sa=0.265
+ sb=0.265 sd=0.28 topography=normal area=0.063 perim=1.14
MI657 net103 SET_B VGND VNB nfet_01v8 m=1 w=0.42 l=0.15 mult=1
+ sa=0.265 sb=0.265 sd=0.28 topography=normal area=0.063 perim=1.14
MI652 net128 S0 VGND VNB nfet_01v8 m=1 w=0.65 l=0.15 mult=1 sa=0.265
+ sb=0.265 sd=0.28 topography=normal area=0.063 perim=1.14
MI653 Q net128 VGND VNB nfet_01v8 m=2 w=0.65 l=0.15 mult=1 sa=0.265
+ sb=0.265 sd=0.28 topography=normal area=0.063 perim=1.14
MI40 db D VPWR VPB pfet_01v8_hvt m=1 w=0.84 l=0.15 mult=1 sa=0.265
+ sb=0.265 sd=0.28 topography=normal area=0.063 perim=1.14
MI38 S0 clkneg net179 VPB pfet_01v8_hvt m=1 w=0.42 l=0.15 mult=1
+ sa=0.265 sb=0.265 sd=0.28 topography=normal area=0.063 perim=1.14
MI37 net179 M0 VPWR VPB pfet_01v8_hvt m=1 w=0.42 l=0.15 mult=1
+ sa=0.265 sb=0.265 sd=0.28 topography=normal area=0.063 perim=1.14
MI43 db clkpos M0 VPB pfet_01v8_hvt m=1 w=0.42 l=0.15 mult=1 sa=0.265
+ sb=0.265 sd=0.28 topography=normal area=0.063 perim=1.14
MI45 clkneg CLK VPWR VPB pfet_01v8_hvt m=1 w=0.64 l=0.15 mult=1
+ sa=0.265 sb=0.265 sd=0.28 topography=normal area=0.063 perim=1.14
MI47 clkpos clkneg VPWR VPB pfet_01v8_hvt m=1 w=0.64 l=0.15 mult=1
+ sa=0.265 sb=0.265 sd=0.28 topography=normal area=0.063 perim=1.14
MI659 M1 SET_B VPWR VPB pfet_01v8_hvt m=1 w=0.42 l=0.15 mult=1
+ sa=0.265 sb=0.265 sd=0.28 topography=normal area=0.063 perim=1.14
MI662 net156 M1 VPWR VPB pfet_01v8_hvt m=1 w=0.42 l=0.15 mult=1
+ sa=0.265 sb=0.265 sd=0.28 topography=normal area=0.063 perim=1.14
MI664 M0 clkneg net156 VPB pfet_01v8_hvt m=1 w=0.42 l=0.15 mult=1
+ sa=0.265 sb=0.265 sd=0.28 topography=normal area=0.063 perim=1.14
MI6 net143 S1 VPWR VPB pfet_01v8_hvt m=1 w=0.42 l=0.15 mult=1 sa=0.265
+ sb=0.265 sd=0.28 topography=normal area=0.063 perim=1.14
MI5 S0 clkpos net143 VPB pfet_01v8_hvt m=1 w=0.42 l=0.15 mult=1
+ sa=0.265 sb=0.265 sd=0.28 topography=normal area=0.063 perim=1.14
MI24 S0 SET_B VPWR VPB pfet_01v8_hvt m=1 w=0.42 l=0.15 mult=1 sa=0.265
+ sb=0.265 sd=0.28 topography=normal area=0.063 perim=1.14
MI648 S1 S0 VPWR VPB pfet_01v8_hvt m=1 w=0.84 l=0.15 mult=1 sa=0.265
+ sb=0.265 sd=0.28 topography=normal area=0.063 perim=1.14
MI658 M1 M0 VPWR VPB pfet_01v8_hvt m=1 w=0.42 l=0.15 mult=1 sa=0.265
+ sb=0.265 sd=0.28 topography=normal area=0.063 perim=1.14
MI663 net128 S0 VPWR VPB pfet_01v8_hvt m=1 w=1 l=0.15 mult=1 sa=0.265
+ sb=0.265 sd=0.28 topography=normal area=0.063 perim=1.14
MI660 Q net128 VPWR VPB pfet_01v8_hvt m=2 w=1.0 l=0.15 mult=1 sa=0.265
+ sb=0.265 sd=0.28 topography=normal area=0.063 perim=1.14
.ENDS

.SUBCKT sky130_fd_sc_hd__dfstp_4 CLK D SET_B VGND VNB VPB VPWR Q
MI36 net120 M0 VGND VNB nfet_01v8 m=1 w=0.42 l=0.15 mult=1 sa=0.265
+ sb=0.265 sd=0.28 topography=normal area=0.063 perim=1.14
MI42 db clkneg M0 VNB nfet_01v8 m=1 w=0.36 l=0.15 mult=1 sa=0.265
+ sb=0.265 sd=0.28 topography=normal area=0.063 perim=1.14
MI44 clkneg CLK VGND VNB nfet_01v8 m=1 w=0.42 l=0.15 mult=1 sa=0.265
+ sb=0.265 sd=0.28 topography=normal area=0.063 perim=1.14
MI39 db D VGND VNB nfet_01v8 m=1 w=0.64 l=0.15 mult=1 sa=0.265
+ sb=0.265 sd=0.28 topography=normal area=0.063 perim=1.14
MI656 M1 M0 net103 VNB nfet_01v8 m=1 w=0.42 l=0.15 mult=1 sa=0.265
+ sb=0.265 sd=0.28 topography=normal area=0.063 perim=1.14
MI654 net71 M1 VGND VNB nfet_01v8 m=1 w=0.42 l=0.15 mult=1 sa=0.265
+ sb=0.265 sd=0.28 topography=normal area=0.063 perim=1.14
MI34 S0 clkpos net120 VNB nfet_01v8 m=1 w=0.42 l=0.15 mult=1 sa=0.265
+ sb=0.265 sd=0.28 topography=normal area=0.063 perim=1.14
MI46 clkpos clkneg VGND VNB nfet_01v8 m=1 w=0.42 l=0.15 mult=1
+ sa=0.265 sb=0.265 sd=0.28 topography=normal area=0.063 perim=1.14
MI25 net88 SET_B VGND VNB nfet_01v8 m=1 w=0.42 l=0.15 mult=1 sa=0.265
+ sb=0.265 sd=0.28 topography=normal area=0.063 perim=1.14
MI26 S0 clkneg net80 VNB nfet_01v8 m=1 w=0.42 l=0.15 mult=1 sa=0.265
+ sb=0.265 sd=0.28 topography=normal area=0.063 perim=1.14
MI27 net80 S1 net88 VNB nfet_01v8 m=1 w=0.42 l=0.15 mult=1 sa=0.265
+ sb=0.265 sd=0.28 topography=normal area=0.063 perim=1.14
MI647 S1 S0 VGND VNB nfet_01v8 m=1 w=0.54 l=0.15 mult=1 sa=0.265
+ sb=0.265 sd=0.28 topography=normal area=0.063 perim=1.14
MI655 M0 clkpos net71 VNB nfet_01v8 m=1 w=0.36 l=0.15 mult=1 sa=0.265
+ sb=0.265 sd=0.28 topography=normal area=0.063 perim=1.14
MI657 net103 SET_B VGND VNB nfet_01v8 m=1 w=0.42 l=0.15 mult=1
+ sa=0.265 sb=0.265 sd=0.28 topography=normal area=0.063 perim=1.14
MI652 net128 S0 VGND VNB nfet_01v8 m=1 w=0.42 l=0.15 mult=1 sa=0.265
+ sb=0.265 sd=0.28 topography=normal area=0.063 perim=1.14
MI653 Q net128 VGND VNB nfet_01v8 m=5 w=0.65 l=0.15 mult=1 sa=0.265
+ sb=0.265 sd=0.28 topography=normal area=0.063 perim=1.14
MI40 db D VPWR VPB pfet_01v8_hvt m=1 w=0.84 l=0.15 mult=1 sa=0.265
+ sb=0.265 sd=0.28 topography=normal area=0.063 perim=1.14
MI38 S0 clkneg net179 VPB pfet_01v8_hvt m=1 w=0.42 l=0.15 mult=1
+ sa=0.265 sb=0.265 sd=0.28 topography=normal area=0.063 perim=1.14
MI37 net179 M0 VPWR VPB pfet_01v8_hvt m=1 w=0.42 l=0.15 mult=1
+ sa=0.265 sb=0.265 sd=0.28 topography=normal area=0.063 perim=1.14
MI43 db clkpos M0 VPB pfet_01v8_hvt m=1 w=0.42 l=0.15 mult=1 sa=0.265
+ sb=0.265 sd=0.28 topography=normal area=0.063 perim=1.14
MI45 clkneg CLK VPWR VPB pfet_01v8_hvt m=1 w=0.64 l=0.15 mult=1
+ sa=0.265 sb=0.265 sd=0.28 topography=normal area=0.063 perim=1.14
MI47 clkpos clkneg VPWR VPB pfet_01v8_hvt m=1 w=0.64 l=0.15 mult=1
+ sa=0.265 sb=0.265 sd=0.28 topography=normal area=0.063 perim=1.14
MI659 M1 SET_B VPWR VPB pfet_01v8_hvt m=1 w=0.42 l=0.15 mult=1
+ sa=0.265 sb=0.265 sd=0.28 topography=normal area=0.063 perim=1.14
MI662 net156 M1 VPWR VPB pfet_01v8_hvt m=1 w=0.42 l=0.15 mult=1
+ sa=0.265 sb=0.265 sd=0.28 topography=normal area=0.063 perim=1.14
MI664 M0 clkneg net156 VPB pfet_01v8_hvt m=1 w=0.42 l=0.15 mult=1
+ sa=0.265 sb=0.265 sd=0.28 topography=normal area=0.063 perim=1.14
MI6 net143 S1 VPWR VPB pfet_01v8_hvt m=1 w=0.42 l=0.15 mult=1 sa=0.265
+ sb=0.265 sd=0.28 topography=normal area=0.063 perim=1.14
MI5 S0 clkpos net143 VPB pfet_01v8_hvt m=1 w=0.42 l=0.15 mult=1
+ sa=0.265 sb=0.265 sd=0.28 topography=normal area=0.063 perim=1.14
MI24 S0 SET_B VPWR VPB pfet_01v8_hvt m=1 w=0.42 l=0.15 mult=1 sa=0.265
+ sb=0.265 sd=0.28 topography=normal area=0.063 perim=1.14
MI648 S1 S0 VPWR VPB pfet_01v8_hvt m=1 w=0.84 l=0.15 mult=1 sa=0.265
+ sb=0.265 sd=0.28 topography=normal area=0.063 perim=1.14
MI658 M1 M0 VPWR VPB pfet_01v8_hvt m=1 w=0.42 l=0.15 mult=1 sa=0.265
+ sb=0.265 sd=0.28 topography=normal area=0.063 perim=1.14
MI663 net128 S0 VPWR VPB pfet_01v8_hvt m=1 w=0.64 l=0.15 mult=1
+ sa=0.265 sb=0.265 sd=0.28 topography=normal area=0.063 perim=1.14
MI660 Q net128 VPWR VPB pfet_01v8_hvt m=5 w=1.0 l=0.15 mult=1 sa=0.265
+ sb=0.265 sd=0.28 topography=normal area=0.063 perim=1.14
.ENDS

.SUBCKT sky130_fd_sc_hd__dfxbp_1 CLK D VGND VNB VPB VPWR Q Q_N
MI657 M0 clkpos net96 VNB nfet_01v8 m=1 w=0.36 l=0.15 mult=1 sa=0.265
+ sb=0.265 sd=0.28 topography=normal area=0.063 perim=1.14
MI656 net96 M1 VGND VNB nfet_01v8 m=1 w=0.42 l=0.15 mult=1 sa=0.265
+ sb=0.265 sd=0.28 topography=normal area=0.063 perim=1.14
MI646 Q S1 VGND VNB nfet_01v8 m=1 w=0.65 l=0.15 mult=1 sa=0.265
+ sb=0.265 sd=0.28 topography=normal area=0.063 perim=1.14
MI669 net88 S1 VGND VNB nfet_01v8 m=1 w=0.42 l=0.15 mult=1 sa=0.265
+ sb=0.265 sd=0.28 topography=normal area=0.063 perim=1.14
MI648 db clkneg M0 VNB nfet_01v8 m=1 w=0.36 l=0.15 mult=1 sa=0.265
+ sb=0.265 sd=0.28 topography=normal area=0.063 perim=1.14
MI654 db D VGND VNB nfet_01v8 m=1 w=0.42 l=0.15 mult=1 sa=0.265
+ sb=0.265 sd=0.28 topography=normal area=0.063 perim=1.14
MI642 S0 clkneg net72 VNB nfet_01v8 m=1 w=0.36 l=0.15 mult=1 sa=0.265
+ sb=0.265 sd=0.28 topography=normal area=0.063 perim=1.14
MI641 net72 S1 VGND VNB nfet_01v8 m=1 w=0.42 l=0.15 mult=1 sa=0.265
+ sb=0.265 sd=0.28 topography=normal area=0.063 perim=1.14
MI652 M1 clkpos S0 VNB nfet_01v8 m=1 w=0.36 l=0.15 mult=1 sa=0.265
+ sb=0.265 sd=0.28 topography=normal area=0.063 perim=1.14
MI649 S1 S0 VGND VNB nfet_01v8 m=1 w=0.65 l=0.15 mult=1 sa=0.265
+ sb=0.265 sd=0.28 topography=normal area=0.063 perim=1.14
MI635 clkneg CLK VGND VNB nfet_01v8 m=1 w=0.42 l=0.15 mult=1 sa=0.265
+ sb=0.265 sd=0.28 topography=normal area=0.063 perim=1.14
MI636 clkpos clkneg VGND VNB nfet_01v8 m=1 w=0.42 l=0.15 mult=1
+ sa=0.265 sb=0.265 sd=0.28 topography=normal area=0.063 perim=1.14
MI634 M1 M0 VGND VNB nfet_01v8 m=1 w=0.64 l=0.15 mult=1 sa=0.265
+ sb=0.265 sd=0.28 topography=normal area=0.063 perim=1.14
MI665 Q_N net88 VGND VNB nfet_01v8 m=1 w=0.65 l=0.15 mult=1 sa=0.265
+ sb=0.265 sd=0.28 topography=normal area=0.063 perim=1.14
MI659 M0 clkneg net128 VPB pfet_01v8_hvt m=1 w=0.42 l=0.15 mult=1
+ sa=0.265 sb=0.265 sd=0.28 topography=normal area=0.063 perim=1.14
MI650 S1 S0 VPWR VPB pfet_01v8_hvt m=1 w=1.0 l=0.15 mult=1 sa=0.265
+ sb=0.265 sd=0.28 topography=normal area=0.063 perim=1.14
MI644 S0 clkpos net147 VPB pfet_01v8_hvt m=1 w=0.42 l=0.15 mult=1
+ sa=0.265 sb=0.265 sd=0.28 topography=normal area=0.063 perim=1.14
MI639 M1 M0 VPWR VPB pfet_01v8_hvt m=1 w=0.75 l=0.15 mult=1 sa=0.265
+ sb=0.265 sd=0.28 topography=normal area=0.063 perim=1.14
MI670 net88 S1 VPWR VPB pfet_01v8_hvt m=1 w=0.64 l=0.15 mult=1
+ sa=0.265 sb=0.265 sd=0.28 topography=normal area=0.063 perim=1.14
MI643 net147 S1 VPWR VPB pfet_01v8_hvt m=1 w=0.42 l=0.15 mult=1
+ sa=0.265 sb=0.265 sd=0.28 topography=normal area=0.063 perim=1.14
MI638 clkneg CLK VPWR VPB pfet_01v8_hvt m=1 w=0.64 l=0.15 mult=1
+ sa=0.265 sb=0.265 sd=0.28 topography=normal area=0.063 perim=1.14
MI658 net128 M1 VPWR VPB pfet_01v8_hvt m=1 w=0.42 l=0.15 mult=1
+ sa=0.265 sb=0.265 sd=0.28 topography=normal area=0.063 perim=1.14
MI645 Q S1 VPWR VPB pfet_01v8_hvt m=1 w=1.0 l=0.15 mult=1 sa=0.265
+ sb=0.265 sd=0.28 topography=normal area=0.063 perim=1.14
MI651 db clkpos M0 VPB pfet_01v8_hvt m=1 w=0.42 l=0.15 mult=1 sa=0.265
+ sb=0.265 sd=0.28 topography=normal area=0.063 perim=1.14
MI655 db D VPWR VPB pfet_01v8_hvt m=1 w=0.42 l=0.15 mult=1 sa=0.265
+ sb=0.265 sd=0.28 topography=normal area=0.063 perim=1.14
MI653 M1 clkneg S0 VPB pfet_01v8_hvt m=1 w=0.42 l=0.15 mult=1 sa=0.265
+ sb=0.265 sd=0.28 topography=normal area=0.063 perim=1.14
MI637 clkpos clkneg VPWR VPB pfet_01v8_hvt m=1 w=0.64 l=0.15 mult=1
+ sa=0.265 sb=0.265 sd=0.28 topography=normal area=0.063 perim=1.14
MI666 Q_N net88 VPWR VPB pfet_01v8_hvt m=1 w=1.0 l=0.15 mult=1
+ sa=0.265 sb=0.265 sd=0.28 topography=normal area=0.063 perim=1.14
.ENDS

.SUBCKT sky130_fd_sc_hd__dfxbp_2 CLK D VGND VNB VPB VPWR Q Q_N
MI657 M0 clkpos net96 VNB nfet_01v8 m=1 w=0.36 l=0.15 mult=1 sa=0.265
+ sb=0.265 sd=0.28 topography=normal area=0.063 perim=1.14
MI656 net96 M1 VGND VNB nfet_01v8 m=1 w=0.42 l=0.15 mult=1 sa=0.265
+ sb=0.265 sd=0.28 topography=normal area=0.063 perim=1.14
MI646 Q S1 VGND VNB nfet_01v8 m=2 w=0.65 l=0.15 mult=1 sa=0.265
+ sb=0.265 sd=0.28 topography=normal area=0.063 perim=1.14
MI669 net88 S1 VGND VNB nfet_01v8 m=1 w=0.42 l=0.15 mult=1 sa=0.265
+ sb=0.265 sd=0.28 topography=normal area=0.063 perim=1.14
MI648 db clkneg M0 VNB nfet_01v8 m=1 w=0.36 l=0.15 mult=1 sa=0.265
+ sb=0.265 sd=0.28 topography=normal area=0.063 perim=1.14
MI654 db D VGND VNB nfet_01v8 m=1 w=0.42 l=0.15 mult=1 sa=0.265
+ sb=0.265 sd=0.28 topography=normal area=0.063 perim=1.14
MI642 S0 clkneg net72 VNB nfet_01v8 m=1 w=0.36 l=0.15 mult=1 sa=0.265
+ sb=0.265 sd=0.28 topography=normal area=0.063 perim=1.14
MI641 net72 S1 VGND VNB nfet_01v8 m=1 w=0.42 l=0.15 mult=1 sa=0.265
+ sb=0.265 sd=0.28 topography=normal area=0.063 perim=1.14
MI652 M1 clkpos S0 VNB nfet_01v8 m=1 w=0.36 l=0.15 mult=1 sa=0.265
+ sb=0.265 sd=0.28 topography=normal area=0.063 perim=1.14
MI649 S1 S0 VGND VNB nfet_01v8 m=1 w=0.65 l=0.15 mult=1 sa=0.265
+ sb=0.265 sd=0.28 topography=normal area=0.063 perim=1.14
MI635 clkneg CLK VGND VNB nfet_01v8 m=1 w=0.42 l=0.15 mult=1 sa=0.265
+ sb=0.265 sd=0.28 topography=normal area=0.063 perim=1.14
MI636 clkpos clkneg VGND VNB nfet_01v8 m=1 w=0.42 l=0.15 mult=1
+ sa=0.265 sb=0.265 sd=0.28 topography=normal area=0.063 perim=1.14
MI634 M1 M0 VGND VNB nfet_01v8 m=1 w=0.64 l=0.15 mult=1 sa=0.265
+ sb=0.265 sd=0.28 topography=normal area=0.063 perim=1.14
MI665 Q_N net88 VGND VNB nfet_01v8 m=2 w=0.65 l=0.15 mult=1 sa=0.265
+ sb=0.265 sd=0.28 topography=normal area=0.063 perim=1.14
MI659 M0 clkneg net128 VPB pfet_01v8_hvt m=1 w=0.42 l=0.15 mult=1
+ sa=0.265 sb=0.265 sd=0.28 topography=normal area=0.063 perim=1.14
MI650 S1 S0 VPWR VPB pfet_01v8_hvt m=1 w=1.0 l=0.15 mult=1 sa=0.265
+ sb=0.265 sd=0.28 topography=normal area=0.063 perim=1.14
MI644 S0 clkpos net147 VPB pfet_01v8_hvt m=1 w=0.42 l=0.15 mult=1
+ sa=0.265 sb=0.265 sd=0.28 topography=normal area=0.063 perim=1.14
MI639 M1 M0 VPWR VPB pfet_01v8_hvt m=1 w=0.75 l=0.15 mult=1 sa=0.265
+ sb=0.265 sd=0.28 topography=normal area=0.063 perim=1.14
MI670 net88 S1 VPWR VPB pfet_01v8_hvt m=1 w=0.64 l=0.15 mult=1
+ sa=0.265 sb=0.265 sd=0.28 topography=normal area=0.063 perim=1.14
MI643 net147 S1 VPWR VPB pfet_01v8_hvt m=1 w=0.42 l=0.15 mult=1
+ sa=0.265 sb=0.265 sd=0.28 topography=normal area=0.063 perim=1.14
MI638 clkneg CLK VPWR VPB pfet_01v8_hvt m=1 w=0.64 l=0.15 mult=1
+ sa=0.265 sb=0.265 sd=0.28 topography=normal area=0.063 perim=1.14
MI658 net128 M1 VPWR VPB pfet_01v8_hvt m=1 w=0.42 l=0.15 mult=1
+ sa=0.265 sb=0.265 sd=0.28 topography=normal area=0.063 perim=1.14
MI645 Q S1 VPWR VPB pfet_01v8_hvt m=2 w=1.0 l=0.15 mult=1 sa=0.265
+ sb=0.265 sd=0.28 topography=normal area=0.063 perim=1.14
MI651 db clkpos M0 VPB pfet_01v8_hvt m=1 w=0.42 l=0.15 mult=1 sa=0.265
+ sb=0.265 sd=0.28 topography=normal area=0.063 perim=1.14
MI655 db D VPWR VPB pfet_01v8_hvt m=1 w=0.42 l=0.15 mult=1 sa=0.265
+ sb=0.265 sd=0.28 topography=normal area=0.063 perim=1.14
MI653 M1 clkneg S0 VPB pfet_01v8_hvt m=1 w=0.42 l=0.15 mult=1 sa=0.265
+ sb=0.265 sd=0.28 topography=normal area=0.063 perim=1.14
MI637 clkpos clkneg VPWR VPB pfet_01v8_hvt m=1 w=0.64 l=0.15 mult=1
+ sa=0.265 sb=0.265 sd=0.28 topography=normal area=0.063 perim=1.14
MI666 Q_N net88 VPWR VPB pfet_01v8_hvt m=2 w=1.0 l=0.15 mult=1
+ sa=0.265 sb=0.265 sd=0.28 topography=normal area=0.063 perim=1.14
.ENDS

.SUBCKT sky130_fd_sc_hd__dfxtp_1 CLK D VGND VNB VPB VPWR Q
MI657 M0 clkpos net79 VNB nfet_01v8 m=1 w=0.36 l=0.15 mult=1 sa=0.265
+ sb=0.265 sd=0.28 topography=normal area=0.063 perim=1.14
MI656 net79 M1 VGND VNB nfet_01v8 m=1 w=0.42 l=0.15 mult=1 sa=0.265
+ sb=0.265 sd=0.28 topography=normal area=0.063 perim=1.14
MI646 Q S1 VGND VNB nfet_01v8 m=1 w=0.65 l=0.15 mult=1 sa=0.265
+ sb=0.265 sd=0.28 topography=normal area=0.063 perim=1.14
MI648 db clkneg M0 VNB nfet_01v8 m=1 w=0.36 l=0.15 mult=1 sa=0.265
+ sb=0.265 sd=0.28 topography=normal area=0.063 perim=1.14
MI654 db D VGND VNB nfet_01v8 m=1 w=0.42 l=0.15 mult=1 sa=0.265
+ sb=0.265 sd=0.28 topography=normal area=0.063 perim=1.14
MI642 S0 clkneg net59 VNB nfet_01v8 m=1 w=0.36 l=0.15 mult=1 sa=0.265
+ sb=0.265 sd=0.28 topography=normal area=0.063 perim=1.14
MI641 net59 S1 VGND VNB nfet_01v8 m=1 w=0.42 l=0.15 mult=1 sa=0.265
+ sb=0.265 sd=0.28 topography=normal area=0.063 perim=1.14
MI652 M1 clkpos S0 VNB nfet_01v8 m=1 w=0.36 l=0.15 mult=1 sa=0.265
+ sb=0.265 sd=0.28 topography=normal area=0.063 perim=1.14
MI649 S1 S0 VGND VNB nfet_01v8 m=1 w=0.65 l=0.15 mult=1 sa=0.265
+ sb=0.265 sd=0.28 topography=normal area=0.063 perim=1.14
MI635 clkneg CLK VGND VNB nfet_01v8 m=1 w=0.42 l=0.15 mult=1 sa=0.265
+ sb=0.265 sd=0.28 topography=normal area=0.063 perim=1.14
MI636 clkpos clkneg VGND VNB nfet_01v8 m=1 w=0.42 l=0.15 mult=1
+ sa=0.265 sb=0.265 sd=0.28 topography=normal area=0.063 perim=1.14
MI634 M1 M0 VGND VNB nfet_01v8 m=1 w=0.64 l=0.15 mult=1 sa=0.265
+ sb=0.265 sd=0.28 topography=normal area=0.063 perim=1.14
MI659 M0 clkneg net107 VPB pfet_01v8_hvt m=1 w=0.42 l=0.15 mult=1
+ sa=0.265 sb=0.265 sd=0.28 topography=normal area=0.063 perim=1.14
MI650 S1 S0 VPWR VPB pfet_01v8_hvt m=1 w=1.0 l=0.15 mult=1 sa=0.265
+ sb=0.265 sd=0.28 topography=normal area=0.063 perim=1.14
MI644 S0 clkpos net122 VPB pfet_01v8_hvt m=1 w=0.42 l=0.15 mult=1
+ sa=0.265 sb=0.265 sd=0.28 topography=normal area=0.063 perim=1.14
MI639 M1 M0 VPWR VPB pfet_01v8_hvt m=1 w=0.75 l=0.15 mult=1 sa=0.265
+ sb=0.265 sd=0.28 topography=normal area=0.063 perim=1.14
MI643 net122 S1 VPWR VPB pfet_01v8_hvt m=1 w=0.42 l=0.15 mult=1
+ sa=0.265 sb=0.265 sd=0.28 topography=normal area=0.063 perim=1.14
MI638 clkneg CLK VPWR VPB pfet_01v8_hvt m=1 w=0.64 l=0.15 mult=1
+ sa=0.265 sb=0.265 sd=0.28 topography=normal area=0.063 perim=1.14
MI658 net107 M1 VPWR VPB pfet_01v8_hvt m=1 w=0.42 l=0.15 mult=1
+ sa=0.265 sb=0.265 sd=0.28 topography=normal area=0.063 perim=1.14
MI645 Q S1 VPWR VPB pfet_01v8_hvt m=1 w=1.0 l=0.15 mult=1 sa=0.265
+ sb=0.265 sd=0.28 topography=normal area=0.063 perim=1.14
MI651 db clkpos M0 VPB pfet_01v8_hvt m=1 w=0.42 l=0.15 mult=1 sa=0.265
+ sb=0.265 sd=0.28 topography=normal area=0.063 perim=1.14
MI655 db D VPWR VPB pfet_01v8_hvt m=1 w=0.42 l=0.15 mult=1 sa=0.265
+ sb=0.265 sd=0.28 topography=normal area=0.063 perim=1.14
MI653 M1 clkneg S0 VPB pfet_01v8_hvt m=1 w=0.42 l=0.15 mult=1 sa=0.265
+ sb=0.265 sd=0.28 topography=normal area=0.063 perim=1.14
MI637 clkpos clkneg VPWR VPB pfet_01v8_hvt m=1 w=0.64 l=0.15 mult=1
+ sa=0.265 sb=0.265 sd=0.28 topography=normal area=0.063 perim=1.14
.ENDS

.SUBCKT sky130_fd_sc_hd__dfxtp_2 CLK D VGND VNB VPB VPWR Q
MI657 M0 clkpos net79 VNB nfet_01v8 m=1 w=0.36 l=0.15 mult=1 sa=0.265
+ sb=0.265 sd=0.28 topography=normal area=0.063 perim=1.14
MI656 net79 M1 VGND VNB nfet_01v8 m=1 w=0.42 l=0.15 mult=1 sa=0.265
+ sb=0.265 sd=0.28 topography=normal area=0.063 perim=1.14
MI646 Q S1 VGND VNB nfet_01v8 m=2 w=0.65 l=0.15 mult=1 sa=0.265
+ sb=0.265 sd=0.28 topography=normal area=0.063 perim=1.14
MI648 db clkneg M0 VNB nfet_01v8 m=1 w=0.36 l=0.15 mult=1 sa=0.265
+ sb=0.265 sd=0.28 topography=normal area=0.063 perim=1.14
MI654 db D VGND VNB nfet_01v8 m=1 w=0.42 l=0.15 mult=1 sa=0.265
+ sb=0.265 sd=0.28 topography=normal area=0.063 perim=1.14
MI642 S0 clkneg net59 VNB nfet_01v8 m=1 w=0.36 l=0.15 mult=1 sa=0.265
+ sb=0.265 sd=0.28 topography=normal area=0.063 perim=1.14
MI641 net59 S1 VGND VNB nfet_01v8 m=1 w=0.42 l=0.15 mult=1 sa=0.265
+ sb=0.265 sd=0.28 topography=normal area=0.063 perim=1.14
MI652 M1 clkpos S0 VNB nfet_01v8 m=1 w=0.36 l=0.15 mult=1 sa=0.265
+ sb=0.265 sd=0.28 topography=normal area=0.063 perim=1.14
MI649 S1 S0 VGND VNB nfet_01v8 m=1 w=0.65 l=0.15 mult=1 sa=0.265
+ sb=0.265 sd=0.28 topography=normal area=0.063 perim=1.14
MI635 clkneg CLK VGND VNB nfet_01v8 m=1 w=0.42 l=0.15 mult=1 sa=0.265
+ sb=0.265 sd=0.28 topography=normal area=0.063 perim=1.14
MI636 clkpos clkneg VGND VNB nfet_01v8 m=1 w=0.42 l=0.15 mult=1
+ sa=0.265 sb=0.265 sd=0.28 topography=normal area=0.063 perim=1.14
MI634 M1 M0 VGND VNB nfet_01v8 m=1 w=0.64 l=0.15 mult=1 sa=0.265
+ sb=0.265 sd=0.28 topography=normal area=0.063 perim=1.14
MI659 M0 clkneg net107 VPB pfet_01v8_hvt m=1 w=0.42 l=0.15 mult=1
+ sa=0.265 sb=0.265 sd=0.28 topography=normal area=0.063 perim=1.14
MI650 S1 S0 VPWR VPB pfet_01v8_hvt m=1 w=1.0 l=0.15 mult=1 sa=0.265
+ sb=0.265 sd=0.28 topography=normal area=0.063 perim=1.14
MI644 S0 clkpos net122 VPB pfet_01v8_hvt m=1 w=0.42 l=0.15 mult=1
+ sa=0.265 sb=0.265 sd=0.28 topography=normal area=0.063 perim=1.14
MI639 M1 M0 VPWR VPB pfet_01v8_hvt m=1 w=0.75 l=0.15 mult=1 sa=0.265
+ sb=0.265 sd=0.28 topography=normal area=0.063 perim=1.14
MI643 net122 S1 VPWR VPB pfet_01v8_hvt m=1 w=0.42 l=0.15 mult=1
+ sa=0.265 sb=0.265 sd=0.28 topography=normal area=0.063 perim=1.14
MI638 clkneg CLK VPWR VPB pfet_01v8_hvt m=1 w=0.64 l=0.15 mult=1
+ sa=0.265 sb=0.265 sd=0.28 topography=normal area=0.063 perim=1.14
MI658 net107 M1 VPWR VPB pfet_01v8_hvt m=1 w=0.42 l=0.15 mult=1
+ sa=0.265 sb=0.265 sd=0.28 topography=normal area=0.063 perim=1.14
MI645 Q S1 VPWR VPB pfet_01v8_hvt m=2 w=1.0 l=0.15 mult=1 sa=0.265
+ sb=0.265 sd=0.28 topography=normal area=0.063 perim=1.14
MI651 db clkpos M0 VPB pfet_01v8_hvt m=1 w=0.42 l=0.15 mult=1 sa=0.265
+ sb=0.265 sd=0.28 topography=normal area=0.063 perim=1.14
MI655 db D VPWR VPB pfet_01v8_hvt m=1 w=0.42 l=0.15 mult=1 sa=0.265
+ sb=0.265 sd=0.28 topography=normal area=0.063 perim=1.14
MI653 M1 clkneg S0 VPB pfet_01v8_hvt m=1 w=0.42 l=0.15 mult=1 sa=0.265
+ sb=0.265 sd=0.28 topography=normal area=0.063 perim=1.14
MI637 clkpos clkneg VPWR VPB pfet_01v8_hvt m=1 w=0.64 l=0.15 mult=1
+ sa=0.265 sb=0.265 sd=0.28 topography=normal area=0.063 perim=1.14
.ENDS

.SUBCKT sky130_fd_sc_hd__dfxtp_4 CLK D VGND VNB VPB VPWR Q
MI657 M0 clkpos net79 VNB nfet_01v8 m=1 w=0.36 l=0.15 mult=1 sa=0.265
+ sb=0.265 sd=0.28 topography=normal area=0.063 perim=1.14
MI656 net79 M1 VGND VNB nfet_01v8 m=1 w=0.42 l=0.15 mult=1 sa=0.265
+ sb=0.265 sd=0.28 topography=normal area=0.063 perim=1.14
MI646 Q S1 VGND VNB nfet_01v8 m=4 w=0.65 l=0.15 mult=1 sa=0.265
+ sb=0.265 sd=0.28 topography=normal area=0.063 perim=1.14
MI648 db clkneg M0 VNB nfet_01v8 m=1 w=0.36 l=0.15 mult=1 sa=0.265
+ sb=0.265 sd=0.28 topography=normal area=0.063 perim=1.14
MI654 db D VGND VNB nfet_01v8 m=1 w=0.42 l=0.15 mult=1 sa=0.265
+ sb=0.265 sd=0.28 topography=normal area=0.063 perim=1.14
MI642 S0 clkneg net59 VNB nfet_01v8 m=1 w=0.36 l=0.15 mult=1 sa=0.265
+ sb=0.265 sd=0.28 topography=normal area=0.063 perim=1.14
MI641 net59 S1 VGND VNB nfet_01v8 m=1 w=0.42 l=0.15 mult=1 sa=0.265
+ sb=0.265 sd=0.28 topography=normal area=0.063 perim=1.14
MI652 M1 clkpos S0 VNB nfet_01v8 m=1 w=0.36 l=0.15 mult=1 sa=0.265
+ sb=0.265 sd=0.28 topography=normal area=0.063 perim=1.14
MI649 S1 S0 VGND VNB nfet_01v8 m=1 w=0.65 l=0.15 mult=1 sa=0.265
+ sb=0.265 sd=0.28 topography=normal area=0.063 perim=1.14
MI635 clkneg CLK VGND VNB nfet_01v8 m=1 w=0.42 l=0.15 mult=1 sa=0.265
+ sb=0.265 sd=0.28 topography=normal area=0.063 perim=1.14
MI636 clkpos clkneg VGND VNB nfet_01v8 m=1 w=0.42 l=0.15 mult=1
+ sa=0.265 sb=0.265 sd=0.28 topography=normal area=0.063 perim=1.14
MI634 M1 M0 VGND VNB nfet_01v8 m=1 w=0.64 l=0.15 mult=1 sa=0.265
+ sb=0.265 sd=0.28 topography=normal area=0.063 perim=1.14
MI659 M0 clkneg net107 VPB pfet_01v8_hvt m=1 w=0.42 l=0.15 mult=1
+ sa=0.265 sb=0.265 sd=0.28 topography=normal area=0.063 perim=1.14
MI650 S1 S0 VPWR VPB pfet_01v8_hvt m=1 w=1.0 l=0.15 mult=1 sa=0.265
+ sb=0.265 sd=0.28 topography=normal area=0.063 perim=1.14
MI644 S0 clkpos net122 VPB pfet_01v8_hvt m=1 w=0.42 l=0.15 mult=1
+ sa=0.265 sb=0.265 sd=0.28 topography=normal area=0.063 perim=1.14
MI639 M1 M0 VPWR VPB pfet_01v8_hvt m=1 w=0.75 l=0.15 mult=1 sa=0.265
+ sb=0.265 sd=0.28 topography=normal area=0.063 perim=1.14
MI643 net122 S1 VPWR VPB pfet_01v8_hvt m=1 w=0.42 l=0.15 mult=1
+ sa=0.265 sb=0.265 sd=0.28 topography=normal area=0.063 perim=1.14
MI638 clkneg CLK VPWR VPB pfet_01v8_hvt m=1 w=0.64 l=0.15 mult=1
+ sa=0.265 sb=0.265 sd=0.28 topography=normal area=0.063 perim=1.14
MI658 net107 M1 VPWR VPB pfet_01v8_hvt m=1 w=0.42 l=0.15 mult=1
+ sa=0.265 sb=0.265 sd=0.28 topography=normal area=0.063 perim=1.14
MI645 Q S1 VPWR VPB pfet_01v8_hvt m=4 w=1.0 l=0.15 mult=1 sa=0.265
+ sb=0.265 sd=0.28 topography=normal area=0.063 perim=1.14
MI651 db clkpos M0 VPB pfet_01v8_hvt m=1 w=0.42 l=0.15 mult=1 sa=0.265
+ sb=0.265 sd=0.28 topography=normal area=0.063 perim=1.14
MI655 db D VPWR VPB pfet_01v8_hvt m=1 w=0.42 l=0.15 mult=1 sa=0.265
+ sb=0.265 sd=0.28 topography=normal area=0.063 perim=1.14
MI653 M1 clkneg S0 VPB pfet_01v8_hvt m=1 w=0.42 l=0.15 mult=1 sa=0.265
+ sb=0.265 sd=0.28 topography=normal area=0.063 perim=1.14
MI637 clkpos clkneg VPWR VPB pfet_01v8_hvt m=1 w=0.64 l=0.15 mult=1
+ sa=0.265 sb=0.265 sd=0.28 topography=normal area=0.063 perim=1.14
.ENDS

.SUBCKT sky130_fd_sc_hd__diode_2 DIODE VGND VNB VPB VPWR
.ENDS

.SUBCKT sky130_fd_sc_hd__dlclkp_1 CLK GATE VGND VNB VPB VPWR GCLK
MI662 net75 m1 VPWR VPB pfet_01v8_hvt m=1 w=0.42 l=0.15 mult=1
+ sa=0.265 sb=0.265 sd=0.28 topography=normal area=0.063 perim=1.14
MI664 M0 clkpos net75 VPB pfet_01v8_hvt m=1 w=0.42 l=0.15 mult=1
+ sa=0.265 sb=0.265 sd=0.28 topography=normal area=0.063 perim=1.14
MI659 net63 CLK VPWR VPB pfet_01v8_hvt m=1 w=0.64 l=0.15 mult=1
+ sa=0.265 sb=0.265 sd=0.28 topography=normal area=0.063 perim=1.14
MI658 net63 m1 VPWR VPB pfet_01v8_hvt m=1 w=0.64 l=0.15 mult=1
+ sa=0.265 sb=0.265 sd=0.28 topography=normal area=0.063 perim=1.14
MI19 m1 M0 VPWR VPB pfet_01v8_hvt m=1 w=1.0 l=0.15 mult=1 sa=0.265
+ sb=0.265 sd=0.28 topography=normal area=0.063 perim=1.14
MI38 M0 clkneg net54 VPB pfet_01v8_hvt m=1 w=0.42 l=0.15 mult=1
+ sa=0.265 sb=0.265 sd=0.28 topography=normal area=0.063 perim=1.14
MI37 net54 GATE VPWR VPB pfet_01v8_hvt m=1 w=0.64 l=0.15 mult=1
+ sa=0.265 sb=0.265 sd=0.28 topography=normal area=0.063 perim=1.14
MI47 clkneg clkpos VPWR VPB pfet_01v8_hvt m=1 w=0.64 l=0.15 mult=1
+ sa=0.265 sb=0.265 sd=0.28 topography=normal area=0.063 perim=1.14
MI45 clkpos CLK VPWR VPB pfet_01v8_hvt m=1 w=0.64 l=0.15 mult=1
+ sa=0.265 sb=0.265 sd=0.28 topography=normal area=0.063 perim=1.14
MI660 GCLK net63 VPWR VPB pfet_01v8_hvt m=1 w=1.0 l=0.15 mult=1
+ sa=0.265 sb=0.265 sd=0.28 topography=normal area=0.063 perim=1.14
MI20 m1 M0 VGND VNB nfet_01v8 m=1 w=0.65 l=0.15 mult=1 sa=0.265
+ sb=0.265 sd=0.28 topography=normal area=0.063 perim=1.14
MI655 M0 clkneg net110 VNB nfet_01v8 m=1 w=0.39 l=0.15 mult=1 sa=0.265
+ sb=0.265 sd=0.28 topography=normal area=0.063 perim=1.14
MI654 net110 m1 VGND VNB nfet_01v8 m=1 w=0.42 l=0.15 mult=1 sa=0.265
+ sb=0.265 sd=0.28 topography=normal area=0.063 perim=1.14
MI34 M0 clkpos net91 VNB nfet_01v8 m=1 w=0.42 l=0.15 mult=1 sa=0.265
+ sb=0.265 sd=0.28 topography=normal area=0.063 perim=1.14
MI657 net99 CLK VGND VNB nfet_01v8 m=1 w=0.42 l=0.15 mult=1 sa=0.265
+ sb=0.265 sd=0.28 topography=normal area=0.063 perim=1.14
MI656 net63 m1 net99 VNB nfet_01v8 m=1 w=0.42 l=0.15 mult=1 sa=0.265
+ sb=0.265 sd=0.28 topography=normal area=0.063 perim=1.14
MI36 net91 GATE VGND VNB nfet_01v8 m=1 w=0.42 l=0.15 mult=1 sa=0.265
+ sb=0.265 sd=0.28 topography=normal area=0.063 perim=1.14
MI46 clkneg clkpos VGND VNB nfet_01v8 m=1 w=0.42 l=0.15 mult=1
+ sa=0.265 sb=0.265 sd=0.28 topography=normal area=0.063 perim=1.14
MI44 clkpos CLK VGND VNB nfet_01v8 m=1 w=0.42 l=0.15 mult=1 sa=0.265
+ sb=0.265 sd=0.28 topography=normal area=0.063 perim=1.14
MI653 GCLK net63 VGND VNB nfet_01v8 m=1 w=0.65 l=0.15 mult=1 sa=0.265
+ sb=0.265 sd=0.28 topography=normal area=0.063 perim=1.14
.ENDS

.SUBCKT sky130_fd_sc_hd__dlclkp_2 CLK GATE VGND VNB VPB VPWR GCLK
MI662 net75 m1 VPWR VPB pfet_01v8_hvt m=1 w=0.42 l=0.15 mult=1
+ sa=0.265 sb=0.265 sd=0.28 topography=normal area=0.063 perim=1.14
MI664 M0 clkpos net75 VPB pfet_01v8_hvt m=1 w=0.42 l=0.15 mult=1
+ sa=0.265 sb=0.265 sd=0.28 topography=normal area=0.063 perim=1.14
MI659 net63 CLK VPWR VPB pfet_01v8_hvt m=1 w=0.64 l=0.15 mult=1
+ sa=0.265 sb=0.265 sd=0.28 topography=normal area=0.063 perim=1.14
MI658 net63 m1 VPWR VPB pfet_01v8_hvt m=1 w=0.64 l=0.15 mult=1
+ sa=0.265 sb=0.265 sd=0.28 topography=normal area=0.063 perim=1.14
MI19 m1 M0 VPWR VPB pfet_01v8_hvt m=1 w=1.0 l=0.15 mult=1 sa=0.265
+ sb=0.265 sd=0.28 topography=normal area=0.063 perim=1.14
MI38 M0 clkneg net54 VPB pfet_01v8_hvt m=1 w=0.42 l=0.15 mult=1
+ sa=0.265 sb=0.265 sd=0.28 topography=normal area=0.063 perim=1.14
MI37 net54 GATE VPWR VPB pfet_01v8_hvt m=1 w=0.64 l=0.15 mult=1
+ sa=0.265 sb=0.265 sd=0.28 topography=normal area=0.063 perim=1.14
MI47 clkneg clkpos VPWR VPB pfet_01v8_hvt m=1 w=0.64 l=0.15 mult=1
+ sa=0.265 sb=0.265 sd=0.28 topography=normal area=0.063 perim=1.14
MI45 clkpos CLK VPWR VPB pfet_01v8_hvt m=1 w=0.64 l=0.15 mult=1
+ sa=0.265 sb=0.265 sd=0.28 topography=normal area=0.063 perim=1.14
MI660 GCLK net63 VPWR VPB pfet_01v8_hvt m=2 w=1.0 l=0.15 mult=1
+ sa=0.265 sb=0.265 sd=0.28 topography=normal area=0.063 perim=1.14
MI20 m1 M0 VGND VNB nfet_01v8 m=1 w=0.65 l=0.15 mult=1 sa=0.265
+ sb=0.265 sd=0.28 topography=normal area=0.063 perim=1.14
MI655 M0 clkneg net110 VNB nfet_01v8 m=1 w=0.39 l=0.15 mult=1 sa=0.265
+ sb=0.265 sd=0.28 topography=normal area=0.063 perim=1.14
MI654 net110 m1 VGND VNB nfet_01v8 m=1 w=0.42 l=0.15 mult=1 sa=0.265
+ sb=0.265 sd=0.28 topography=normal area=0.063 perim=1.14
MI34 M0 clkpos net91 VNB nfet_01v8 m=1 w=0.42 l=0.15 mult=1 sa=0.265
+ sb=0.265 sd=0.28 topography=normal area=0.063 perim=1.14
MI657 net99 CLK VGND VNB nfet_01v8 m=1 w=0.42 l=0.15 mult=1 sa=0.265
+ sb=0.265 sd=0.28 topography=normal area=0.063 perim=1.14
MI656 net63 m1 net99 VNB nfet_01v8 m=1 w=0.42 l=0.15 mult=1 sa=0.265
+ sb=0.265 sd=0.28 topography=normal area=0.063 perim=1.14
MI36 net91 GATE VGND VNB nfet_01v8 m=1 w=0.42 l=0.15 mult=1 sa=0.265
+ sb=0.265 sd=0.28 topography=normal area=0.063 perim=1.14
MI46 clkneg clkpos VGND VNB nfet_01v8 m=1 w=0.42 l=0.15 mult=1
+ sa=0.265 sb=0.265 sd=0.28 topography=normal area=0.063 perim=1.14
MI44 clkpos CLK VGND VNB nfet_01v8 m=1 w=0.42 l=0.15 mult=1 sa=0.265
+ sb=0.265 sd=0.28 topography=normal area=0.063 perim=1.14
MI653 GCLK net63 VGND VNB nfet_01v8 m=2 w=0.65 l=0.15 mult=1 sa=0.265
+ sb=0.265 sd=0.28 topography=normal area=0.063 perim=1.14
.ENDS

.SUBCKT sky130_fd_sc_hd__dlclkp_4 CLK GATE VGND VNB VPB VPWR GCLK
MI662 net75 m1 VPWR VPB pfet_01v8_hvt m=1 w=0.42 l=0.15 mult=1
+ sa=0.265 sb=0.265 sd=0.28 topography=normal area=0.063 perim=1.14
MI664 M0 clkpos net75 VPB pfet_01v8_hvt m=1 w=0.42 l=0.15 mult=1
+ sa=0.265 sb=0.265 sd=0.28 topography=normal area=0.063 perim=1.14
MI659 net63 CLK VPWR VPB pfet_01v8_hvt m=1 w=1.0 l=0.15 mult=1
+ sa=0.265 sb=0.265 sd=0.28 topography=normal area=0.063 perim=1.14
MI658 net63 m1 VPWR VPB pfet_01v8_hvt m=1 w=1.0 l=0.15 mult=1 sa=0.265
+ sb=0.265 sd=0.28 topography=normal area=0.063 perim=1.14
MI19 m1 M0 VPWR VPB pfet_01v8_hvt m=1 w=1.0 l=0.15 mult=1 sa=0.265
+ sb=0.265 sd=0.28 topography=normal area=0.063 perim=1.14
MI38 M0 clkneg net54 VPB pfet_01v8_hvt m=1 w=0.42 l=0.15 mult=1
+ sa=0.265 sb=0.265 sd=0.28 topography=normal area=0.063 perim=1.14
MI37 net54 GATE VPWR VPB pfet_01v8_hvt m=1 w=0.64 l=0.15 mult=1
+ sa=0.265 sb=0.265 sd=0.28 topography=normal area=0.063 perim=1.14
MI47 clkneg clkpos VPWR VPB pfet_01v8_hvt m=1 w=0.64 l=0.15 mult=1
+ sa=0.265 sb=0.265 sd=0.28 topography=normal area=0.063 perim=1.14
MI45 clkpos CLK VPWR VPB pfet_01v8_hvt m=1 w=0.64 l=0.15 mult=1
+ sa=0.265 sb=0.265 sd=0.28 topography=normal area=0.063 perim=1.14
MI660 GCLK net63 VPWR VPB pfet_01v8_hvt m=4 w=1.0 l=0.15 mult=1
+ sa=0.265 sb=0.265 sd=0.28 topography=normal area=0.063 perim=1.14
MI20 m1 M0 VGND VNB nfet_01v8 m=1 w=0.65 l=0.15 mult=1 sa=0.265
+ sb=0.265 sd=0.28 topography=normal area=0.063 perim=1.14
MI655 M0 clkneg net110 VNB nfet_01v8 m=1 w=0.36 l=0.15 mult=1 sa=0.265
+ sb=0.265 sd=0.28 topography=normal area=0.063 perim=1.14
MI654 net110 m1 VGND VNB nfet_01v8 m=1 w=0.42 l=0.15 mult=1 sa=0.265
+ sb=0.265 sd=0.28 topography=normal area=0.063 perim=1.14
MI34 M0 clkpos net91 VNB nfet_01v8 m=1 w=0.36 l=0.15 mult=1 sa=0.265
+ sb=0.265 sd=0.28 topography=normal area=0.063 perim=1.14
MI657 net99 CLK VGND VNB nfet_01v8 m=1 w=0.65 l=0.15 mult=1 sa=0.265
+ sb=0.265 sd=0.28 topography=normal area=0.063 perim=1.14
MI656 net63 m1 net99 VNB nfet_01v8 m=1 w=0.65 l=0.15 mult=1 sa=0.265
+ sb=0.265 sd=0.28 topography=normal area=0.063 perim=1.14
MI36 net91 GATE VGND VNB nfet_01v8 m=1 w=0.42 l=0.15 mult=1 sa=0.265
+ sb=0.265 sd=0.28 topography=normal area=0.063 perim=1.14
MI46 clkneg clkpos VGND VNB nfet_01v8 m=1 w=0.42 l=0.15 mult=1
+ sa=0.265 sb=0.265 sd=0.28 topography=normal area=0.063 perim=1.14
MI44 clkpos CLK VGND VNB nfet_01v8 m=1 w=0.42 l=0.15 mult=1 sa=0.265
+ sb=0.265 sd=0.28 topography=normal area=0.063 perim=1.14
MI653 GCLK net63 VGND VNB nfet_01v8 m=4 w=0.65 l=0.15 mult=1 sa=0.265
+ sb=0.265 sd=0.28 topography=normal area=0.063 perim=1.14
.ENDS

.SUBCKT sky130_fd_sc_hd__dlrbn_1 D GATE_N RESET_B VGND VNB VPB VPWR Q Q_N
MI635 clkneg clkpos VPWR VPB pfet_01v8_hvt m=1 w=0.64 l=0.15 mult=1
+ sa=0.265 sb=0.265 sd=0.28 topography=normal area=0.063 perim=1.14
MI648 Q_N net125 VPWR VPB pfet_01v8_hvt m=1 w=1.0 l=0.15 mult=1
+ sa=0.265 sb=0.265 sd=0.28 topography=normal area=0.063 perim=1.14
MI17 M0 clkneg net61 VPB pfet_01v8_hvt m=1 w=0.42 l=0.15 mult=1
+ sa=0.265 sb=0.265 sd=0.28 topography=normal area=0.063 perim=1.14
MI646 net125 m1 VPWR VPB pfet_01v8_hvt m=1 w=0.64 l=0.15 mult=1
+ sa=0.265 sb=0.265 sd=0.28 topography=normal area=0.063 perim=1.14
MI650 Q m1 VPWR VPB pfet_01v8_hvt m=1 w=1.0 l=0.15 mult=1 sa=0.265
+ sb=0.265 sd=0.28 topography=normal area=0.063 perim=1.14
MI633 clkpos GATE_N VPWR VPB pfet_01v8_hvt m=1 w=0.64 l=0.15 mult=1
+ sa=0.265 sb=0.265 sd=0.28 topography=normal area=0.063 perim=1.14
MI658 m1 RESET_B VPWR VPB pfet_01v8_hvt m=1 w=1.0 l=0.15 mult=1
+ sa=0.265 sb=0.265 sd=0.28 topography=normal area=0.063 perim=1.14
MI18 net61 db VPWR VPB pfet_01v8_hvt m=1 w=0.64 l=0.15 mult=1 sa=0.265
+ sb=0.265 sd=0.28 topography=normal area=0.063 perim=1.14
MI653 net57 m1 VPWR VPB pfet_01v8_hvt m=1 w=0.42 l=0.15 mult=1
+ sa=0.265 sb=0.265 sd=0.28 topography=normal area=0.063 perim=1.14
MI651 M0 clkpos net57 VPB pfet_01v8_hvt m=1 w=0.42 l=0.15 mult=1
+ sa=0.265 sb=0.265 sd=0.28 topography=normal area=0.063 perim=1.14
MI655 m1 M0 VPWR VPB pfet_01v8_hvt m=1 w=1.0 l=0.15 mult=1 sa=0.265
+ sb=0.265 sd=0.28 topography=normal area=0.063 perim=1.14
MI638 db D VPWR VPB pfet_01v8_hvt m=1 w=0.64 l=0.15 mult=1 sa=0.265
+ sb=0.265 sd=0.28 topography=normal area=0.063 perim=1.14
MI634 clkpos GATE_N VGND VNB nfet_01v8 m=1 w=0.42 l=0.15 mult=1
+ sa=0.265 sb=0.265 sd=0.28 topography=normal area=0.063 perim=1.14
MI647 Q_N net125 VGND VNB nfet_01v8 m=1 w=0.65 l=0.15 mult=1 sa=0.265
+ sb=0.265 sd=0.28 topography=normal area=0.063 perim=1.14
MI649 Q m1 VGND VNB nfet_01v8 m=1 w=0.65 l=0.15 mult=1 sa=0.265
+ sb=0.265 sd=0.28 topography=normal area=0.063 perim=1.14
MI645 net125 m1 VGND VNB nfet_01v8 m=1 w=0.42 l=0.15 mult=1 sa=0.265
+ sb=0.265 sd=0.28 topography=normal area=0.063 perim=1.14
MI657 net108 RESET_B VGND VNB nfet_01v8 m=1 w=0.65 l=0.15 mult=1
+ sa=0.265 sb=0.265 sd=0.28 topography=normal area=0.063 perim=1.14
MI652 M0 clkneg net116 VNB nfet_01v8 m=1 w=0.36 l=0.15 mult=1 sa=0.265
+ sb=0.265 sd=0.28 topography=normal area=0.063 perim=1.14
MI654 net116 m1 VGND VNB nfet_01v8 m=1 w=0.42 l=0.15 mult=1 sa=0.265
+ sb=0.265 sd=0.28 topography=normal area=0.063 perim=1.14
MI656 m1 M0 net108 VNB nfet_01v8 m=1 w=0.65 l=0.15 mult=1 sa=0.265
+ sb=0.265 sd=0.28 topography=normal area=0.063 perim=1.14
MI636 clkneg clkpos VGND VNB nfet_01v8 m=1 w=0.42 l=0.15 mult=1
+ sa=0.265 sb=0.265 sd=0.28 topography=normal area=0.063 perim=1.14
MI637 db D VGND VNB nfet_01v8 m=1 w=0.42 l=0.15 mult=1 sa=0.265
+ sb=0.265 sd=0.28 topography=normal area=0.063 perim=1.14
MI19 M0 clkpos net96 VNB nfet_01v8 m=1 w=0.36 l=0.15 mult=1 sa=0.265
+ sb=0.265 sd=0.28 topography=normal area=0.063 perim=1.14
MI20 net96 db VGND VNB nfet_01v8 m=1 w=0.42 l=0.15 mult=1 sa=0.265
+ sb=0.265 sd=0.28 topography=normal area=0.063 perim=1.14
.ENDS

.SUBCKT sky130_fd_sc_hd__dlrbn_2 D GATE_N RESET_B VGND VNB VPB VPWR Q Q_N
MI635 clkneg clkpos VPWR VPB pfet_01v8_hvt m=1 w=0.64 l=0.15 mult=1
+ sa=0.265 sb=0.265 sd=0.28 topography=normal area=0.063 perim=1.14
MI648 Q_N net125 VPWR VPB pfet_01v8_hvt m=2 w=1.0 l=0.15 mult=1
+ sa=0.265 sb=0.265 sd=0.28 topography=normal area=0.063 perim=1.14
MI17 M0 clkneg net61 VPB pfet_01v8_hvt m=1 w=0.42 l=0.15 mult=1
+ sa=0.265 sb=0.265 sd=0.28 topography=normal area=0.063 perim=1.14
MI646 net125 m1 VPWR VPB pfet_01v8_hvt m=1 w=0.64 l=0.15 mult=1
+ sa=0.265 sb=0.265 sd=0.28 topography=normal area=0.063 perim=1.14
MI650 Q m1 VPWR VPB pfet_01v8_hvt m=2 w=1.0 l=0.15 mult=1 sa=0.265
+ sb=0.265 sd=0.28 topography=normal area=0.063 perim=1.14
MI633 clkpos GATE_N VPWR VPB pfet_01v8_hvt m=1 w=0.64 l=0.15 mult=1
+ sa=0.265 sb=0.265 sd=0.28 topography=normal area=0.063 perim=1.14
MI658 m1 RESET_B VPWR VPB pfet_01v8_hvt m=1 w=1.0 l=0.15 mult=1
+ sa=0.265 sb=0.265 sd=0.28 topography=normal area=0.063 perim=1.14
MI18 net61 db VPWR VPB pfet_01v8_hvt m=1 w=0.64 l=0.15 mult=1 sa=0.265
+ sb=0.265 sd=0.28 topography=normal area=0.063 perim=1.14
MI653 net57 m1 VPWR VPB pfet_01v8_hvt m=1 w=0.42 l=0.15 mult=1
+ sa=0.265 sb=0.265 sd=0.28 topography=normal area=0.063 perim=1.14
MI651 M0 clkpos net57 VPB pfet_01v8_hvt m=1 w=0.42 l=0.15 mult=1
+ sa=0.265 sb=0.265 sd=0.28 topography=normal area=0.063 perim=1.14
MI655 m1 M0 VPWR VPB pfet_01v8_hvt m=1 w=1.0 l=0.15 mult=1 sa=0.265
+ sb=0.265 sd=0.28 topography=normal area=0.063 perim=1.14
MI638 db D VPWR VPB pfet_01v8_hvt m=1 w=0.64 l=0.15 mult=1 sa=0.265
+ sb=0.265 sd=0.28 topography=normal area=0.063 perim=1.14
MI634 clkpos GATE_N VGND VNB nfet_01v8 m=1 w=0.42 l=0.15 mult=1
+ sa=0.265 sb=0.265 sd=0.28 topography=normal area=0.063 perim=1.14
MI647 Q_N net125 VGND VNB nfet_01v8 m=2 w=0.65 l=0.15 mult=1 sa=0.265
+ sb=0.265 sd=0.28 topography=normal area=0.063 perim=1.14
MI649 Q m1 VGND VNB nfet_01v8 m=2 w=0.65 l=0.15 mult=1 sa=0.265
+ sb=0.265 sd=0.28 topography=normal area=0.063 perim=1.14
MI645 net125 m1 VGND VNB nfet_01v8 m=1 w=0.42 l=0.15 mult=1 sa=0.265
+ sb=0.265 sd=0.28 topography=normal area=0.063 perim=1.14
MI657 net108 RESET_B VGND VNB nfet_01v8 m=1 w=0.65 l=0.15 mult=1
+ sa=0.265 sb=0.265 sd=0.28 topography=normal area=0.063 perim=1.14
MI652 M0 clkneg net116 VNB nfet_01v8 m=1 w=0.36 l=0.15 mult=1 sa=0.265
+ sb=0.265 sd=0.28 topography=normal area=0.063 perim=1.14
MI654 net116 m1 VGND VNB nfet_01v8 m=1 w=0.42 l=0.15 mult=1 sa=0.265
+ sb=0.265 sd=0.28 topography=normal area=0.063 perim=1.14
MI656 m1 M0 net108 VNB nfet_01v8 m=1 w=0.65 l=0.15 mult=1 sa=0.265
+ sb=0.265 sd=0.28 topography=normal area=0.063 perim=1.14
MI636 clkneg clkpos VGND VNB nfet_01v8 m=1 w=0.42 l=0.15 mult=1
+ sa=0.265 sb=0.265 sd=0.28 topography=normal area=0.063 perim=1.14
MI637 db D VGND VNB nfet_01v8 m=1 w=0.42 l=0.15 mult=1 sa=0.265
+ sb=0.265 sd=0.28 topography=normal area=0.063 perim=1.14
MI19 M0 clkpos net96 VNB nfet_01v8 m=1 w=0.36 l=0.15 mult=1 sa=0.265
+ sb=0.265 sd=0.28 topography=normal area=0.063 perim=1.14
MI20 net96 db VGND VNB nfet_01v8 m=1 w=0.42 l=0.15 mult=1 sa=0.265
+ sb=0.265 sd=0.28 topography=normal area=0.063 perim=1.14
.ENDS

.SUBCKT sky130_fd_sc_hd__dlrbp_1 D GATE RESET_B VGND VNB VPB VPWR Q Q_N
MI635 clkpos clkneg VPWR VPB pfet_01v8_hvt m=1 w=0.64 l=0.15 mult=1
+ sa=0.265 sb=0.265 sd=0.28 topography=normal area=0.063 perim=1.14
MI648 Q_N net125 VPWR VPB pfet_01v8_hvt m=1 w=1.0 l=0.15 mult=1
+ sa=0.265 sb=0.265 sd=0.28 topography=normal area=0.063 perim=1.14
MI17 M0 clkneg net61 VPB pfet_01v8_hvt m=1 w=0.42 l=0.15 mult=1
+ sa=0.265 sb=0.265 sd=0.28 topography=normal area=0.063 perim=1.14
MI646 net125 m1 VPWR VPB pfet_01v8_hvt m=1 w=0.64 l=0.15 mult=1
+ sa=0.265 sb=0.265 sd=0.28 topography=normal area=0.063 perim=1.14
MI650 Q m1 VPWR VPB pfet_01v8_hvt m=1 w=1.0 l=0.15 mult=1 sa=0.265
+ sb=0.265 sd=0.28 topography=normal area=0.063 perim=1.14
MI633 clkneg GATE VPWR VPB pfet_01v8_hvt m=1 w=0.64 l=0.15 mult=1
+ sa=0.265 sb=0.265 sd=0.28 topography=normal area=0.063 perim=1.14
MI658 m1 RESET_B VPWR VPB pfet_01v8_hvt m=1 w=1.0 l=0.15 mult=1
+ sa=0.265 sb=0.265 sd=0.28 topography=normal area=0.063 perim=1.14
MI18 net61 db VPWR VPB pfet_01v8_hvt m=1 w=0.64 l=0.15 mult=1 sa=0.265
+ sb=0.265 sd=0.28 topography=normal area=0.063 perim=1.14
MI653 net57 m1 VPWR VPB pfet_01v8_hvt m=1 w=0.42 l=0.15 mult=1
+ sa=0.265 sb=0.265 sd=0.28 topography=normal area=0.063 perim=1.14
MI651 M0 clkpos net57 VPB pfet_01v8_hvt m=1 w=0.42 l=0.15 mult=1
+ sa=0.265 sb=0.265 sd=0.28 topography=normal area=0.063 perim=1.14
MI655 m1 M0 VPWR VPB pfet_01v8_hvt m=1 w=1.0 l=0.15 mult=1 sa=0.265
+ sb=0.265 sd=0.28 topography=normal area=0.063 perim=1.14
MI638 db D VPWR VPB pfet_01v8_hvt m=1 w=0.64 l=0.15 mult=1 sa=0.265
+ sb=0.265 sd=0.28 topography=normal area=0.063 perim=1.14
MI634 clkneg GATE VGND VNB nfet_01v8 m=1 w=0.42 l=0.15 mult=1 sa=0.265
+ sb=0.265 sd=0.28 topography=normal area=0.063 perim=1.14
MI647 Q_N net125 VGND VNB nfet_01v8 m=1 w=0.65 l=0.15 mult=1 sa=0.265
+ sb=0.265 sd=0.28 topography=normal area=0.063 perim=1.14
MI649 Q m1 VGND VNB nfet_01v8 m=1 w=0.65 l=0.15 mult=1 sa=0.265
+ sb=0.265 sd=0.28 topography=normal area=0.063 perim=1.14
MI645 net125 m1 VGND VNB nfet_01v8 m=1 w=0.42 l=0.15 mult=1 sa=0.265
+ sb=0.265 sd=0.28 topography=normal area=0.063 perim=1.14
MI657 net121 RESET_B VGND VNB nfet_01v8 m=1 w=0.65 l=0.15 mult=1
+ sa=0.265 sb=0.265 sd=0.28 topography=normal area=0.063 perim=1.14
MI652 M0 clkneg net116 VNB nfet_01v8 m=1 w=0.36 l=0.15 mult=1 sa=0.265
+ sb=0.265 sd=0.28 topography=normal area=0.063 perim=1.14
MI654 net116 m1 VGND VNB nfet_01v8 m=1 w=0.42 l=0.15 mult=1 sa=0.265
+ sb=0.265 sd=0.28 topography=normal area=0.063 perim=1.14
MI656 m1 M0 net121 VNB nfet_01v8 m=1 w=0.65 l=0.15 mult=1 sa=0.265
+ sb=0.265 sd=0.28 topography=normal area=0.063 perim=1.14
MI636 clkpos clkneg VGND VNB nfet_01v8 m=1 w=0.42 l=0.15 mult=1
+ sa=0.265 sb=0.265 sd=0.28 topography=normal area=0.063 perim=1.14
MI637 db D VGND VNB nfet_01v8 m=1 w=0.42 l=0.15 mult=1 sa=0.265
+ sb=0.265 sd=0.28 topography=normal area=0.063 perim=1.14
MI19 M0 clkpos net96 VNB nfet_01v8 m=1 w=0.36 l=0.15 mult=1 sa=0.265
+ sb=0.265 sd=0.28 topography=normal area=0.063 perim=1.14
MI20 net96 db VGND VNB nfet_01v8 m=1 w=0.42 l=0.15 mult=1 sa=0.265
+ sb=0.265 sd=0.28 topography=normal area=0.063 perim=1.14
.ENDS

.SUBCKT sky130_fd_sc_hd__dlrbp_2 D GATE RESET_B VGND VNB VPB VPWR Q Q_N
MI635 clkpos clkneg VPWR VPB pfet_01v8_hvt m=1 w=0.64 l=0.15 mult=1
+ sa=0.265 sb=0.265 sd=0.28 topography=normal area=0.063 perim=1.14
MI648 Q_N net125 VPWR VPB pfet_01v8_hvt m=2 w=1.0 l=0.15 mult=1
+ sa=0.265 sb=0.265 sd=0.28 topography=normal area=0.063 perim=1.14
MI17 M0 clkneg net61 VPB pfet_01v8_hvt m=1 w=0.42 l=0.15 mult=1
+ sa=0.265 sb=0.265 sd=0.28 topography=normal area=0.063 perim=1.14
MI646 net125 m1 VPWR VPB pfet_01v8_hvt m=1 w=0.64 l=0.15 mult=1
+ sa=0.265 sb=0.265 sd=0.28 topography=normal area=0.063 perim=1.14
MI650 Q m1 VPWR VPB pfet_01v8_hvt m=2 w=1.0 l=0.15 mult=1 sa=0.265
+ sb=0.265 sd=0.28 topography=normal area=0.063 perim=1.14
MI633 clkneg GATE VPWR VPB pfet_01v8_hvt m=1 w=0.64 l=0.15 mult=1
+ sa=0.265 sb=0.265 sd=0.28 topography=normal area=0.063 perim=1.14
MI658 m1 RESET_B VPWR VPB pfet_01v8_hvt m=1 w=1.0 l=0.15 mult=1
+ sa=0.265 sb=0.265 sd=0.28 topography=normal area=0.063 perim=1.14
MI18 net61 db VPWR VPB pfet_01v8_hvt m=1 w=0.64 l=0.15 mult=1 sa=0.265
+ sb=0.265 sd=0.28 topography=normal area=0.063 perim=1.14
MI653 net57 m1 VPWR VPB pfet_01v8_hvt m=1 w=0.42 l=0.15 mult=1
+ sa=0.265 sb=0.265 sd=0.28 topography=normal area=0.063 perim=1.14
MI651 M0 clkpos net57 VPB pfet_01v8_hvt m=1 w=0.42 l=0.15 mult=1
+ sa=0.265 sb=0.265 sd=0.28 topography=normal area=0.063 perim=1.14
MI655 m1 M0 VPWR VPB pfet_01v8_hvt m=1 w=1.0 l=0.15 mult=1 sa=0.265
+ sb=0.265 sd=0.28 topography=normal area=0.063 perim=1.14
MI638 db D VPWR VPB pfet_01v8_hvt m=1 w=0.64 l=0.15 mult=1 sa=0.265
+ sb=0.265 sd=0.28 topography=normal area=0.063 perim=1.14
MI634 clkneg GATE VGND VNB nfet_01v8 m=1 w=0.42 l=0.15 mult=1 sa=0.265
+ sb=0.265 sd=0.28 topography=normal area=0.063 perim=1.14
MI647 Q_N net125 VGND VNB nfet_01v8 m=2 w=0.65 l=0.15 mult=1 sa=0.265
+ sb=0.265 sd=0.28 topography=normal area=0.063 perim=1.14
MI649 Q m1 VGND VNB nfet_01v8 m=2 w=0.65 l=0.15 mult=1 sa=0.265
+ sb=0.265 sd=0.28 topography=normal area=0.063 perim=1.14
MI645 net125 m1 VGND VNB nfet_01v8 m=1 w=0.42 l=0.15 mult=1 sa=0.265
+ sb=0.265 sd=0.28 topography=normal area=0.063 perim=1.14
MI657 net108 RESET_B VGND VNB nfet_01v8 m=1 w=0.65 l=0.15 mult=1
+ sa=0.265 sb=0.265 sd=0.28 topography=normal area=0.063 perim=1.14
MI652 M0 clkneg net116 VNB nfet_01v8 m=1 w=0.36 l=0.15 mult=1 sa=0.265
+ sb=0.265 sd=0.28 topography=normal area=0.063 perim=1.14
MI654 net116 m1 VGND VNB nfet_01v8 m=1 w=0.42 l=0.15 mult=1 sa=0.265
+ sb=0.265 sd=0.28 topography=normal area=0.063 perim=1.14
MI656 m1 M0 net108 VNB nfet_01v8 m=1 w=0.65 l=0.15 mult=1 sa=0.265
+ sb=0.265 sd=0.28 topography=normal area=0.063 perim=1.14
MI636 clkpos clkneg VGND VNB nfet_01v8 m=1 w=0.42 l=0.15 mult=1
+ sa=0.265 sb=0.265 sd=0.28 topography=normal area=0.063 perim=1.14
MI637 db D VGND VNB nfet_01v8 m=1 w=0.42 l=0.15 mult=1 sa=0.265
+ sb=0.265 sd=0.28 topography=normal area=0.063 perim=1.14
MI19 M0 clkpos net96 VNB nfet_01v8 m=1 w=0.36 l=0.15 mult=1 sa=0.265
+ sb=0.265 sd=0.28 topography=normal area=0.063 perim=1.14
MI20 net96 db VGND VNB nfet_01v8 m=1 w=0.42 l=0.15 mult=1 sa=0.265
+ sb=0.265 sd=0.28 topography=normal area=0.063 perim=1.14
.ENDS

.SUBCKT sky130_fd_sc_hd__dlrtn_1 D GATE_N RESET_B VGND VNB VPB VPWR Q
MI635 clkneg clkpos VPWR VPB pfet_01v8_hvt m=1 w=0.64 l=0.15 mult=1
+ sa=0.265 sb=0.265 sd=0.28 topography=normal area=0.063 perim=1.14
MI17 M0 clkneg net54 VPB pfet_01v8_hvt m=1 w=0.42 l=0.15 mult=1
+ sa=0.265 sb=0.265 sd=0.28 topography=normal area=0.063 perim=1.14
MI650 Q m1 VPWR VPB pfet_01v8_hvt m=1 w=1.0 l=0.15 mult=1 sa=0.265
+ sb=0.265 sd=0.28 topography=normal area=0.063 perim=1.14
MI633 clkpos GATE_N VPWR VPB pfet_01v8_hvt m=1 w=0.64 l=0.15 mult=1
+ sa=0.265 sb=0.265 sd=0.28 topography=normal area=0.063 perim=1.14
MI658 m1 RESET_B VPWR VPB pfet_01v8_hvt m=1 w=1.0 l=0.15 mult=1
+ sa=0.265 sb=0.265 sd=0.28 topography=normal area=0.063 perim=1.14
MI18 net54 db VPWR VPB pfet_01v8_hvt m=1 w=0.64 l=0.15 mult=1 sa=0.265
+ sb=0.265 sd=0.28 topography=normal area=0.063 perim=1.14
MI653 net50 m1 VPWR VPB pfet_01v8_hvt m=1 w=0.42 l=0.15 mult=1
+ sa=0.265 sb=0.265 sd=0.28 topography=normal area=0.063 perim=1.14
MI651 M0 clkpos net50 VPB pfet_01v8_hvt m=1 w=0.42 l=0.15 mult=1
+ sa=0.265 sb=0.265 sd=0.28 topography=normal area=0.063 perim=1.14
MI655 m1 M0 VPWR VPB pfet_01v8_hvt m=1 w=1.0 l=0.15 mult=1 sa=0.265
+ sb=0.265 sd=0.28 topography=normal area=0.063 perim=1.14
MI638 db D VPWR VPB pfet_01v8_hvt m=1 w=0.64 l=0.15 mult=1 sa=0.265
+ sb=0.265 sd=0.28 topography=normal area=0.063 perim=1.14
MI634 clkpos GATE_N VGND VNB nfet_01v8 m=1 w=0.42 l=0.15 mult=1
+ sa=0.265 sb=0.265 sd=0.28 topography=normal area=0.063 perim=1.14
MI649 Q m1 VGND VNB nfet_01v8 m=1 w=0.65 l=0.15 mult=1 sa=0.265
+ sb=0.265 sd=0.28 topography=normal area=0.063 perim=1.14
MI657 net93 RESET_B VGND VNB nfet_01v8 m=1 w=0.65 l=0.15 mult=1
+ sa=0.265 sb=0.265 sd=0.28 topography=normal area=0.063 perim=1.14
MI652 M0 clkneg net101 VNB nfet_01v8 m=1 w=0.36 l=0.15 mult=1 sa=0.265
+ sb=0.265 sd=0.28 topography=normal area=0.063 perim=1.14
MI654 net101 m1 VGND VNB nfet_01v8 m=1 w=0.42 l=0.15 mult=1 sa=0.265
+ sb=0.265 sd=0.28 topography=normal area=0.063 perim=1.14
MI656 m1 M0 net93 VNB nfet_01v8 m=1 w=0.65 l=0.15 mult=1 sa=0.265
+ sb=0.265 sd=0.28 topography=normal area=0.063 perim=1.14
MI636 clkneg clkpos VGND VNB nfet_01v8 m=1 w=0.42 l=0.15 mult=1
+ sa=0.265 sb=0.265 sd=0.28 topography=normal area=0.063 perim=1.14
MI637 db D VGND VNB nfet_01v8 m=1 w=0.42 l=0.15 mult=1 sa=0.265
+ sb=0.265 sd=0.28 topography=normal area=0.063 perim=1.14
MI19 M0 clkpos net81 VNB nfet_01v8 m=1 w=0.36 l=0.15 mult=1 sa=0.265
+ sb=0.265 sd=0.28 topography=normal area=0.063 perim=1.14
MI20 net81 db VGND VNB nfet_01v8 m=1 w=0.42 l=0.15 mult=1 sa=0.265
+ sb=0.265 sd=0.28 topography=normal area=0.063 perim=1.14
.ENDS

.SUBCKT sky130_fd_sc_hd__dlrtn_2 D GATE_N RESET_B VGND VNB VPB VPWR Q
MI635 clkneg clkpos VPWR VPB pfet_01v8_hvt m=1 w=0.64 l=0.15 mult=1
+ sa=0.265 sb=0.265 sd=0.28 topography=normal area=0.063 perim=1.14
MI17 M0 clkneg net54 VPB pfet_01v8_hvt m=1 w=0.42 l=0.15 mult=1
+ sa=0.265 sb=0.265 sd=0.28 topography=normal area=0.063 perim=1.14
MI650 Q m1 VPWR VPB pfet_01v8_hvt m=2 w=1.0 l=0.15 mult=1 sa=0.265
+ sb=0.265 sd=0.28 topography=normal area=0.063 perim=1.14
MI633 clkpos GATE_N VPWR VPB pfet_01v8_hvt m=1 w=0.64 l=0.15 mult=1
+ sa=0.265 sb=0.265 sd=0.28 topography=normal area=0.063 perim=1.14
MI658 m1 RESET_B VPWR VPB pfet_01v8_hvt m=1 w=1.0 l=0.15 mult=1
+ sa=0.265 sb=0.265 sd=0.28 topography=normal area=0.063 perim=1.14
MI18 net54 db VPWR VPB pfet_01v8_hvt m=1 w=0.64 l=0.15 mult=1 sa=0.265
+ sb=0.265 sd=0.28 topography=normal area=0.063 perim=1.14
MI653 net50 m1 VPWR VPB pfet_01v8_hvt m=1 w=0.42 l=0.15 mult=1
+ sa=0.265 sb=0.265 sd=0.28 topography=normal area=0.063 perim=1.14
MI651 M0 clkpos net50 VPB pfet_01v8_hvt m=1 w=0.42 l=0.15 mult=1
+ sa=0.265 sb=0.265 sd=0.28 topography=normal area=0.063 perim=1.14
MI655 m1 M0 VPWR VPB pfet_01v8_hvt m=1 w=1.0 l=0.15 mult=1 sa=0.265
+ sb=0.265 sd=0.28 topography=normal area=0.063 perim=1.14
MI638 db D VPWR VPB pfet_01v8_hvt m=1 w=0.64 l=0.15 mult=1 sa=0.265
+ sb=0.265 sd=0.28 topography=normal area=0.063 perim=1.14
MI634 clkpos GATE_N VGND VNB nfet_01v8 m=1 w=0.42 l=0.15 mult=1
+ sa=0.265 sb=0.265 sd=0.28 topography=normal area=0.063 perim=1.14
MI649 Q m1 VGND VNB nfet_01v8 m=2 w=0.65 l=0.15 mult=1 sa=0.265
+ sb=0.265 sd=0.28 topography=normal area=0.063 perim=1.14
MI657 net93 RESET_B VGND VNB nfet_01v8 m=1 w=0.65 l=0.15 mult=1
+ sa=0.265 sb=0.265 sd=0.28 topography=normal area=0.063 perim=1.14
MI652 M0 clkneg net101 VNB nfet_01v8 m=1 w=0.36 l=0.15 mult=1 sa=0.265
+ sb=0.265 sd=0.28 topography=normal area=0.063 perim=1.14
MI654 net101 m1 VGND VNB nfet_01v8 m=1 w=0.42 l=0.15 mult=1 sa=0.265
+ sb=0.265 sd=0.28 topography=normal area=0.063 perim=1.14
MI656 m1 M0 net93 VNB nfet_01v8 m=1 w=0.65 l=0.15 mult=1 sa=0.265
+ sb=0.265 sd=0.28 topography=normal area=0.063 perim=1.14
MI636 clkneg clkpos VGND VNB nfet_01v8 m=1 w=0.42 l=0.15 mult=1
+ sa=0.265 sb=0.265 sd=0.28 topography=normal area=0.063 perim=1.14
MI637 db D VGND VNB nfet_01v8 m=1 w=0.42 l=0.15 mult=1 sa=0.265
+ sb=0.265 sd=0.28 topography=normal area=0.063 perim=1.14
MI19 M0 clkpos net81 VNB nfet_01v8 m=1 w=0.36 l=0.15 mult=1 sa=0.265
+ sb=0.265 sd=0.28 topography=normal area=0.063 perim=1.14
MI20 net81 db VGND VNB nfet_01v8 m=1 w=0.42 l=0.15 mult=1 sa=0.265
+ sb=0.265 sd=0.28 topography=normal area=0.063 perim=1.14
.ENDS

.SUBCKT sky130_fd_sc_hd__dlrtn_4 D GATE_N RESET_B VGND VNB VPB VPWR Q
MI635 clkneg clkpos VPWR VPB pfet_01v8_hvt m=1 w=0.64 l=0.15 mult=1
+ sa=0.265 sb=0.265 sd=0.28 topography=normal area=0.063 perim=1.14
MI17 M0 clkneg net55 VPB pfet_01v8_hvt m=1 w=0.42 l=0.15 mult=1
+ sa=0.265 sb=0.265 sd=0.28 topography=normal area=0.063 perim=1.14
MI650 Q m1 VPWR VPB pfet_01v8_hvt m=4 w=1.0 l=0.15 mult=1 sa=0.265
+ sb=0.265 sd=0.28 topography=normal area=0.063 perim=1.14
MI633 clkpos GATE_N VPWR VPB pfet_01v8_hvt m=1 w=0.64 l=0.15 mult=1
+ sa=0.265 sb=0.265 sd=0.28 topography=normal area=0.063 perim=1.14
MI658 m1 RESET_B VPWR VPB pfet_01v8_hvt m=1 w=1.0 l=0.15 mult=1
+ sa=0.265 sb=0.265 sd=0.28 topography=normal area=0.063 perim=1.14
MI18 net55 db VPWR VPB pfet_01v8_hvt m=1 w=0.64 l=0.15 mult=1 sa=0.265
+ sb=0.265 sd=0.28 topography=normal area=0.063 perim=1.14
MI653 net51 m1 VPWR VPB pfet_01v8_hvt m=1 w=0.42 l=0.15 mult=1
+ sa=0.265 sb=0.265 sd=0.28 topography=normal area=0.063 perim=1.14
MI651 M0 clkpos net51 VPB pfet_01v8_hvt m=1 w=0.42 l=0.15 mult=1
+ sa=0.265 sb=0.265 sd=0.28 topography=normal area=0.063 perim=1.14
MI655 m1 M0 VPWR VPB pfet_01v8_hvt m=1 w=1.0 l=0.15 mult=1 sa=0.265
+ sb=0.265 sd=0.28 topography=normal area=0.063 perim=1.14
MI638 db D VPWR VPB pfet_01v8_hvt m=1 w=0.64 l=0.15 mult=1 sa=0.265
+ sb=0.265 sd=0.28 topography=normal area=0.063 perim=1.14
MI634 clkpos GATE_N VGND VNB nfet_01v8 m=1 w=0.42 l=0.15 mult=1
+ sa=0.265 sb=0.265 sd=0.28 topography=normal area=0.063 perim=1.14
MI649 Q m1 VGND VNB nfet_01v8 m=4 w=0.65 l=0.15 mult=1 sa=0.265
+ sb=0.265 sd=0.28 topography=normal area=0.063 perim=1.14
MI657 net94 RESET_B VGND VNB nfet_01v8 m=1 w=0.65 l=0.15 mult=1
+ sa=0.265 sb=0.265 sd=0.28 topography=normal area=0.063 perim=1.14
MI652 M0 clkneg net102 VNB nfet_01v8 m=1 w=0.36 l=0.15 mult=1 sa=0.265
+ sb=0.265 sd=0.28 topography=normal area=0.063 perim=1.14
MI654 net102 m1 VGND VNB nfet_01v8 m=1 w=0.42 l=0.15 mult=1 sa=0.265
+ sb=0.265 sd=0.28 topography=normal area=0.063 perim=1.14
MI656 m1 M0 net94 VNB nfet_01v8 m=1 w=0.65 l=0.15 mult=1 sa=0.265
+ sb=0.265 sd=0.28 topography=normal area=0.063 perim=1.14
MI636 clkneg clkpos VGND VNB nfet_01v8 m=1 w=0.42 l=0.15 mult=1
+ sa=0.265 sb=0.265 sd=0.28 topography=normal area=0.063 perim=1.14
MI637 db D VGND VNB nfet_01v8 m=1 w=0.42 l=0.15 mult=1 sa=0.265
+ sb=0.265 sd=0.28 topography=normal area=0.063 perim=1.14
MI19 M0 clkpos net82 VNB nfet_01v8 m=1 w=0.36 l=0.15 mult=1 sa=0.265
+ sb=0.265 sd=0.28 topography=normal area=0.063 perim=1.14
MI20 net82 db VGND VNB nfet_01v8 m=1 w=0.42 l=0.15 mult=1 sa=0.265
+ sb=0.265 sd=0.28 topography=normal area=0.063 perim=1.14
.ENDS

.SUBCKT sky130_fd_sc_hd__dlrtp_1 D GATE RESET_B VGND VNB VPB VPWR Q
MI635 clkpos clkneg VPWR VPB pfet_01v8_hvt m=1 w=0.64 l=0.15 mult=1
+ sa=0.265 sb=0.265 sd=0.28 topography=normal area=0.063 perim=1.14
MI17 M0 clkneg net54 VPB pfet_01v8_hvt m=1 w=0.36 l=0.15 mult=1
+ sa=0.265 sb=0.265 sd=0.28 topography=normal area=0.063 perim=1.14
MI650 Q m1 VPWR VPB pfet_01v8_hvt m=1 w=1.0 l=0.15 mult=1 sa=0.265
+ sb=0.265 sd=0.28 topography=normal area=0.063 perim=1.14
MI633 clkneg GATE VPWR VPB pfet_01v8_hvt m=1 w=0.64 l=0.15 mult=1
+ sa=0.265 sb=0.265 sd=0.28 topography=normal area=0.063 perim=1.14
MI658 m1 RESET_B VPWR VPB pfet_01v8_hvt m=1 w=1.0 l=0.15 mult=1
+ sa=0.265 sb=0.265 sd=0.28 topography=normal area=0.063 perim=1.14
MI18 net54 db VPWR VPB pfet_01v8_hvt m=1 w=0.64 l=0.15 mult=1 sa=0.265
+ sb=0.265 sd=0.28 topography=normal area=0.063 perim=1.14
MI653 net50 m1 VPWR VPB pfet_01v8_hvt m=1 w=0.42 l=0.15 mult=1
+ sa=0.265 sb=0.265 sd=0.28 topography=normal area=0.063 perim=1.14
MI651 M0 clkpos net50 VPB pfet_01v8_hvt m=1 w=0.36 l=0.15 mult=1
+ sa=0.265 sb=0.265 sd=0.28 topography=normal area=0.063 perim=1.14
MI655 m1 M0 VPWR VPB pfet_01v8_hvt m=1 w=1.0 l=0.15 mult=1 sa=0.265
+ sb=0.265 sd=0.28 topography=normal area=0.063 perim=1.14
MI638 db D VPWR VPB pfet_01v8_hvt m=1 w=0.64 l=0.15 mult=1 sa=0.265
+ sb=0.265 sd=0.28 topography=normal area=0.063 perim=1.14
MI634 clkneg GATE VGND VNB nfet_01v8 m=1 w=0.42 l=0.15 mult=1 sa=0.265
+ sb=0.265 sd=0.28 topography=normal area=0.063 perim=1.14
MI649 Q m1 VGND VNB nfet_01v8 m=1 w=0.65 l=0.15 mult=1 sa=0.265
+ sb=0.265 sd=0.28 topography=normal area=0.063 perim=1.14
MI657 net93 RESET_B VGND VNB nfet_01v8 m=1 w=0.65 l=0.15 mult=1
+ sa=0.265 sb=0.265 sd=0.28 topography=normal area=0.063 perim=1.14
MI652 M0 clkneg net101 VNB nfet_01v8 m=1 w=0.42 l=0.15 mult=1 sa=0.265
+ sb=0.265 sd=0.28 topography=normal area=0.063 perim=1.14
MI654 net101 m1 VGND VNB nfet_01v8 m=1 w=0.42 l=0.15 mult=1 sa=0.265
+ sb=0.265 sd=0.28 topography=normal area=0.063 perim=1.14
MI656 m1 M0 net93 VNB nfet_01v8 m=1 w=0.65 l=0.15 mult=1 sa=0.265
+ sb=0.265 sd=0.28 topography=normal area=0.063 perim=1.14
MI636 clkpos clkneg VGND VNB nfet_01v8 m=1 w=0.42 l=0.15 mult=1
+ sa=0.265 sb=0.265 sd=0.28 topography=normal area=0.063 perim=1.14
MI637 db D VGND VNB nfet_01v8 m=1 w=0.42 l=0.15 mult=1 sa=0.265
+ sb=0.265 sd=0.28 topography=normal area=0.063 perim=1.14
MI19 M0 clkpos net81 VNB nfet_01v8 m=1 w=0.42 l=0.15 mult=1 sa=0.265
+ sb=0.265 sd=0.28 topography=normal area=0.063 perim=1.14
MI20 net81 db VGND VNB nfet_01v8 m=1 w=0.42 l=0.15 mult=1 sa=0.265
+ sb=0.265 sd=0.28 topography=normal area=0.063 perim=1.14
.ENDS

.SUBCKT sky130_fd_sc_hd__dlrtp_2 D GATE RESET_B VGND VNB VPB VPWR Q
MI635 clkpos clkneg VPWR VPB pfet_01v8_hvt m=1 w=0.64 l=0.15 mult=1
+ sa=0.265 sb=0.265 sd=0.28 topography=normal area=0.063 perim=1.14
MI17 M0 clkneg net54 VPB pfet_01v8_hvt m=1 w=0.42 l=0.15 mult=1
+ sa=0.265 sb=0.265 sd=0.28 topography=normal area=0.063 perim=1.14
MI650 Q m1 VPWR VPB pfet_01v8_hvt m=2 w=1.0 l=0.15 mult=1 sa=0.265
+ sb=0.265 sd=0.28 topography=normal area=0.063 perim=1.14
MI633 clkneg GATE VPWR VPB pfet_01v8_hvt m=1 w=0.64 l=0.15 mult=1
+ sa=0.265 sb=0.265 sd=0.28 topography=normal area=0.063 perim=1.14
MI658 m1 RESET_B VPWR VPB pfet_01v8_hvt m=1 w=1.0 l=0.15 mult=1
+ sa=0.265 sb=0.265 sd=0.28 topography=normal area=0.063 perim=1.14
MI18 net54 db VPWR VPB pfet_01v8_hvt m=1 w=0.64 l=0.15 mult=1 sa=0.265
+ sb=0.265 sd=0.28 topography=normal area=0.063 perim=1.14
MI653 net50 m1 VPWR VPB pfet_01v8_hvt m=1 w=0.42 l=0.15 mult=1
+ sa=0.265 sb=0.265 sd=0.28 topography=normal area=0.063 perim=1.14
MI651 M0 clkpos net50 VPB pfet_01v8_hvt m=1 w=0.42 l=0.15 mult=1
+ sa=0.265 sb=0.265 sd=0.28 topography=normal area=0.063 perim=1.14
MI655 m1 M0 VPWR VPB pfet_01v8_hvt m=1 w=1.0 l=0.15 mult=1 sa=0.265
+ sb=0.265 sd=0.28 topography=normal area=0.063 perim=1.14
MI638 db D VPWR VPB pfet_01v8_hvt m=1 w=0.64 l=0.15 mult=1 sa=0.265
+ sb=0.265 sd=0.28 topography=normal area=0.063 perim=1.14
MI634 clkneg GATE VGND VNB nfet_01v8 m=1 w=0.42 l=0.15 mult=1 sa=0.265
+ sb=0.265 sd=0.28 topography=normal area=0.063 perim=1.14
MI649 Q m1 VGND VNB nfet_01v8 m=2 w=0.65 l=0.15 mult=1 sa=0.265
+ sb=0.265 sd=0.28 topography=normal area=0.063 perim=1.14
MI657 net93 RESET_B VGND VNB nfet_01v8 m=1 w=0.65 l=0.15 mult=1
+ sa=0.265 sb=0.265 sd=0.28 topography=normal area=0.063 perim=1.14
MI652 M0 clkneg net101 VNB nfet_01v8 m=1 w=0.36 l=0.15 mult=1 sa=0.265
+ sb=0.265 sd=0.28 topography=normal area=0.063 perim=1.14
MI654 net101 m1 VGND VNB nfet_01v8 m=1 w=0.42 l=0.15 mult=1 sa=0.265
+ sb=0.265 sd=0.28 topography=normal area=0.063 perim=1.14
MI656 m1 M0 net93 VNB nfet_01v8 m=1 w=0.65 l=0.15 mult=1 sa=0.265
+ sb=0.265 sd=0.28 topography=normal area=0.063 perim=1.14
MI636 clkpos clkneg VGND VNB nfet_01v8 m=1 w=0.42 l=0.15 mult=1
+ sa=0.265 sb=0.265 sd=0.28 topography=normal area=0.063 perim=1.14
MI637 db D VGND VNB nfet_01v8 m=1 w=0.42 l=0.15 mult=1 sa=0.265
+ sb=0.265 sd=0.28 topography=normal area=0.063 perim=1.14
MI19 M0 clkpos net81 VNB nfet_01v8 m=1 w=0.36 l=0.15 mult=1 sa=0.265
+ sb=0.265 sd=0.28 topography=normal area=0.063 perim=1.14
MI20 net81 db VGND VNB nfet_01v8 m=1 w=0.42 l=0.15 mult=1 sa=0.265
+ sb=0.265 sd=0.28 topography=normal area=0.063 perim=1.14
.ENDS

.SUBCKT sky130_fd_sc_hd__dlrtp_4 D GATE RESET_B VGND VNB VPB VPWR Q
MI635 clkpos clkneg VPWR VPB pfet_01v8_hvt m=1 w=0.64 l=0.15 mult=1
+ sa=0.265 sb=0.265 sd=0.28 topography=normal area=0.063 perim=1.14
MI17 M0 clkneg net55 VPB pfet_01v8_hvt m=1 w=0.42 l=0.15 mult=1
+ sa=0.265 sb=0.265 sd=0.28 topography=normal area=0.063 perim=1.14
MI650 Q m1 VPWR VPB pfet_01v8_hvt m=4 w=1.0 l=0.15 mult=1 sa=0.265
+ sb=0.265 sd=0.28 topography=normal area=0.063 perim=1.14
MI633 clkneg GATE VPWR VPB pfet_01v8_hvt m=1 w=0.64 l=0.15 mult=1
+ sa=0.265 sb=0.265 sd=0.28 topography=normal area=0.063 perim=1.14
MI658 m1 RESET_B VPWR VPB pfet_01v8_hvt m=1 w=1.0 l=0.15 mult=1
+ sa=0.265 sb=0.265 sd=0.28 topography=normal area=0.063 perim=1.14
MI18 net55 db VPWR VPB pfet_01v8_hvt m=1 w=0.64 l=0.15 mult=1 sa=0.265
+ sb=0.265 sd=0.28 topography=normal area=0.063 perim=1.14
MI653 net51 m1 VPWR VPB pfet_01v8_hvt m=1 w=0.42 l=0.15 mult=1
+ sa=0.265 sb=0.265 sd=0.28 topography=normal area=0.063 perim=1.14
MI651 M0 clkpos net51 VPB pfet_01v8_hvt m=1 w=0.42 l=0.15 mult=1
+ sa=0.265 sb=0.265 sd=0.28 topography=normal area=0.063 perim=1.14
MI655 m1 M0 VPWR VPB pfet_01v8_hvt m=1 w=1.0 l=0.15 mult=1 sa=0.265
+ sb=0.265 sd=0.28 topography=normal area=0.063 perim=1.14
MI638 db D VPWR VPB pfet_01v8_hvt m=1 w=0.64 l=0.15 mult=1 sa=0.265
+ sb=0.265 sd=0.28 topography=normal area=0.063 perim=1.14
MI634 clkneg GATE VGND VNB nfet_01v8 m=1 w=0.42 l=0.15 mult=1 sa=0.265
+ sb=0.265 sd=0.28 topography=normal area=0.063 perim=1.14
MI649 Q m1 VGND VNB nfet_01v8 m=4 w=0.65 l=0.15 mult=1 sa=0.265
+ sb=0.265 sd=0.28 topography=normal area=0.063 perim=1.14
MI657 net94 RESET_B VGND VNB nfet_01v8 m=1 w=0.65 l=0.15 mult=1
+ sa=0.265 sb=0.265 sd=0.28 topography=normal area=0.063 perim=1.14
MI652 M0 clkneg net102 VNB nfet_01v8 m=1 w=0.36 l=0.15 mult=1 sa=0.265
+ sb=0.265 sd=0.28 topography=normal area=0.063 perim=1.14
MI654 net102 m1 VGND VNB nfet_01v8 m=1 w=0.42 l=0.15 mult=1 sa=0.265
+ sb=0.265 sd=0.28 topography=normal area=0.063 perim=1.14
MI656 m1 M0 net94 VNB nfet_01v8 m=1 w=0.65 l=0.15 mult=1 sa=0.265
+ sb=0.265 sd=0.28 topography=normal area=0.063 perim=1.14
MI636 clkpos clkneg VGND VNB nfet_01v8 m=1 w=0.42 l=0.15 mult=1
+ sa=0.265 sb=0.265 sd=0.28 topography=normal area=0.063 perim=1.14
MI637 db D VGND VNB nfet_01v8 m=1 w=0.42 l=0.15 mult=1 sa=0.265
+ sb=0.265 sd=0.28 topography=normal area=0.063 perim=1.14
MI19 M0 clkpos net82 VNB nfet_01v8 m=1 w=0.36 l=0.15 mult=1 sa=0.265
+ sb=0.265 sd=0.28 topography=normal area=0.063 perim=1.14
MI20 net82 db VGND VNB nfet_01v8 m=1 w=0.42 l=0.15 mult=1 sa=0.265
+ sb=0.265 sd=0.28 topography=normal area=0.063 perim=1.14
.ENDS

.SUBCKT sky130_fd_sc_hd__dlxbn_1 D GATE_N VGND VNB VPB VPWR Q Q_N
MI635 clkneg clkpos VPWR VPB pfet_01v8_hvt m=1 w=0.64 l=0.15 mult=1
+ sa=0.265 sb=0.265 sd=0.28 topography=normal area=0.063 perim=1.14
MI648 Q_N net112 VPWR VPB pfet_01v8_hvt m=1 w=1.0 l=0.15 mult=1
+ sa=0.265 sb=0.265 sd=0.28 topography=normal area=0.063 perim=1.14
MI17 M0 clkneg net56 VPB pfet_01v8_hvt m=1 w=0.42 l=0.15 mult=1
+ sa=0.265 sb=0.265 sd=0.28 topography=normal area=0.063 perim=1.14
MI646 net112 m1 VPWR VPB pfet_01v8_hvt m=1 w=0.64 l=0.15 mult=1
+ sa=0.265 sb=0.265 sd=0.28 topography=normal area=0.063 perim=1.14
MI650 Q m1 VPWR VPB pfet_01v8_hvt m=1 w=1.0 l=0.15 mult=1 sa=0.265
+ sb=0.265 sd=0.28 topography=normal area=0.063 perim=1.14
MI633 clkpos GATE_N VPWR VPB pfet_01v8_hvt m=1 w=0.64 l=0.15 mult=1
+ sa=0.265 sb=0.265 sd=0.28 topography=normal area=0.063 perim=1.14
MI18 net56 db VPWR VPB pfet_01v8_hvt m=1 w=0.64 l=0.15 mult=1 sa=0.265
+ sb=0.265 sd=0.28 topography=normal area=0.063 perim=1.14
MI653 net52 m1 VPWR VPB pfet_01v8_hvt m=1 w=0.42 l=0.15 mult=1
+ sa=0.265 sb=0.265 sd=0.28 topography=normal area=0.063 perim=1.14
MI651 M0 clkpos net52 VPB pfet_01v8_hvt m=1 w=0.42 l=0.15 mult=1
+ sa=0.265 sb=0.265 sd=0.28 topography=normal area=0.063 perim=1.14
MI655 m1 M0 VPWR VPB pfet_01v8_hvt m=1 w=1.0 l=0.15 mult=1 sa=0.265
+ sb=0.265 sd=0.28 topography=normal area=0.063 perim=1.14
MI638 db D VPWR VPB pfet_01v8_hvt m=1 w=0.64 l=0.15 mult=1 sa=0.265
+ sb=0.265 sd=0.28 topography=normal area=0.063 perim=1.14
MI634 clkpos GATE_N VGND VNB nfet_01v8 m=1 w=0.42 l=0.15 mult=1
+ sa=0.265 sb=0.265 sd=0.28 topography=normal area=0.063 perim=1.14
MI647 Q_N net112 VGND VNB nfet_01v8 m=1 w=0.65 l=0.15 mult=1 sa=0.265
+ sb=0.265 sd=0.28 topography=normal area=0.063 perim=1.14
MI649 Q m1 VGND VNB nfet_01v8 m=1 w=0.65 l=0.15 mult=1 sa=0.265
+ sb=0.265 sd=0.28 topography=normal area=0.063 perim=1.14
MI645 net112 m1 VGND VNB nfet_01v8 m=1 w=0.42 l=0.15 mult=1 sa=0.265
+ sb=0.265 sd=0.28 topography=normal area=0.063 perim=1.14
MI652 M0 clkneg net107 VNB nfet_01v8 m=1 w=0.36 l=0.15 mult=1 sa=0.265
+ sb=0.265 sd=0.28 topography=normal area=0.063 perim=1.14
MI654 net107 m1 VGND VNB nfet_01v8 m=1 w=0.42 l=0.15 mult=1 sa=0.265
+ sb=0.265 sd=0.28 topography=normal area=0.063 perim=1.14
MI656 m1 M0 VGND VNB nfet_01v8 m=1 w=0.65 l=0.15 mult=1 sa=0.265
+ sb=0.265 sd=0.28 topography=normal area=0.063 perim=1.14
MI636 clkneg clkpos VGND VNB nfet_01v8 m=1 w=0.42 l=0.15 mult=1
+ sa=0.265 sb=0.265 sd=0.28 topography=normal area=0.063 perim=1.14
MI637 db D VGND VNB nfet_01v8 m=1 w=0.42 l=0.15 mult=1 sa=0.265
+ sb=0.265 sd=0.28 topography=normal area=0.063 perim=1.14
MI19 M0 clkpos net87 VNB nfet_01v8 m=1 w=0.36 l=0.15 mult=1 sa=0.265
+ sb=0.265 sd=0.28 topography=normal area=0.063 perim=1.14
MI20 net87 db VGND VNB nfet_01v8 m=1 w=0.42 l=0.15 mult=1 sa=0.265
+ sb=0.265 sd=0.28 topography=normal area=0.063 perim=1.14
.ENDS

.SUBCKT sky130_fd_sc_hd__dlxbn_2 D GATE_N VGND VNB VPB VPWR Q Q_N
MI635 clkneg clkpos VPWR VPB pfet_01v8_hvt m=1 w=0.64 l=0.15 mult=1
+ sa=0.265 sb=0.265 sd=0.28 topography=normal area=0.063 perim=1.14
MI648 Q_N net114 VPWR VPB pfet_01v8_hvt m=2 w=1.0 l=0.15 mult=1
+ sa=0.265 sb=0.265 sd=0.28 topography=normal area=0.063 perim=1.14
MI17 M0 clkneg net58 VPB pfet_01v8_hvt m=1 w=0.42 l=0.15 mult=1
+ sa=0.265 sb=0.265 sd=0.28 topography=normal area=0.063 perim=1.14
MI646 net114 m1 VPWR VPB pfet_01v8_hvt m=1 w=0.64 l=0.15 mult=1
+ sa=0.265 sb=0.265 sd=0.28 topography=normal area=0.063 perim=1.14
MI650 Q m1 VPWR VPB pfet_01v8_hvt m=2 w=1.0 l=0.15 mult=1 sa=0.265
+ sb=0.265 sd=0.28 topography=normal area=0.063 perim=1.14
MI633 clkpos GATE_N VPWR VPB pfet_01v8_hvt m=1 w=0.64 l=0.15 mult=1
+ sa=0.265 sb=0.265 sd=0.28 topography=normal area=0.063 perim=1.14
MI18 net58 db VPWR VPB pfet_01v8_hvt m=1 w=0.64 l=0.15 mult=1 sa=0.265
+ sb=0.265 sd=0.28 topography=normal area=0.063 perim=1.14
MI653 net54 m1 VPWR VPB pfet_01v8_hvt m=1 w=0.42 l=0.15 mult=1
+ sa=0.265 sb=0.265 sd=0.28 topography=normal area=0.063 perim=1.14
MI651 M0 clkpos net54 VPB pfet_01v8_hvt m=1 w=0.42 l=0.15 mult=1
+ sa=0.265 sb=0.265 sd=0.28 topography=normal area=0.063 perim=1.14
MI655 m1 M0 VPWR VPB pfet_01v8_hvt m=1 w=1.0 l=0.15 mult=1 sa=0.265
+ sb=0.265 sd=0.28 topography=normal area=0.063 perim=1.14
MI638 db D VPWR VPB pfet_01v8_hvt m=1 w=0.64 l=0.15 mult=1 sa=0.265
+ sb=0.265 sd=0.28 topography=normal area=0.063 perim=1.14
MI634 clkpos GATE_N VGND VNB nfet_01v8 m=1 w=0.42 l=0.15 mult=1
+ sa=0.265 sb=0.265 sd=0.28 topography=normal area=0.063 perim=1.14
MI647 Q_N net114 VGND VNB nfet_01v8 m=2 w=0.65 l=0.15 mult=1 sa=0.265
+ sb=0.265 sd=0.28 topography=normal area=0.063 perim=1.14
MI649 Q m1 VGND VNB nfet_01v8 m=2 w=0.65 l=0.15 mult=1 sa=0.265
+ sb=0.265 sd=0.28 topography=normal area=0.063 perim=1.14
MI645 net114 m1 VGND VNB nfet_01v8 m=1 w=0.42 l=0.15 mult=1 sa=0.265
+ sb=0.265 sd=0.28 topography=normal area=0.063 perim=1.14
MI652 M0 clkneg net109 VNB nfet_01v8 m=1 w=0.36 l=0.15 mult=1 sa=0.265
+ sb=0.265 sd=0.28 topography=normal area=0.063 perim=1.14
MI654 net109 m1 VGND VNB nfet_01v8 m=1 w=0.42 l=0.15 mult=1 sa=0.265
+ sb=0.265 sd=0.28 topography=normal area=0.063 perim=1.14
MI656 m1 M0 VGND VNB nfet_01v8 m=1 w=0.65 l=0.15 mult=1 sa=0.265
+ sb=0.265 sd=0.28 topography=normal area=0.063 perim=1.14
MI636 clkneg clkpos VGND VNB nfet_01v8 m=1 w=0.42 l=0.15 mult=1
+ sa=0.265 sb=0.265 sd=0.28 topography=normal area=0.063 perim=1.14
MI637 db D VGND VNB nfet_01v8 m=1 w=0.42 l=0.15 mult=1 sa=0.265
+ sb=0.265 sd=0.28 topography=normal area=0.063 perim=1.14
MI19 M0 clkpos net89 VNB nfet_01v8 m=1 w=0.36 l=0.15 mult=1 sa=0.265
+ sb=0.265 sd=0.28 topography=normal area=0.063 perim=1.14
MI20 net89 db VGND VNB nfet_01v8 m=1 w=0.42 l=0.15 mult=1 sa=0.265
+ sb=0.265 sd=0.28 topography=normal area=0.063 perim=1.14
.ENDS

.SUBCKT sky130_fd_sc_hd__dlxbp_1 D GATE VGND VNB VPB VPWR Q Q_N
MI635 clkpos clkneg VPWR VPB pfet_01v8_hvt m=1 w=0.64 l=0.15 mult=1
+ sa=0.265 sb=0.265 sd=0.28 topography=normal area=0.063 perim=1.14
MI648 Q_N net114 VPWR VPB pfet_01v8_hvt m=1 w=1.0 l=0.15 mult=1
+ sa=0.265 sb=0.265 sd=0.28 topography=normal area=0.063 perim=1.14
MI17 M0 clkneg net58 VPB pfet_01v8_hvt m=1 w=0.42 l=0.15 mult=1
+ sa=0.265 sb=0.265 sd=0.28 topography=normal area=0.063 perim=1.14
MI646 net114 m1 VPWR VPB pfet_01v8_hvt m=1 w=0.64 l=0.15 mult=1
+ sa=0.265 sb=0.265 sd=0.28 topography=normal area=0.063 perim=1.14
MI650 Q m1 VPWR VPB pfet_01v8_hvt m=1 w=1.0 l=0.15 mult=1 sa=0.265
+ sb=0.265 sd=0.28 topography=normal area=0.063 perim=1.14
MI633 clkneg GATE VPWR VPB pfet_01v8_hvt m=1 w=0.64 l=0.15 mult=1
+ sa=0.265 sb=0.265 sd=0.28 topography=normal area=0.063 perim=1.14
MI18 net58 db VPWR VPB pfet_01v8_hvt m=1 w=0.64 l=0.15 mult=1 sa=0.265
+ sb=0.265 sd=0.28 topography=normal area=0.063 perim=1.14
MI653 net54 m1 VPWR VPB pfet_01v8_hvt m=1 w=0.42 l=0.15 mult=1
+ sa=0.265 sb=0.265 sd=0.28 topography=normal area=0.063 perim=1.14
MI651 M0 clkpos net54 VPB pfet_01v8_hvt m=1 w=0.42 l=0.15 mult=1
+ sa=0.265 sb=0.265 sd=0.28 topography=normal area=0.063 perim=1.14
MI655 m1 M0 VPWR VPB pfet_01v8_hvt m=1 w=1.0 l=0.15 mult=1 sa=0.265
+ sb=0.265 sd=0.28 topography=normal area=0.063 perim=1.14
MI638 db D VPWR VPB pfet_01v8_hvt m=1 w=0.64 l=0.15 mult=1 sa=0.265
+ sb=0.265 sd=0.28 topography=normal area=0.063 perim=1.14
MI634 clkneg GATE VGND VNB nfet_01v8 m=1 w=0.42 l=0.15 mult=1 sa=0.265
+ sb=0.265 sd=0.28 topography=normal area=0.063 perim=1.14
MI647 Q_N net114 VGND VNB nfet_01v8 m=1 w=0.65 l=0.15 mult=1 sa=0.265
+ sb=0.265 sd=0.28 topography=normal area=0.063 perim=1.14
MI649 Q m1 VGND VNB nfet_01v8 m=1 w=0.65 l=0.15 mult=1 sa=0.265
+ sb=0.265 sd=0.28 topography=normal area=0.063 perim=1.14
MI645 net114 m1 VGND VNB nfet_01v8 m=1 w=0.42 l=0.15 mult=1 sa=0.265
+ sb=0.265 sd=0.28 topography=normal area=0.063 perim=1.14
MI652 M0 clkneg net109 VNB nfet_01v8 m=1 w=0.36 l=0.15 mult=1 sa=0.265
+ sb=0.265 sd=0.28 topography=normal area=0.063 perim=1.14
MI654 net109 m1 VGND VNB nfet_01v8 m=1 w=0.42 l=0.15 mult=1 sa=0.265
+ sb=0.265 sd=0.28 topography=normal area=0.063 perim=1.14
MI656 m1 M0 VGND VNB nfet_01v8 m=1 w=0.65 l=0.15 mult=1 sa=0.265
+ sb=0.265 sd=0.28 topography=normal area=0.063 perim=1.14
MI636 clkpos clkneg VGND VNB nfet_01v8 m=1 w=0.42 l=0.15 mult=1
+ sa=0.265 sb=0.265 sd=0.28 topography=normal area=0.063 perim=1.14
MI637 db D VGND VNB nfet_01v8 m=1 w=0.42 l=0.15 mult=1 sa=0.265
+ sb=0.265 sd=0.28 topography=normal area=0.063 perim=1.14
MI19 M0 clkpos net89 VNB nfet_01v8 m=1 w=0.36 l=0.15 mult=1 sa=0.265
+ sb=0.265 sd=0.28 topography=normal area=0.063 perim=1.14
MI20 net89 db VGND VNB nfet_01v8 m=1 w=0.42 l=0.15 mult=1 sa=0.265
+ sb=0.265 sd=0.28 topography=normal area=0.063 perim=1.14
.ENDS

.SUBCKT sky130_fd_sc_hd__dlxtn_1 D GATE_N VGND VNB VPB VPWR Q
MI635 clkneg clkpos VPWR VPB pfet_01v8_hvt m=1 w=0.64 l=0.15 mult=1
+ sa=0.265 sb=0.265 sd=0.28 topography=normal area=0.063 perim=1.14
MI17 M0 clkneg net53 VPB pfet_01v8_hvt m=1 w=0.42 l=0.15 mult=1
+ sa=0.265 sb=0.265 sd=0.28 topography=normal area=0.063 perim=1.14
MI650 Q m1 VPWR VPB pfet_01v8_hvt m=1 w=1.0 l=0.15 mult=1 sa=0.265
+ sb=0.265 sd=0.28 topography=normal area=0.063 perim=1.14
MI633 clkpos GATE_N VPWR VPB pfet_01v8_hvt m=1 w=0.64 l=0.15 mult=1
+ sa=0.265 sb=0.265 sd=0.28 topography=normal area=0.063 perim=1.14
MI18 net53 db VPWR VPB pfet_01v8_hvt m=1 w=0.64 l=0.15 mult=1 sa=0.265
+ sb=0.265 sd=0.28 topography=normal area=0.063 perim=1.14
MI653 net44 m1 VPWR VPB pfet_01v8_hvt m=1 w=0.42 l=0.15 mult=1
+ sa=0.265 sb=0.265 sd=0.28 topography=normal area=0.063 perim=1.14
MI651 M0 clkpos net44 VPB pfet_01v8_hvt m=1 w=0.42 l=0.15 mult=1
+ sa=0.265 sb=0.265 sd=0.28 topography=normal area=0.063 perim=1.14
MI655 m1 M0 VPWR VPB pfet_01v8_hvt m=1 w=1.0 l=0.15 mult=1 sa=0.265
+ sb=0.265 sd=0.28 topography=normal area=0.063 perim=1.14
MI638 db D VPWR VPB pfet_01v8_hvt m=1 w=0.64 l=0.15 mult=1 sa=0.265
+ sb=0.265 sd=0.28 topography=normal area=0.063 perim=1.14
MI634 clkpos GATE_N VGND VNB nfet_01v8 m=1 w=0.42 l=0.15 mult=1
+ sa=0.265 sb=0.265 sd=0.28 topography=normal area=0.063 perim=1.14
MI649 Q m1 VGND VNB nfet_01v8 m=1 w=0.65 l=0.15 mult=1 sa=0.265
+ sb=0.265 sd=0.28 topography=normal area=0.063 perim=1.14
MI652 M0 clkneg net96 VNB nfet_01v8 m=1 w=0.36 l=0.15 mult=1 sa=0.265
+ sb=0.265 sd=0.28 topography=normal area=0.063 perim=1.14
MI654 net96 m1 VGND VNB nfet_01v8 m=1 w=0.42 l=0.15 mult=1 sa=0.265
+ sb=0.265 sd=0.28 topography=normal area=0.063 perim=1.14
MI656 m1 M0 VGND VNB nfet_01v8 m=1 w=0.65 l=0.15 mult=1 sa=0.265
+ sb=0.265 sd=0.28 topography=normal area=0.063 perim=1.14
MI636 clkneg clkpos VGND VNB nfet_01v8 m=1 w=0.42 l=0.15 mult=1
+ sa=0.265 sb=0.265 sd=0.28 topography=normal area=0.063 perim=1.14
MI637 db D VGND VNB nfet_01v8 m=1 w=0.42 l=0.15 mult=1 sa=0.265
+ sb=0.265 sd=0.28 topography=normal area=0.063 perim=1.14
MI19 M0 clkpos net76 VNB nfet_01v8 m=1 w=0.36 l=0.15 mult=1 sa=0.265
+ sb=0.265 sd=0.28 topography=normal area=0.063 perim=1.14
MI20 net76 db VGND VNB nfet_01v8 m=1 w=0.42 l=0.15 mult=1 sa=0.265
+ sb=0.265 sd=0.28 topography=normal area=0.063 perim=1.14
.ENDS

.SUBCKT sky130_fd_sc_hd__dlxtn_2 D GATE_N VGND VNB VPB VPWR Q
MI635 clkneg clkpos VPWR VPB pfet_01v8_hvt m=1 w=0.64 l=0.15 mult=1
+ sa=0.265 sb=0.265 sd=0.28 topography=normal area=0.063 perim=1.14
MI17 M0 clkneg net51 VPB pfet_01v8_hvt m=1 w=0.42 l=0.15 mult=1
+ sa=0.265 sb=0.265 sd=0.28 topography=normal area=0.063 perim=1.14
MI650 Q m1 VPWR VPB pfet_01v8_hvt m=2 w=1.0 l=0.15 mult=1 sa=0.265
+ sb=0.265 sd=0.28 topography=normal area=0.063 perim=1.14
MI633 clkpos GATE_N VPWR VPB pfet_01v8_hvt m=1 w=0.64 l=0.15 mult=1
+ sa=0.265 sb=0.265 sd=0.28 topography=normal area=0.063 perim=1.14
MI18 net51 db VPWR VPB pfet_01v8_hvt m=1 w=0.64 l=0.15 mult=1 sa=0.265
+ sb=0.265 sd=0.28 topography=normal area=0.063 perim=1.14
MI653 net47 m1 VPWR VPB pfet_01v8_hvt m=1 w=0.42 l=0.15 mult=1
+ sa=0.265 sb=0.265 sd=0.28 topography=normal area=0.063 perim=1.14
MI651 M0 clkpos net47 VPB pfet_01v8_hvt m=1 w=0.42 l=0.15 mult=1
+ sa=0.265 sb=0.265 sd=0.28 topography=normal area=0.063 perim=1.14
MI655 m1 M0 VPWR VPB pfet_01v8_hvt m=1 w=1.0 l=0.15 mult=1 sa=0.265
+ sb=0.265 sd=0.28 topography=normal area=0.063 perim=1.14
MI638 db D VPWR VPB pfet_01v8_hvt m=1 w=0.64 l=0.15 mult=1 sa=0.265
+ sb=0.265 sd=0.28 topography=normal area=0.063 perim=1.14
MI634 clkpos GATE_N VGND VNB nfet_01v8 m=1 w=0.42 l=0.15 mult=1
+ sa=0.265 sb=0.265 sd=0.28 topography=normal area=0.063 perim=1.14
MI649 Q m1 VGND VNB nfet_01v8 m=2 w=0.65 l=0.15 mult=1 sa=0.265
+ sb=0.265 sd=0.28 topography=normal area=0.063 perim=1.14
MI652 M0 clkneg net94 VNB nfet_01v8 m=1 w=0.36 l=0.15 mult=1 sa=0.265
+ sb=0.265 sd=0.28 topography=normal area=0.063 perim=1.14
MI654 net94 m1 VGND VNB nfet_01v8 m=1 w=0.42 l=0.15 mult=1 sa=0.265
+ sb=0.265 sd=0.28 topography=normal area=0.063 perim=1.14
MI656 m1 M0 VGND VNB nfet_01v8 m=1 w=0.65 l=0.15 mult=1 sa=0.265
+ sb=0.265 sd=0.28 topography=normal area=0.063 perim=1.14
MI636 clkneg clkpos VGND VNB nfet_01v8 m=1 w=0.42 l=0.15 mult=1
+ sa=0.265 sb=0.265 sd=0.28 topography=normal area=0.063 perim=1.14
MI637 db D VGND VNB nfet_01v8 m=1 w=0.42 l=0.15 mult=1 sa=0.265
+ sb=0.265 sd=0.28 topography=normal area=0.063 perim=1.14
MI19 M0 clkpos net74 VNB nfet_01v8 m=1 w=0.36 l=0.15 mult=1 sa=0.265
+ sb=0.265 sd=0.28 topography=normal area=0.063 perim=1.14
MI20 net74 db VGND VNB nfet_01v8 m=1 w=0.42 l=0.15 mult=1 sa=0.265
+ sb=0.265 sd=0.28 topography=normal area=0.063 perim=1.14
.ENDS

.SUBCKT sky130_fd_sc_hd__dlxtn_4 D GATE_N VGND VNB VPB VPWR Q
MI635 clkneg clkpos VPWR VPB pfet_01v8_hvt m=1 w=0.64 l=0.15 mult=1
+ sa=0.265 sb=0.265 sd=0.28 topography=normal area=0.063 perim=1.14
MI17 M0 clkneg net51 VPB pfet_01v8_hvt m=1 w=0.42 l=0.15 mult=1
+ sa=0.265 sb=0.265 sd=0.28 topography=normal area=0.063 perim=1.14
MI650 Q m1 VPWR VPB pfet_01v8_hvt m=4 w=1.0 l=0.15 mult=1 sa=0.265
+ sb=0.265 sd=0.28 topography=normal area=0.063 perim=1.14
MI633 clkpos GATE_N VPWR VPB pfet_01v8_hvt m=1 w=0.64 l=0.15 mult=1
+ sa=0.265 sb=0.265 sd=0.28 topography=normal area=0.063 perim=1.14
MI18 net51 db VPWR VPB pfet_01v8_hvt m=1 w=0.64 l=0.15 mult=1 sa=0.265
+ sb=0.265 sd=0.28 topography=normal area=0.063 perim=1.14
MI653 net47 m1 VPWR VPB pfet_01v8_hvt m=1 w=0.42 l=0.15 mult=1
+ sa=0.265 sb=0.265 sd=0.28 topography=normal area=0.063 perim=1.14
MI651 M0 clkpos net47 VPB pfet_01v8_hvt m=1 w=0.42 l=0.15 mult=1
+ sa=0.265 sb=0.265 sd=0.28 topography=normal area=0.063 perim=1.14
MI655 m1 M0 VPWR VPB pfet_01v8_hvt m=1 w=1.0 l=0.15 mult=1 sa=0.265
+ sb=0.265 sd=0.28 topography=normal area=0.063 perim=1.14
MI638 db D VPWR VPB pfet_01v8_hvt m=1 w=0.64 l=0.15 mult=1 sa=0.265
+ sb=0.265 sd=0.28 topography=normal area=0.063 perim=1.14
MI634 clkpos GATE_N VGND VNB nfet_01v8 m=1 w=0.42 l=0.15 mult=1
+ sa=0.265 sb=0.265 sd=0.28 topography=normal area=0.063 perim=1.14
MI649 Q m1 VGND VNB nfet_01v8 m=4 w=0.65 l=0.15 mult=1 sa=0.265
+ sb=0.265 sd=0.28 topography=normal area=0.063 perim=1.14
MI652 M0 clkneg net94 VNB nfet_01v8 m=1 w=0.36 l=0.15 mult=1 sa=0.265
+ sb=0.265 sd=0.28 topography=normal area=0.063 perim=1.14
MI654 net94 m1 VGND VNB nfet_01v8 m=1 w=0.42 l=0.15 mult=1 sa=0.265
+ sb=0.265 sd=0.28 topography=normal area=0.063 perim=1.14
MI656 m1 M0 VGND VNB nfet_01v8 m=1 w=0.65 l=0.15 mult=1 sa=0.265
+ sb=0.265 sd=0.28 topography=normal area=0.063 perim=1.14
MI636 clkneg clkpos VGND VNB nfet_01v8 m=1 w=0.42 l=0.15 mult=1
+ sa=0.265 sb=0.265 sd=0.28 topography=normal area=0.063 perim=1.14
MI637 db D VGND VNB nfet_01v8 m=1 w=0.42 l=0.15 mult=1 sa=0.265
+ sb=0.265 sd=0.28 topography=normal area=0.063 perim=1.14
MI19 M0 clkpos net74 VNB nfet_01v8 m=1 w=0.36 l=0.15 mult=1 sa=0.265
+ sb=0.265 sd=0.28 topography=normal area=0.063 perim=1.14
MI20 net74 db VGND VNB nfet_01v8 m=1 w=0.42 l=0.15 mult=1 sa=0.265
+ sb=0.265 sd=0.28 topography=normal area=0.063 perim=1.14
.ENDS

.SUBCKT sky130_fd_sc_hd__dlxtp_1 D GATE VGND VNB VPB VPWR Q
MI635 clkpos clkneg VPWR VPB pfet_01v8_hvt m=1 w=0.64 l=0.15 mult=1
+ sa=0.265 sb=0.265 sd=0.28 topography=normal area=0.063 perim=1.14
MI17 M0 clkneg net51 VPB pfet_01v8_hvt m=1 w=0.42 l=0.15 mult=1
+ sa=0.265 sb=0.265 sd=0.28 topography=normal area=0.063 perim=1.14
MI650 Q m1 VPWR VPB pfet_01v8_hvt m=1 w=1.0 l=0.15 mult=1 sa=0.265
+ sb=0.265 sd=0.28 topography=normal area=0.063 perim=1.14
MI633 clkneg GATE VPWR VPB pfet_01v8_hvt m=1 w=0.64 l=0.15 mult=1
+ sa=0.265 sb=0.265 sd=0.28 topography=normal area=0.063 perim=1.14
MI18 net51 db VPWR VPB pfet_01v8_hvt m=1 w=0.64 l=0.15 mult=1 sa=0.265
+ sb=0.265 sd=0.28 topography=normal area=0.063 perim=1.14
MI653 net47 m1 VPWR VPB pfet_01v8_hvt m=1 w=0.42 l=0.15 mult=1
+ sa=0.265 sb=0.265 sd=0.28 topography=normal area=0.063 perim=1.14
MI651 M0 clkpos net47 VPB pfet_01v8_hvt m=1 w=0.42 l=0.15 mult=1
+ sa=0.265 sb=0.265 sd=0.28 topography=normal area=0.063 perim=1.14
MI655 m1 M0 VPWR VPB pfet_01v8_hvt m=1 w=1.0 l=0.15 mult=1 sa=0.265
+ sb=0.265 sd=0.28 topography=normal area=0.063 perim=1.14
MI638 db D VPWR VPB pfet_01v8_hvt m=1 w=0.64 l=0.15 mult=1 sa=0.265
+ sb=0.265 sd=0.28 topography=normal area=0.063 perim=1.14
MI634 clkneg GATE VGND VNB nfet_01v8 m=1 w=0.42 l=0.15 mult=1 sa=0.265
+ sb=0.265 sd=0.28 topography=normal area=0.063 perim=1.14
MI649 Q m1 VGND VNB nfet_01v8 m=1 w=0.65 l=0.15 mult=1 sa=0.265
+ sb=0.265 sd=0.28 topography=normal area=0.063 perim=1.14
MI652 M0 clkneg net94 VNB nfet_01v8 m=1 w=0.36 l=0.15 mult=1 sa=0.265
+ sb=0.265 sd=0.28 topography=normal area=0.063 perim=1.14
MI654 net94 m1 VGND VNB nfet_01v8 m=1 w=0.36 l=0.15 mult=1 sa=0.265
+ sb=0.265 sd=0.28 topography=normal area=0.063 perim=1.14
MI656 m1 M0 VGND VNB nfet_01v8 m=1 w=0.65 l=0.15 mult=1 sa=0.265
+ sb=0.265 sd=0.28 topography=normal area=0.063 perim=1.14
MI636 clkpos clkneg VGND VNB nfet_01v8 m=1 w=0.42 l=0.15 mult=1
+ sa=0.265 sb=0.265 sd=0.28 topography=normal area=0.063 perim=1.14
MI637 db D VGND VNB nfet_01v8 m=1 w=0.42 l=0.15 mult=1 sa=0.265
+ sb=0.265 sd=0.28 topography=normal area=0.063 perim=1.14
MI19 M0 clkpos net74 VNB nfet_01v8 m=1 w=0.36 l=0.15 mult=1 sa=0.265
+ sb=0.265 sd=0.28 topography=normal area=0.063 perim=1.14
MI20 net74 db VGND VNB nfet_01v8 m=1 w=0.42 l=0.15 mult=1 sa=0.265
+ sb=0.265 sd=0.28 topography=normal area=0.063 perim=1.14
.ENDS

.SUBCKT sky130_fd_sc_hd__dlygate4sd1_1 A VGND VNB VPB VPWR X
MMIN1 Ab net34 VGND VNB nfet_01v8 m=1 w=0.42 l=0.15 mult=1 sa=0.265
+ sb=0.265 sd=0.28 topography=normal area=0.063 perim=1.14
MMIN2 X Ab VGND VNB nfet_01v8 m=1 w=0.65 l=0.15 mult=1 sa=0.265
+ sb=0.265 sd=0.28 topography=normal area=0.063 perim=1.14
MI6 net34 net30 VGND VNB nfet_01v8 m=1 w=0.42 l=0.15 mult=1 sa=0.265
+ sb=0.265 sd=0.28 topography=normal area=0.063 perim=1.14
MI9 net30 A VGND VNB nfet_01v8 m=1 w=0.42 l=0.15 mult=1 sa=0.265
+ sb=0.265 sd=0.28 topography=normal area=0.063 perim=1.14
MMIP1 Ab net34 VPWR VPB pfet_01v8_hvt m=1 w=0.42 l=0.15 mult=1
+ sa=0.265 sb=0.265 sd=0.28 topography=normal area=0.063 perim=1.14
MMIP2 X Ab VPWR VPB pfet_01v8_hvt m=1 w=1.0 l=0.15 mult=1 sa=0.265
+ sb=0.265 sd=0.28 topography=normal area=0.063 perim=1.14
MI7 net34 net30 VPWR VPB pfet_01v8_hvt m=1 w=0.42 l=0.15 mult=1
+ sa=0.265 sb=0.265 sd=0.28 topography=normal area=0.063 perim=1.14
MI8 net30 A VPWR VPB pfet_01v8_hvt m=1 w=0.42 l=0.15 mult=1 sa=0.265
+ sb=0.265 sd=0.28 topography=normal area=0.063 perim=1.14
.ENDS

.SUBCKT sky130_fd_sc_hd__dlygate4sd2_1 A VGND VNB VPB VPWR X
MMIN1 Ab net34 VGND VNB nfet_01v8 m=1 w=0.42 l=0.18 mult=1 sa=0.265
+ sb=0.265 sd=0.28 topography=normal area=0.063 perim=1.14
MMIN2 X Ab VGND VNB nfet_01v8 m=1 w=0.65 l=0.15 mult=1 sa=0.265
+ sb=0.265 sd=0.28 topography=normal area=0.063 perim=1.14
MI6 net34 net30 VGND VNB nfet_01v8 m=1 w=0.42 l=0.18 mult=1 sa=0.265
+ sb=0.265 sd=0.28 topography=normal area=0.063 perim=1.14
MI9 net30 A VGND VNB nfet_01v8 m=1 w=0.42 l=0.15 mult=1 sa=0.265
+ sb=0.265 sd=0.28 topography=normal area=0.063 perim=1.14
MMIP1 Ab net34 VPWR VPB pfet_01v8_hvt m=1 w=0.42 l=0.18 mult=1
+ sa=0.265 sb=0.265 sd=0.28 topography=normal area=0.063 perim=1.14
MMIP2 X Ab VPWR VPB pfet_01v8_hvt m=1 w=1.0 l=0.15 mult=1 sa=0.265
+ sb=0.265 sd=0.28 topography=normal area=0.063 perim=1.14
MI7 net34 net30 VPWR VPB pfet_01v8_hvt m=1 w=0.42 l=0.18 mult=1
+ sa=0.265 sb=0.265 sd=0.28 topography=normal area=0.063 perim=1.14
MI8 net30 A VPWR VPB pfet_01v8_hvt m=1 w=0.42 l=0.15 mult=1 sa=0.265
+ sb=0.265 sd=0.28 topography=normal area=0.063 perim=1.14
.ENDS

.SUBCKT sky130_fd_sc_hd__dlygate4sd3_1 A VGND VNB VPB VPWR X
MMIN1 Ab net34 VGND VNB nfet_01v8 m=1 w=0.42 l=0.5 mult=1 sa=0.265
+ sb=0.265 sd=0.28 topography=normal area=0.063 perim=1.14
MMIN2 X Ab VGND VNB nfet_01v8 m=1 w=0.65 l=0.15 mult=1 sa=0.265
+ sb=0.265 sd=0.28 topography=normal area=0.063 perim=1.14
MI6 net34 net30 VGND VNB nfet_01v8 m=1 w=0.42 l=0.5 mult=1 sa=0.265
+ sb=0.265 sd=0.28 topography=normal area=0.063 perim=1.14
MI9 net30 A VGND VNB nfet_01v8 m=1 w=0.42 l=0.15 mult=1 sa=0.265
+ sb=0.265 sd=0.28 topography=normal area=0.063 perim=1.14
MMIP1 Ab net34 VPWR VPB pfet_01v8_hvt m=1 w=0.42 l=0.5 mult=1 sa=0.265
+ sb=0.265 sd=0.28 topography=normal area=0.063 perim=1.14
MMIP2 X Ab VPWR VPB pfet_01v8_hvt m=1 w=1.0 l=0.15 mult=1 sa=0.265
+ sb=0.265 sd=0.28 topography=normal area=0.063 perim=1.14
MI7 net34 net30 VPWR VPB pfet_01v8_hvt m=1 w=0.42 l=0.5 mult=1
+ sa=0.265 sb=0.265 sd=0.28 topography=normal area=0.063 perim=1.14
MI8 net30 A VPWR VPB pfet_01v8_hvt m=1 w=0.42 l=0.15 mult=1 sa=0.265
+ sb=0.265 sd=0.28 topography=normal area=0.063 perim=1.14
.ENDS

.SUBCKT sky130_fd_sc_hd__dlymetal6s2s_1 A VGND VNB VPB VPWR X
MMIN1 Ab net55 VGND VNB nfet_01v8 m=1 w=0.42 l=0.15 mult=1 sa=0.265
+ sb=0.265 sd=0.28 topography=normal area=0.063 perim=1.14
MMIN2 net59 Ab VGND VNB nfet_01v8 m=1 w=0.65 l=0.15 mult=1 sa=0.265
+ sb=0.265 sd=0.28 topography=normal area=0.063 perim=1.14
MI6 net55 net47 VGND VNB nfet_01v8 m=1 w=0.65 l=0.15 mult=1 sa=0.265
+ sb=0.265 sd=0.28 topography=normal area=0.063 perim=1.14
MI15 net51 A VGND VNB nfet_01v8 m=1 w=0.42 l=0.15 mult=1 sa=0.265
+ sb=0.265 sd=0.28 topography=normal area=0.063 perim=1.14
MI9 net47 X VGND VNB nfet_01v8 m=1 w=0.42 l=0.15 mult=1 sa=0.265
+ sb=0.265 sd=0.28 topography=normal area=0.063 perim=1.14
MI16 X net51 VGND VNB nfet_01v8 m=1 w=0.65 l=0.15 mult=1 sa=0.265
+ sb=0.265 sd=0.28 topography=normal area=0.063 perim=1.14
MMIP1 Ab net55 VPWR VPB pfet_01v8_hvt m=1 w=0.42 l=0.15 mult=1
+ sa=0.265 sb=0.265 sd=0.28 topography=normal area=0.063 perim=1.14
MMIP2 net59 Ab VPWR VPB pfet_01v8_hvt m=1 w=1.0 l=0.15 mult=1 sa=0.265
+ sb=0.265 sd=0.28 topography=normal area=0.063 perim=1.14
MI7 net55 net47 VPWR VPB pfet_01v8_hvt m=1 w=1.0 l=0.15 mult=1
+ sa=0.265 sb=0.265 sd=0.28 topography=normal area=0.063 perim=1.14
MI8 net47 X VPWR VPB pfet_01v8_hvt m=1 w=0.42 l=0.15 mult=1 sa=0.265
+ sb=0.265 sd=0.28 topography=normal area=0.063 perim=1.14
MI18 X net51 VPWR VPB pfet_01v8_hvt m=1 w=1.0 l=0.15 mult=1 sa=0.265
+ sb=0.265 sd=0.28 topography=normal area=0.063 perim=1.14
MI17 net51 A VPWR VPB pfet_01v8_hvt m=1 w=0.42 l=0.15 mult=1 sa=0.265
+ sb=0.265 sd=0.28 topography=normal area=0.063 perim=1.14
.ENDS

.SUBCKT sky130_fd_sc_hd__dlymetal6s4s_1 A VGND VNB VPB VPWR X
MMIN1 Ab X VGND VNB nfet_01v8 m=1 w=0.42 l=0.15 mult=1 sa=0.265
+ sb=0.265 sd=0.28 topography=normal area=0.063 perim=1.14
MMIN2 net59 Ab VGND VNB nfet_01v8 m=1 w=0.65 l=0.15 mult=1 sa=0.265
+ sb=0.265 sd=0.28 topography=normal area=0.063 perim=1.14
MI6 X net47 VGND VNB nfet_01v8 m=1 w=0.65 l=0.15 mult=1 sa=0.265
+ sb=0.265 sd=0.28 topography=normal area=0.063 perim=1.14
MI15 net51 A VGND VNB nfet_01v8 m=1 w=0.42 l=0.15 mult=1 sa=0.265
+ sb=0.265 sd=0.28 topography=normal area=0.063 perim=1.14
MI9 net47 net43 VGND VNB nfet_01v8 m=1 w=0.42 l=0.15 mult=1 sa=0.265
+ sb=0.265 sd=0.28 topography=normal area=0.063 perim=1.14
MI16 net43 net51 VGND VNB nfet_01v8 m=1 w=0.65 l=0.15 mult=1 sa=0.265
+ sb=0.265 sd=0.28 topography=normal area=0.063 perim=1.14
MMIP1 Ab X VPWR VPB pfet_01v8_hvt m=1 w=0.42 l=0.15 mult=1 sa=0.265
+ sb=0.265 sd=0.28 topography=normal area=0.063 perim=1.14
MMIP2 net59 Ab VPWR VPB pfet_01v8_hvt m=1 w=1.0 l=0.15 mult=1 sa=0.265
+ sb=0.265 sd=0.28 topography=normal area=0.063 perim=1.14
MI7 X net47 VPWR VPB pfet_01v8_hvt m=1 w=1.0 l=0.15 mult=1 sa=0.265
+ sb=0.265 sd=0.28 topography=normal area=0.063 perim=1.14
MI8 net47 net43 VPWR VPB pfet_01v8_hvt m=1 w=0.42 l=0.15 mult=1
+ sa=0.265 sb=0.265 sd=0.28 topography=normal area=0.063 perim=1.14
MI18 net43 net51 VPWR VPB pfet_01v8_hvt m=1 w=1.0 l=0.15 mult=1
+ sa=0.265 sb=0.265 sd=0.28 topography=normal area=0.063 perim=1.14
MI17 net51 A VPWR VPB pfet_01v8_hvt m=1 w=0.42 l=0.15 mult=1 sa=0.265
+ sb=0.265 sd=0.28 topography=normal area=0.063 perim=1.14
.ENDS

.SUBCKT sky130_fd_sc_hd__dlymetal6s6s_1 A VGND VNB VPB VPWR X
MMIN1 Ab net56 VGND VNB nfet_01v8 m=1 w=0.42 l=0.15 mult=1 sa=0.265
+ sb=0.265 sd=0.28 topography=normal area=0.063 perim=1.14
MMIN2 X Ab VGND VNB nfet_01v8 m=1 w=0.65 l=0.15 mult=1 sa=0.265
+ sb=0.265 sd=0.28 topography=normal area=0.063 perim=1.14
MI6 net56 net48 VGND VNB nfet_01v8 m=1 w=0.65 l=0.15 mult=1 sa=0.265
+ sb=0.265 sd=0.28 topography=normal area=0.063 perim=1.14
MI15 net52 A VGND VNB nfet_01v8 m=1 w=0.42 l=0.15 mult=1 sa=0.265
+ sb=0.265 sd=0.28 topography=normal area=0.063 perim=1.14
MI9 net48 net44 VGND VNB nfet_01v8 m=1 w=0.42 l=0.15 mult=1 sa=0.265
+ sb=0.265 sd=0.28 topography=normal area=0.063 perim=1.14
MI16 net44 net52 VGND VNB nfet_01v8 m=1 w=0.65 l=0.15 mult=1 sa=0.265
+ sb=0.265 sd=0.28 topography=normal area=0.063 perim=1.14
MMIP1 Ab net56 VPWR VPB pfet_01v8_hvt m=1 w=0.42 l=0.15 mult=1
+ sa=0.265 sb=0.265 sd=0.28 topography=normal area=0.063 perim=1.14
MMIP2 X Ab VPWR VPB pfet_01v8_hvt m=1 w=1.0 l=0.15 mult=1 sa=0.265
+ sb=0.265 sd=0.28 topography=normal area=0.063 perim=1.14
MI7 net56 net48 VPWR VPB pfet_01v8_hvt m=1 w=1.0 l=0.15 mult=1
+ sa=0.265 sb=0.265 sd=0.28 topography=normal area=0.063 perim=1.14
MI8 net48 net44 VPWR VPB pfet_01v8_hvt m=1 w=0.42 l=0.15 mult=1
+ sa=0.265 sb=0.265 sd=0.28 topography=normal area=0.063 perim=1.14
MI18 net44 net52 VPWR VPB pfet_01v8_hvt m=1 w=1.0 l=0.15 mult=1
+ sa=0.265 sb=0.265 sd=0.28 topography=normal area=0.063 perim=1.14
MI17 net52 A VPWR VPB pfet_01v8_hvt m=1 w=0.42 l=0.15 mult=1 sa=0.265
+ sb=0.265 sd=0.28 topography=normal area=0.063 perim=1.14
.ENDS

.SUBCKT sky130_fd_sc_hd__ebufn_1 A TE_B VGND VNB VPB VPWR Z
MMN0 Z net35 sndA VNB nfet_01v8 m=1 w=0.65 l=0.15 mult=1 sa=0.265
+ sb=0.265 sd=0.28 topography=normal area=0.063 perim=1.14
MMN1 sndA net39 VGND VNB nfet_01v8 m=1 w=0.65 l=0.15 mult=1 sa=0.265
+ sb=0.265 sd=0.28 topography=normal area=0.063 perim=1.14
MMIN1 net39 TE_B VGND VNB nfet_01v8 m=1 w=0.42 l=0.15 mult=1 sa=0.265
+ sb=0.265 sd=0.28 topography=normal area=0.063 perim=1.14
MI6 net35 A VGND VNB nfet_01v8 m=1 w=0.42 l=0.15 mult=1 sa=0.265
+ sb=0.265 sd=0.28 topography=normal area=0.063 perim=1.14
MMP0 VPWR TE_B sndTEB VPB pfet_01v8_hvt m=1 w=1.0 l=0.15 mult=1
+ sa=0.265 sb=0.265 sd=0.28 topography=normal area=0.063 perim=1.14
MMP1 sndTEB net35 Z VPB pfet_01v8_hvt m=1 w=1.0 l=0.15 mult=1 sa=0.265
+ sb=0.265 sd=0.28 topography=normal area=0.063 perim=1.14
MMIP1 net39 TE_B VPWR VPB pfet_01v8_hvt m=1 w=0.64 l=0.15 mult=1
+ sa=0.265 sb=0.265 sd=0.28 topography=normal area=0.063 perim=1.14
MI5 net35 A VPWR VPB pfet_01v8_hvt m=1 w=0.64 l=0.15 mult=1 sa=0.265
+ sb=0.265 sd=0.28 topography=normal area=0.063 perim=1.14
.ENDS

.SUBCKT sky130_fd_sc_hd__ebufn_2 A TE_B VGND VNB VPB VPWR Z
MMN0 Z net35 sndA VNB nfet_01v8 m=2 w=0.65 l=0.15 mult=1 sa=0.265
+ sb=0.265 sd=0.28 topography=normal area=0.063 perim=1.14
MMN1 sndA net39 VGND VNB nfet_01v8 m=2 w=0.65 l=0.15 mult=1 sa=0.265
+ sb=0.265 sd=0.28 topography=normal area=0.063 perim=1.14
MMIN1 net39 TE_B VGND VNB nfet_01v8 m=1 w=0.42 l=0.15 mult=1 sa=0.265
+ sb=0.265 sd=0.28 topography=normal area=0.063 perim=1.14
MI6 net35 A VGND VNB nfet_01v8 m=1 w=0.42 l=0.15 mult=1 sa=0.265
+ sb=0.265 sd=0.28 topography=normal area=0.063 perim=1.14
MMP0 VPWR TE_B sndTEB VPB pfet_01v8_hvt m=2 w=0.94 l=0.15 mult=1
+ sa=0.265 sb=0.265 sd=0.28 topography=normal area=0.063 perim=1.14
MMP1 sndTEB net35 Z VPB pfet_01v8_hvt m=2 w=1.0 l=0.15 mult=1 sa=0.265
+ sb=0.265 sd=0.28 topography=normal area=0.063 perim=1.14
MMIP1 net39 TE_B VPWR VPB pfet_01v8_hvt m=1 w=0.64 l=0.15 mult=1
+ sa=0.265 sb=0.265 sd=0.28 topography=normal area=0.063 perim=1.14
MI5 net35 A VPWR VPB pfet_01v8_hvt m=1 w=0.64 l=0.15 mult=1 sa=0.265
+ sb=0.265 sd=0.28 topography=normal area=0.063 perim=1.14
.ENDS

.SUBCKT sky130_fd_sc_hd__ebufn_4 A TE_B VGND VNB VPB VPWR Z
MMN0 Z net35 sndA VNB nfet_01v8 m=4 w=0.65 l=0.15 mult=1 sa=0.265
+ sb=0.265 sd=0.28 topography=normal area=0.063 perim=1.14
MMN1 sndA net39 VGND VNB nfet_01v8 m=4 w=0.65 l=0.15 mult=1 sa=0.265
+ sb=0.265 sd=0.28 topography=normal area=0.063 perim=1.14
MMIN1 net39 TE_B VGND VNB nfet_01v8 m=1 w=0.65 l=0.15 mult=1 sa=0.265
+ sb=0.265 sd=0.28 topography=normal area=0.063 perim=1.14
MI6 net35 A VGND VNB nfet_01v8 m=1 w=0.65 l=0.15 mult=1 sa=0.265
+ sb=0.265 sd=0.28 topography=normal area=0.063 perim=1.14
MMP0 VPWR TE_B sndTEB VPB pfet_01v8_hvt m=4 w=0.94 l=0.15 mult=1
+ sa=0.265 sb=0.265 sd=0.28 topography=normal area=0.063 perim=1.14
MMP1 sndTEB net35 Z VPB pfet_01v8_hvt m=4 w=1.0 l=0.15 mult=1 sa=0.265
+ sb=0.265 sd=0.28 topography=normal area=0.063 perim=1.14
MMIP1 net39 TE_B VPWR VPB pfet_01v8_hvt m=1 w=1.0 l=0.15 mult=1
+ sa=0.265 sb=0.265 sd=0.28 topography=normal area=0.063 perim=1.14
MI5 net35 A VPWR VPB pfet_01v8_hvt m=1 w=1.0 l=0.15 mult=1 sa=0.265
+ sb=0.265 sd=0.28 topography=normal area=0.063 perim=1.14
.ENDS

.SUBCKT sky130_fd_sc_hd__ebufn_8 A TE_B VGND VNB VPB VPWR Z
MMN0 Z net35 sndA VNB nfet_01v8 m=8 w=0.65 l=0.15 mult=1 sa=0.265
+ sb=0.265 sd=0.28 topography=normal area=0.063 perim=1.14
MMN1 sndA net39 VGND VNB nfet_01v8 m=8 w=0.65 l=0.15 mult=1 sa=0.265
+ sb=0.265 sd=0.28 topography=normal area=0.063 perim=1.14
MMIN1 net39 TE_B VGND VNB nfet_01v8 m=1 w=0.65 l=0.15 mult=1 sa=0.265
+ sb=0.265 sd=0.28 topography=normal area=0.063 perim=1.14
MI6 net35 A VGND VNB nfet_01v8 m=2 w=0.65 l=0.15 mult=1 sa=0.265
+ sb=0.265 sd=0.28 topography=normal area=0.063 perim=1.14
MMP0 VPWR TE_B sndTEB VPB pfet_01v8_hvt m=8 w=0.94 l=0.15 mult=1
+ sa=0.265 sb=0.265 sd=0.28 topography=normal area=0.063 perim=1.14
MMP1 sndTEB net35 Z VPB pfet_01v8_hvt m=8 w=1.0 l=0.15 mult=1 sa=0.265
+ sb=0.265 sd=0.28 topography=normal area=0.063 perim=1.14
MMIP1 net39 TE_B VPWR VPB pfet_01v8_hvt m=1 w=1.0 l=0.15 mult=1
+ sa=0.265 sb=0.265 sd=0.28 topography=normal area=0.063 perim=1.14
MI5 net35 A VPWR VPB pfet_01v8_hvt m=2 w=1.0 l=0.15 mult=1 sa=0.265
+ sb=0.265 sd=0.28 topography=normal area=0.063 perim=1.14
.ENDS

.SUBCKT sky130_fd_sc_hd__edfxbp_1 CLK D DE VGND VNB VPB VPWR Q Q_N
MI14 net124 M1 VPWR VPB pfet_01v8_hvt m=1 w=0.42 l=0.15 mult=1
+ sa=0.265 sb=0.265 sd=0.28 topography=normal area=0.063 perim=1.14
MI637 clkpos clkneg VPWR VPB pfet_01v8_hvt m=1 w=0.64 l=0.15 mult=1
+ sa=0.265 sb=0.265 sd=0.28 topography=normal area=0.063 perim=1.14
MI13 S0 clkneg net124 VPB pfet_01v8_hvt m=1 w=0.42 l=0.15 mult=1
+ sa=0.265 sb=0.265 sd=0.28 topography=normal area=0.063 perim=1.14
MI655 net68 deneg VPWR VPB pfet_01v8_hvt m=1 w=0.64 l=0.15 mult=1
+ sa=0.265 sb=0.265 sd=0.28 topography=normal area=0.063 perim=1.14
MI651 db clkpos M0 VPB pfet_01v8_hvt m=1 w=0.42 l=0.15 mult=1 sa=0.265
+ sb=0.265 sd=0.28 topography=normal area=0.063 perim=1.14
MI645 Q S0 VPWR VPB pfet_01v8_hvt m=1 w=1.0 l=0.15 mult=1 sa=0.265
+ sb=0.265 sd=0.28 topography=normal area=0.063 perim=1.14
MI658 net109 M1 VPWR VPB pfet_01v8_hvt m=1 w=0.42 l=0.15 mult=1
+ sa=0.265 sb=0.265 sd=0.28 topography=normal area=0.063 perim=1.14
MI638 clkneg CLK VPWR VPB pfet_01v8_hvt m=1 w=0.64 l=0.15 mult=1
+ sa=0.265 sb=0.265 sd=0.28 topography=normal area=0.063 perim=1.14
MI643 net92 S1 VPWR VPB pfet_01v8_hvt m=1 w=0.42 l=0.15 mult=1
+ sa=0.265 sb=0.265 sd=0.28 topography=normal area=0.063 perim=1.14
MI639 M1 M0 VPWR VPB pfet_01v8_hvt m=1 w=0.75 l=0.15 mult=1 sa=0.265
+ sb=0.265 sd=0.28 topography=normal area=0.063 perim=1.14
MI644 S0 clkpos net92 VPB pfet_01v8_hvt m=1 w=0.42 l=0.15 mult=1
+ sa=0.265 sb=0.265 sd=0.28 topography=normal area=0.063 perim=1.14
MI659 M0 clkneg net109 VPB pfet_01v8_hvt m=1 w=0.42 l=0.15 mult=1
+ sa=0.265 sb=0.265 sd=0.28 topography=normal area=0.063 perim=1.14
MI10 net85 DE VPWR VPB pfet_01v8_hvt m=1 w=0.64 l=0.15 mult=1 sa=0.265
+ sb=0.265 sd=0.28 topography=normal area=0.063 perim=1.14
MI17 S1 S0 VPWR VPB pfet_01v8_hvt m=1 w=0.64 l=0.15 mult=1 sa=0.265
+ sb=0.265 sd=0.28 topography=normal area=0.063 perim=1.14
MI9 db S1 net85 VPB pfet_01v8_hvt m=1 w=0.64 l=0.15 mult=1 sa=0.265
+ sb=0.265 sd=0.28 topography=normal area=0.063 perim=1.14
MI4 deneg DE VPWR VPB pfet_01v8_hvt m=1 w=0.64 l=0.15 mult=1 sa=0.265
+ sb=0.265 sd=0.28 topography=normal area=0.063 perim=1.14
MI8 db D net68 VPB pfet_01v8_hvt m=1 w=0.64 l=0.15 mult=1 sa=0.265
+ sb=0.265 sd=0.28 topography=normal area=0.063 perim=1.14
MI21 Q_N S1 VPWR VPB pfet_01v8_hvt m=1 w=1.0 l=0.15 mult=1 sa=0.265
+ sb=0.265 sd=0.28 topography=normal area=0.063 perim=1.14
MI634 M1 M0 VGND VNB nfet_01v8 m=1 w=0.64 l=0.15 mult=1 sa=0.265
+ sb=0.265 sd=0.28 topography=normal area=0.063 perim=1.14
MI636 clkpos clkneg VGND VNB nfet_01v8 m=1 w=0.42 l=0.15 mult=1
+ sa=0.265 sb=0.265 sd=0.28 topography=normal area=0.063 perim=1.14
MI635 clkneg CLK VGND VNB nfet_01v8 m=1 w=0.42 l=0.15 mult=1 sa=0.265
+ sb=0.265 sd=0.28 topography=normal area=0.063 perim=1.14
MI641 net193 S1 VGND VNB nfet_01v8 m=1 w=0.42 l=0.15 mult=1 sa=0.265
+ sb=0.265 sd=0.28 topography=normal area=0.063 perim=1.14
MI642 S0 clkneg net193 VNB nfet_01v8 m=1 w=0.36 l=0.15 mult=1 sa=0.265
+ sb=0.265 sd=0.28 topography=normal area=0.063 perim=1.14
MI654 net148 DE VGND VNB nfet_01v8 m=1 w=0.42 l=0.15 mult=1 sa=0.265
+ sb=0.265 sd=0.28 topography=normal area=0.063 perim=1.14
MI648 db clkneg M0 VNB nfet_01v8 m=1 w=0.36 l=0.15 mult=1 sa=0.265
+ sb=0.265 sd=0.28 topography=normal area=0.063 perim=1.14
MI646 Q S0 VGND VNB nfet_01v8 m=1 w=0.65 l=0.15 mult=1 sa=0.265
+ sb=0.265 sd=0.28 topography=normal area=0.063 perim=1.14
MI656 net168 M1 VGND VNB nfet_01v8 m=1 w=0.42 l=0.15 mult=1 sa=0.265
+ sb=0.265 sd=0.28 topography=normal area=0.063 perim=1.14
MI657 M0 clkpos net168 VNB nfet_01v8 m=1 w=0.36 l=0.15 mult=1 sa=0.265
+ sb=0.265 sd=0.28 topography=normal area=0.063 perim=1.14
MI18 S1 S0 VGND VNB nfet_01v8 m=1 w=0.42 l=0.15 mult=1 sa=0.265
+ sb=0.265 sd=0.28 topography=normal area=0.063 perim=1.14
MI16 net161 M1 VGND VNB nfet_01v8 m=1 w=0.42 l=0.15 mult=1 sa=0.265
+ sb=0.265 sd=0.28 topography=normal area=0.063 perim=1.14
MI15 S0 clkpos net161 VNB nfet_01v8 m=1 w=0.36 l=0.15 mult=1 sa=0.265
+ sb=0.265 sd=0.28 topography=normal area=0.063 perim=1.14
MI5 deneg DE VGND VNB nfet_01v8 m=1 w=0.42 l=0.15 mult=1 sa=0.265
+ sb=0.265 sd=0.28 topography=normal area=0.063 perim=1.14
MI7 db D net148 VNB nfet_01v8 m=1 w=0.42 l=0.15 mult=1 sa=0.265
+ sb=0.265 sd=0.28 topography=normal area=0.063 perim=1.14
MI11 db S1 net141 VNB nfet_01v8 m=1 w=0.42 l=0.15 mult=1 sa=0.265
+ sb=0.265 sd=0.28 topography=normal area=0.063 perim=1.14
MI12 net141 deneg VGND VNB nfet_01v8 m=1 w=0.42 l=0.15 mult=1 sa=0.265
+ sb=0.265 sd=0.28 topography=normal area=0.063 perim=1.14
MI22 Q_N S1 VGND VNB nfet_01v8 m=1 w=0.65 l=0.15 mult=1 sa=0.265
+ sb=0.265 sd=0.28 topography=normal area=0.063 perim=1.14
.ENDS

.SUBCKT sky130_fd_sc_hd__edfxtp_1 CLK D DE VGND VNB VPB VPWR Q
MI14 net115 M1 VPWR VPB pfet_01v8_hvt m=1 w=0.42 l=0.15 mult=1
+ sa=0.265 sb=0.265 sd=0.28 topography=normal area=0.063 perim=1.14
MI637 clkpos clkneg VPWR VPB pfet_01v8_hvt m=1 w=0.64 l=0.15 mult=1
+ sa=0.265 sb=0.265 sd=0.28 topography=normal area=0.063 perim=1.14
MI13 S0 clkneg net115 VPB pfet_01v8_hvt m=1 w=0.42 l=0.15 mult=1
+ sa=0.265 sb=0.265 sd=0.28 topography=normal area=0.063 perim=1.14
MI655 net59 deneg VPWR VPB pfet_01v8_hvt m=1 w=0.64 l=0.15 mult=1
+ sa=0.265 sb=0.265 sd=0.28 topography=normal area=0.063 perim=1.14
MI651 db clkpos M0 VPB pfet_01v8_hvt m=1 w=0.42 l=0.15 mult=1 sa=0.265
+ sb=0.265 sd=0.28 topography=normal area=0.063 perim=1.14
MI645 Q S0 VPWR VPB pfet_01v8_hvt m=1 w=1.0 l=0.15 mult=1 sa=0.265
+ sb=0.265 sd=0.28 topography=normal area=0.063 perim=1.14
MI658 net79 M1 VPWR VPB pfet_01v8_hvt m=1 w=0.42 l=0.15 mult=1
+ sa=0.265 sb=0.265 sd=0.28 topography=normal area=0.063 perim=1.14
MI638 clkneg CLK VPWR VPB pfet_01v8_hvt m=1 w=0.64 l=0.15 mult=1
+ sa=0.265 sb=0.265 sd=0.28 topography=normal area=0.063 perim=1.14
MI643 net83 S1 VPWR VPB pfet_01v8_hvt m=1 w=0.42 l=0.15 mult=1
+ sa=0.265 sb=0.265 sd=0.28 topography=normal area=0.063 perim=1.14
MI639 M1 M0 VPWR VPB pfet_01v8_hvt m=1 w=0.75 l=0.15 mult=1 sa=0.265
+ sb=0.265 sd=0.28 topography=normal area=0.063 perim=1.14
MI644 S0 clkpos net83 VPB pfet_01v8_hvt m=1 w=0.42 l=0.15 mult=1
+ sa=0.265 sb=0.265 sd=0.28 topography=normal area=0.063 perim=1.14
MI659 M0 clkneg net79 VPB pfet_01v8_hvt m=1 w=0.42 l=0.15 mult=1
+ sa=0.265 sb=0.265 sd=0.28 topography=normal area=0.063 perim=1.14
MI10 net76 DE VPWR VPB pfet_01v8_hvt m=1 w=0.64 l=0.15 mult=1 sa=0.265
+ sb=0.265 sd=0.28 topography=normal area=0.063 perim=1.14
MI17 S1 S0 VPWR VPB pfet_01v8_hvt m=1 w=0.64 l=0.15 mult=1 sa=0.265
+ sb=0.265 sd=0.28 topography=normal area=0.063 perim=1.14
MI9 db S1 net76 VPB pfet_01v8_hvt m=1 w=0.64 l=0.15 mult=1 sa=0.265
+ sb=0.265 sd=0.28 topography=normal area=0.063 perim=1.14
MI4 deneg DE VPWR VPB pfet_01v8_hvt m=1 w=0.64 l=0.15 mult=1 sa=0.265
+ sb=0.265 sd=0.28 topography=normal area=0.063 perim=1.14
MI8 db D net59 VPB pfet_01v8_hvt m=1 w=0.64 l=0.15 mult=1 sa=0.265
+ sb=0.265 sd=0.28 topography=normal area=0.063 perim=1.14
MI634 M1 M0 VGND VNB nfet_01v8 m=1 w=0.64 l=0.15 mult=1 sa=0.265
+ sb=0.265 sd=0.28 topography=normal area=0.063 perim=1.14
MI636 clkpos clkneg VGND VNB nfet_01v8 m=1 w=0.42 l=0.15 mult=1
+ sa=0.265 sb=0.265 sd=0.28 topography=normal area=0.063 perim=1.14
MI635 clkneg CLK VGND VNB nfet_01v8 m=1 w=0.42 l=0.15 mult=1 sa=0.265
+ sb=0.265 sd=0.28 topography=normal area=0.063 perim=1.14
MI641 net175 S1 VGND VNB nfet_01v8 m=1 w=0.42 l=0.15 mult=1 sa=0.265
+ sb=0.265 sd=0.28 topography=normal area=0.063 perim=1.14
MI642 S0 clkneg net175 VNB nfet_01v8 m=1 w=0.36 l=0.15 mult=1 sa=0.265
+ sb=0.265 sd=0.28 topography=normal area=0.063 perim=1.14
MI654 net172 DE VGND VNB nfet_01v8 m=1 w=0.42 l=0.15 mult=1 sa=0.265
+ sb=0.265 sd=0.28 topography=normal area=0.063 perim=1.14
MI648 db clkneg M0 VNB nfet_01v8 m=1 w=0.36 l=0.15 mult=1 sa=0.265
+ sb=0.265 sd=0.28 topography=normal area=0.063 perim=1.14
MI646 Q S0 VGND VNB nfet_01v8 m=1 w=0.65 l=0.15 mult=1 sa=0.265
+ sb=0.265 sd=0.28 topography=normal area=0.063 perim=1.14
MI656 net160 M1 VGND VNB nfet_01v8 m=1 w=0.42 l=0.15 mult=1 sa=0.265
+ sb=0.265 sd=0.28 topography=normal area=0.063 perim=1.14
MI657 M0 clkpos net160 VNB nfet_01v8 m=1 w=0.36 l=0.15 mult=1 sa=0.265
+ sb=0.265 sd=0.28 topography=normal area=0.063 perim=1.14
MI18 S1 S0 VGND VNB nfet_01v8 m=1 w=0.42 l=0.15 mult=1 sa=0.265
+ sb=0.265 sd=0.28 topography=normal area=0.063 perim=1.14
MI16 net148 M1 VGND VNB nfet_01v8 m=1 w=0.42 l=0.15 mult=1 sa=0.265
+ sb=0.265 sd=0.28 topography=normal area=0.063 perim=1.14
MI15 S0 clkpos net148 VNB nfet_01v8 m=1 w=0.36 l=0.15 mult=1 sa=0.265
+ sb=0.265 sd=0.28 topography=normal area=0.063 perim=1.14
MI5 deneg DE VGND VNB nfet_01v8 m=1 w=0.42 l=0.15 mult=1 sa=0.265
+ sb=0.265 sd=0.28 topography=normal area=0.063 perim=1.14
MI7 db D net172 VNB nfet_01v8 m=1 w=0.42 l=0.15 mult=1 sa=0.265
+ sb=0.265 sd=0.28 topography=normal area=0.063 perim=1.14
MI11 db S1 net128 VNB nfet_01v8 m=1 w=0.42 l=0.15 mult=1 sa=0.265
+ sb=0.265 sd=0.28 topography=normal area=0.063 perim=1.14
MI12 net128 deneg VGND VNB nfet_01v8 m=1 w=0.42 l=0.15 mult=1 sa=0.265
+ sb=0.265 sd=0.28 topography=normal area=0.063 perim=1.14
.ENDS

.SUBCKT sky130_fd_sc_hd__einvn_0 A TE_B VGND VNB VPB VPWR Z
MMN0 Z A sndA VNB nfet_01v8 m=1 w=0.42 l=0.15 mult=1 sa=0.265 sb=0.265
+ sd=0.28 topography=normal area=0.063 perim=1.14
MMN1 sndA net25 VGND VNB nfet_01v8 m=1 w=0.42 l=0.15 mult=1 sa=0.265
+ sb=0.265 sd=0.28 topography=normal area=0.063 perim=1.14
MMIN1 net25 TE_B VGND VNB nfet_01v8 m=1 w=0.42 l=0.15 mult=1 sa=0.265
+ sb=0.265 sd=0.28 topography=normal area=0.063 perim=1.14
MMP0 VPWR TE_B sndTEB VPB pfet_01v8_hvt m=1 w=0.64 l=0.15 mult=1
+ sa=0.265 sb=0.265 sd=0.28 topography=normal area=0.063 perim=1.14
MMP1 sndTEB A Z VPB pfet_01v8_hvt m=1 w=0.64 l=0.15 mult=1 sa=0.265
+ sb=0.265 sd=0.28 topography=normal area=0.063 perim=1.14
MMIP1 net25 TE_B VPWR VPB pfet_01v8_hvt m=1 w=0.42 l=0.15 mult=1
+ sa=0.265 sb=0.265 sd=0.28 topography=normal area=0.063 perim=1.14
.ENDS

.SUBCKT sky130_fd_sc_hd__einvn_1 A TE_B VGND VNB VPB VPWR Z
MMN0 Z A sndA VNB nfet_01v8 m=1 w=0.65 l=0.15 mult=1 sa=0.265 sb=0.265
+ sd=0.28 topography=normal area=0.063 perim=1.14
MMN1 sndA net25 VGND VNB nfet_01v8 m=1 w=0.65 l=0.15 mult=1 sa=0.265
+ sb=0.265 sd=0.28 topography=normal area=0.063 perim=1.14
MMIN1 net25 TE_B VGND VNB nfet_01v8 m=1 w=0.42 l=0.15 mult=1 sa=0.265
+ sb=0.265 sd=0.28 topography=normal area=0.063 perim=1.14
MMP0 VPWR TE_B sndTEB VPB pfet_01v8_hvt m=1 w=1.0 l=0.15 mult=1
+ sa=0.265 sb=0.265 sd=0.28 topography=normal area=0.063 perim=1.14
MMP1 sndTEB A Z VPB pfet_01v8_hvt m=1 w=1.0 l=0.15 mult=1 sa=0.265
+ sb=0.265 sd=0.28 topography=normal area=0.063 perim=1.14
MMIP1 net25 TE_B VPWR VPB pfet_01v8_hvt m=1 w=0.64 l=0.15 mult=1
+ sa=0.265 sb=0.265 sd=0.28 topography=normal area=0.063 perim=1.14
.ENDS

.SUBCKT sky130_fd_sc_hd__einvn_2 A TE_B VGND VNB VPB VPWR Z
MMN0 Z A sndA VNB nfet_01v8 m=2 w=0.65 l=0.15 mult=1 sa=0.265 sb=0.265
+ sd=0.28 topography=normal area=0.063 perim=1.14
MMN1 sndA TE VGND VNB nfet_01v8 m=2 w=0.65 l=0.15 mult=1 sa=0.265
+ sb=0.265 sd=0.28 topography=normal area=0.063 perim=1.14
MMIN1 TE TE_B VGND VNB nfet_01v8 m=1 w=0.42 l=0.15 mult=1 sa=0.265
+ sb=0.265 sd=0.28 topography=normal area=0.063 perim=1.14
MMP0 VPWR TE_B sndTEB VPB pfet_01v8_hvt m=2 w=0.94 l=0.15 mult=1
+ sa=0.265 sb=0.265 sd=0.28 topography=normal area=0.063 perim=1.14
MMP1 sndTEB A Z VPB pfet_01v8_hvt m=2 w=1.0 l=0.15 mult=1 sa=0.265
+ sb=0.265 sd=0.28 topography=normal area=0.063 perim=1.14
MMIP1 TE TE_B VPWR VPB pfet_01v8_hvt m=1 w=0.64 l=0.15 mult=1 sa=0.265
+ sb=0.265 sd=0.28 topography=normal area=0.063 perim=1.14
.ENDS

.SUBCKT sky130_fd_sc_hd__einvn_4 A TE_B VGND VNB VPB VPWR Z
MMN0 Z A sndA VNB nfet_01v8 m=4 w=0.65 l=0.15 mult=1 sa=0.265 sb=0.265
+ sd=0.28 topography=normal area=0.063 perim=1.14
MMN1 sndA TE VGND VNB nfet_01v8 m=4 w=0.65 l=0.15 mult=1 sa=0.265
+ sb=0.265 sd=0.28 topography=normal area=0.063 perim=1.14
MMIN1 TE TE_B VGND VNB nfet_01v8 m=1 w=0.65 l=0.15 mult=1 sa=0.265
+ sb=0.265 sd=0.28 topography=normal area=0.063 perim=1.14
MMP0 VPWR TE_B sndTEB VPB pfet_01v8_hvt m=4 w=0.94 l=0.15 mult=1
+ sa=0.265 sb=0.265 sd=0.28 topography=normal area=0.063 perim=1.14
MMP1 sndTEB A Z VPB pfet_01v8_hvt m=4 w=1.0 l=0.15 mult=1 sa=0.265
+ sb=0.265 sd=0.28 topography=normal area=0.063 perim=1.14
MMIP1 TE TE_B VPWR VPB pfet_01v8_hvt m=1 w=1.0 l=0.15 mult=1 sa=0.265
+ sb=0.265 sd=0.28 topography=normal area=0.063 perim=1.14
.ENDS

.SUBCKT sky130_fd_sc_hd__einvn_8 A TE_B VGND VNB VPB VPWR Z
MMN0 Z A sndA VNB nfet_01v8 m=8 w=0.65 l=0.15 mult=1 sa=0.265 sb=0.265
+ sd=0.28 topography=normal area=0.063 perim=1.14
MMN1 sndA TE VGND VNB nfet_01v8 m=8 w=0.65 l=0.15 mult=1 sa=0.265
+ sb=0.265 sd=0.28 topography=normal area=0.063 perim=1.14
MMIN1 TE TE_B VGND VNB nfet_01v8 m=1 w=0.65 l=0.15 mult=1 sa=0.265
+ sb=0.265 sd=0.28 topography=normal area=0.063 perim=1.14
MMP0 VPWR TE_B sndTEB VPB pfet_01v8_hvt m=8 w=0.94 l=0.15 mult=1
+ sa=0.265 sb=0.265 sd=0.28 topography=normal area=0.063 perim=1.14
MMP1 sndTEB A Z VPB pfet_01v8_hvt m=8 w=1.0 l=0.15 mult=1 sa=0.265
+ sb=0.265 sd=0.28 topography=normal area=0.063 perim=1.14
MMIP1 TE TE_B VPWR VPB pfet_01v8_hvt m=1 w=1.0 l=0.15 mult=1 sa=0.265
+ sb=0.265 sd=0.28 topography=normal area=0.063 perim=1.14
.ENDS

.SUBCKT sky130_fd_sc_hd__einvp_1 A TE VGND VNB VPB VPWR Z
MMN0 Z A sndA VNB nfet_01v8 m=1 w=0.65 l=0.15 mult=1 sa=0.265 sb=0.265
+ sd=0.28 topography=normal area=0.063 perim=1.14
MMN1 sndA TE VGND VNB nfet_01v8 m=1 w=0.65 l=0.15 mult=1 sa=0.265
+ sb=0.265 sd=0.28 topography=normal area=0.063 perim=1.14
MMIN1 TEB TE VGND VNB nfet_01v8 m=1 w=0.42 l=0.15 mult=1 sa=0.265
+ sb=0.265 sd=0.28 topography=normal area=0.063 perim=1.14
MMP0 VPWR TEB sndTEB VPB pfet_01v8_hvt m=1 w=1.0 l=0.15 mult=1
+ sa=0.265 sb=0.265 sd=0.28 topography=normal area=0.063 perim=1.14
MMP1 sndTEB A Z VPB pfet_01v8_hvt m=1 w=1.0 l=0.15 mult=1 sa=0.265
+ sb=0.265 sd=0.28 topography=normal area=0.063 perim=1.14
MMIP1 TEB TE VPWR VPB pfet_01v8_hvt m=1 w=0.42 l=0.15 mult=1 sa=0.265
+ sb=0.265 sd=0.28 topography=normal area=0.063 perim=1.14
.ENDS

.SUBCKT sky130_fd_sc_hd__einvp_2 A TE VGND VNB VPB VPWR Z
MMN0 Z A sndA VNB nfet_01v8 m=2 w=0.65 l=0.15 mult=1 sa=0.265 sb=0.265
+ sd=0.28 topography=normal area=0.063 perim=1.14
MMN1 sndA TE VGND VNB nfet_01v8 m=2 w=0.65 l=0.15 mult=1 sa=0.265
+ sb=0.265 sd=0.28 topography=normal area=0.063 perim=1.14
MMIN1 TEB TE VGND VNB nfet_01v8 m=1 w=0.42 l=0.15 mult=1 sa=0.265
+ sb=0.265 sd=0.28 topography=normal area=0.063 perim=1.14
MMP0 VPWR TEB sndTEB VPB pfet_01v8_hvt m=2 w=0.94 l=0.15 mult=1
+ sa=0.265 sb=0.265 sd=0.28 topography=normal area=0.063 perim=1.14
MMP1 sndTEB A Z VPB pfet_01v8_hvt m=2 w=1.0 l=0.15 mult=1 sa=0.265
+ sb=0.265 sd=0.28 topography=normal area=0.063 perim=1.14
MMIP1 TEB TE VPWR VPB pfet_01v8_hvt m=1 w=0.64 l=0.15 mult=1 sa=0.265
+ sb=0.265 sd=0.28 topography=normal area=0.063 perim=1.14
.ENDS

.SUBCKT sky130_fd_sc_hd__einvp_4 A TE VGND VNB VPB VPWR Z
MMN0 Z A sndA VNB nfet_01v8 m=4 w=0.65 l=0.15 mult=1 sa=0.265 sb=0.265
+ sd=0.28 topography=normal area=0.063 perim=1.14
MMN1 sndA TE VGND VNB nfet_01v8 m=4 w=0.65 l=0.15 mult=1 sa=0.265
+ sb=0.265 sd=0.28 topography=normal area=0.063 perim=1.14
MMIN1 TEB TE VGND VNB nfet_01v8 m=1 w=0.65 l=0.15 mult=1 sa=0.265
+ sb=0.265 sd=0.28 topography=normal area=0.063 perim=1.14
MMP0 VPWR TEB sndTEB VPB pfet_01v8_hvt m=4 w=0.94 l=0.15 mult=1
+ sa=0.265 sb=0.265 sd=0.28 topography=normal area=0.063 perim=1.14
MMP1 sndTEB A Z VPB pfet_01v8_hvt m=4 w=1.0 l=0.15 mult=1 sa=0.265
+ sb=0.265 sd=0.28 topography=normal area=0.063 perim=1.14
MMIP1 TEB TE VPWR VPB pfet_01v8_hvt m=1 w=1.0 l=0.15 mult=1 sa=0.265
+ sb=0.265 sd=0.28 topography=normal area=0.063 perim=1.14
.ENDS

.SUBCKT sky130_fd_sc_hd__einvp_8 A TE VGND VNB VPB VPWR Z
MMN0 Z A sndA VNB nfet_01v8 m=8 w=0.65 l=0.15 mult=1 sa=0.265 sb=0.265
+ sd=0.28 topography=normal area=0.063 perim=1.14
MMN1 sndA TE VGND VNB nfet_01v8 m=8 w=0.65 l=0.15 mult=1 sa=0.265
+ sb=0.265 sd=0.28 topography=normal area=0.063 perim=1.14
MMIN1 TEB TE VGND VNB nfet_01v8 m=1 w=0.65 l=0.15 mult=1 sa=0.265
+ sb=0.265 sd=0.28 topography=normal area=0.063 perim=1.14
MMP0 VPWR TEB sndTEB VPB pfet_01v8_hvt m=8 w=0.94 l=0.15 mult=1
+ sa=0.265 sb=0.265 sd=0.28 topography=normal area=0.063 perim=1.14
MMP1 sndTEB A Z VPB pfet_01v8_hvt m=8 w=1.0 l=0.15 mult=1 sa=0.265
+ sb=0.265 sd=0.28 topography=normal area=0.063 perim=1.14
MMIP1 TEB TE VPWR VPB pfet_01v8_hvt m=1 w=1.0 l=0.15 mult=1 sa=0.265
+ sb=0.265 sd=0.28 topography=normal area=0.063 perim=1.14
.ENDS

.SUBCKT sky130_fd_sc_hd__fa_1 A B CIN VGND VNB VPB VPWR COUT SUM
MMNs1s nint1 majb sumb VNB nfet_01v8 m=1 w=0.42 l=0.15 mult=1 sa=0.265
+ sb=0.265 sd=0.28 topography=normal area=0.063 perim=1.14
MMIN2 COUT majb VGND VNB nfet_01v8 m=1 w=0.65 l=0.15 mult=1 sa=0.265
+ sb=0.265 sd=0.28 topography=normal area=0.063 perim=1.14
MMIN3 SUM sumb VGND VNB nfet_01v8 m=1 w=0.65 l=0.15 mult=1 sa=0.265
+ sb=0.265 sd=0.28 topography=normal area=0.063 perim=1.14
MMNmaj10 majb B sndNAp1 VNB nfet_01v8 m=1 w=0.42 l=0.15 mult=1
+ sa=0.265 sb=0.265 sd=0.28 topography=normal area=0.063 perim=1.14
MMNmaj11 sndNAp1 A VGND VNB nfet_01v8 m=1 w=0.42 l=0.15 mult=1
+ sa=0.265 sb=0.265 sd=0.28 topography=normal area=0.063 perim=1.14
MMNmaj30 majb CIN sndNCINn3 VNB nfet_01v8 m=1 w=0.42 l=0.15 mult=1
+ sa=0.265 sb=0.265 sd=0.28 topography=normal area=0.063 perim=1.14
MMNmaj31 sndNCINn3 B VGND VNB nfet_01v8 m=1 w=0.42 l=0.15 mult=1
+ sa=0.265 sb=0.265 sd=0.28 topography=normal area=0.063 perim=1.14
MMNmaj20 VGND A sndNCINn3 VNB nfet_01v8 m=1 w=0.42 l=0.15 mult=1
+ sa=0.265 sb=0.265 sd=0.28 topography=normal area=0.063 perim=1.14
MMNs2s0 VGND A sndNAn4 VNB nfet_01v8 m=1 w=0.42 l=0.15 mult=1 sa=0.265
+ sb=0.265 sd=0.28 topography=normal area=0.063 perim=1.14
MMNs2s1 sndNAn4 B sndNBn4 VNB nfet_01v8 m=1 w=0.42 l=0.15 mult=1
+ sa=0.265 sb=0.265 sd=0.28 topography=normal area=0.063 perim=1.14
MMNs2s2 sndNBn4 CIN sumb VNB nfet_01v8 m=1 w=0.42 l=0.15 mult=1
+ sa=0.265 sb=0.265 sd=0.28 topography=normal area=0.063 perim=1.14
MMNs3s0 nint1 B VGND VNB nfet_01v8 m=1 w=0.42 l=0.15 mult=1 sa=0.265
+ sb=0.265 sd=0.28 topography=normal area=0.063 perim=1.14
MMNs3s1 nint1 A VGND VNB nfet_01v8 m=1 w=0.42 l=0.15 mult=1 sa=0.265
+ sb=0.265 sd=0.28 topography=normal area=0.063 perim=1.14
MMNs3s2 nint1 CIN VGND VNB nfet_01v8 m=1 w=0.42 l=0.15 mult=1 sa=0.265
+ sb=0.265 sd=0.28 topography=normal area=0.063 perim=1.14
MMIP2 COUT majb VPWR VPB pfet_01v8_hvt m=1 w=1.0 l=0.15 mult=1
+ sa=0.265 sb=0.265 sd=0.28 topography=normal area=0.063 perim=1.14
MMIP3 SUM sumb VPWR VPB pfet_01v8_hvt m=1 w=1.0 l=0.15 mult=1 sa=0.265
+ sb=0.265 sd=0.28 topography=normal area=0.063 perim=1.14
MMPmaj10 VPWR A sndPAp1 VPB pfet_01v8_hvt m=1 w=0.42 l=0.15 mult=1
+ sa=0.265 sb=0.265 sd=0.28 topography=normal area=0.063 perim=1.14
MMPmaj11 sndPAp1 B majb VPB pfet_01v8_hvt m=1 w=0.42 l=0.15 mult=1
+ sa=0.265 sb=0.265 sd=0.28 topography=normal area=0.063 perim=1.14
MMPmaj20 VPWR A sndPCINp3 VPB pfet_01v8_hvt m=1 w=0.42 l=0.15 mult=1
+ sa=0.265 sb=0.265 sd=0.28 topography=normal area=0.063 perim=1.14
MMPmaj21 sndPCINp3 CIN majb VPB pfet_01v8_hvt m=1 w=0.42 l=0.15 mult=1
+ sa=0.265 sb=0.265 sd=0.28 topography=normal area=0.063 perim=1.14
MMPmaj31 sndPCINp3 B VPWR VPB pfet_01v8_hvt m=1 w=0.42 l=0.15 mult=1
+ sa=0.265 sb=0.265 sd=0.28 topography=normal area=0.063 perim=1.14
MMPs2s0 VPWR A sndPAp4 VPB pfet_01v8_hvt m=1 w=0.42 l=0.15 mult=1
+ sa=0.265 sb=0.265 sd=0.28 topography=normal area=0.063 perim=1.14
MMPs2s1 sndPAp4 B sndPBp4 VPB pfet_01v8_hvt m=1 w=0.42 l=0.15 mult=1
+ sa=0.265 sb=0.265 sd=0.28 topography=normal area=0.063 perim=1.14
MMPs2s2 sndPBp4 CIN sumb VPB pfet_01v8_hvt m=1 w=0.42 l=0.15 mult=1
+ sa=0.265 sb=0.265 sd=0.28 topography=normal area=0.063 perim=1.14
MMPs3s0 pint1 B VPWR VPB pfet_01v8_hvt m=1 w=0.42 l=0.15 mult=1
+ sa=0.265 sb=0.265 sd=0.28 topography=normal area=0.063 perim=1.14
MMPs3s1 pint1 A VPWR VPB pfet_01v8_hvt m=1 w=0.42 l=0.15 mult=1
+ sa=0.265 sb=0.265 sd=0.28 topography=normal area=0.063 perim=1.14
MMPs3s2 pint1 CIN VPWR VPB pfet_01v8_hvt m=1 w=0.42 l=0.15 mult=1
+ sa=0.265 sb=0.265 sd=0.28 topography=normal area=0.063 perim=1.14
MMPs1s pint1 majb sumb VPB pfet_01v8_hvt m=1 w=0.42 l=0.15 mult=1
+ sa=0.265 sb=0.265 sd=0.28 topography=normal area=0.063 perim=1.14
.ENDS

.SUBCKT sky130_fd_sc_hd__fa_2 A B CIN VGND VNB VPB VPWR COUT SUM
MMNs1s nint1 majb sumb VNB nfet_01v8 m=1 w=0.42 l=0.15 mult=1 sa=0.265
+ sb=0.265 sd=0.28 topography=normal area=0.063 perim=1.14
MMIN2 COUT majb VGND VNB nfet_01v8 m=2 w=0.65 l=0.15 mult=1 sa=0.265
+ sb=0.265 sd=0.28 topography=normal area=0.063 perim=1.14
MMIN3 SUM sumb VGND VNB nfet_01v8 m=2 w=0.65 l=0.15 mult=1 sa=0.265
+ sb=0.265 sd=0.28 topography=normal area=0.063 perim=1.14
MMNmaj10 majb B sndNAp1 VNB nfet_01v8 m=1 w=0.42 l=0.15 mult=1
+ sa=0.265 sb=0.265 sd=0.28 topography=normal area=0.063 perim=1.14
MMNmaj11 sndNAp1 A VGND VNB nfet_01v8 m=1 w=0.42 l=0.15 mult=1
+ sa=0.265 sb=0.265 sd=0.28 topography=normal area=0.063 perim=1.14
MMNmaj30 majb CIN nmajmid VNB nfet_01v8 m=1 w=0.42 l=0.15 mult=1
+ sa=0.265 sb=0.265 sd=0.28 topography=normal area=0.063 perim=1.14
MMNmaj21 nmajmid A VGND VNB nfet_01v8 m=1 w=0.42 l=0.15 mult=1
+ sa=0.265 sb=0.265 sd=0.28 topography=normal area=0.063 perim=1.14
MMNmaj20 VGND B nmajmid VNB nfet_01v8 m=1 w=0.42 l=0.15 mult=1
+ sa=0.265 sb=0.265 sd=0.28 topography=normal area=0.063 perim=1.14
MMNs2s0 VGND A sndNAn4 VNB nfet_01v8 m=1 w=0.42 l=0.15 mult=1 sa=0.265
+ sb=0.265 sd=0.28 topography=normal area=0.063 perim=1.14
MMNs2s1 sndNAn4 B sndNBn4 VNB nfet_01v8 m=1 w=0.42 l=0.15 mult=1
+ sa=0.265 sb=0.265 sd=0.28 topography=normal area=0.063 perim=1.14
MMNs2s2 sndNBn4 CIN sumb VNB nfet_01v8 m=1 w=0.42 l=0.15 mult=1
+ sa=0.265 sb=0.265 sd=0.28 topography=normal area=0.063 perim=1.14
MMNs3s0 nint1 A VGND VNB nfet_01v8 m=1 w=0.42 l=0.15 mult=1 sa=0.265
+ sb=0.265 sd=0.28 topography=normal area=0.063 perim=1.14
MMNs3s1 nint1 B VGND VNB nfet_01v8 m=1 w=0.42 l=0.15 mult=1 sa=0.265
+ sb=0.265 sd=0.28 topography=normal area=0.063 perim=1.14
MMNs3s2 nint1 CIN VGND VNB nfet_01v8 m=1 w=0.42 l=0.15 mult=1 sa=0.265
+ sb=0.265 sd=0.28 topography=normal area=0.063 perim=1.14
MMIP2 COUT majb VPWR VPB pfet_01v8_hvt m=2 w=1.0 l=0.15 mult=1
+ sa=0.265 sb=0.265 sd=0.28 topography=normal area=0.063 perim=1.14
MMIP3 SUM sumb VPWR VPB pfet_01v8_hvt m=2 w=1.0 l=0.15 mult=1 sa=0.265
+ sb=0.265 sd=0.28 topography=normal area=0.063 perim=1.14
MMPmaj10 VPWR A sndPAp1 VPB pfet_01v8_hvt m=1 w=0.63 l=0.15 mult=1
+ sa=0.265 sb=0.265 sd=0.28 topography=normal area=0.063 perim=1.14
MMPmaj11 sndPAp1 B majb VPB pfet_01v8_hvt m=1 w=0.63 l=0.15 mult=1
+ sa=0.265 sb=0.265 sd=0.28 topography=normal area=0.063 perim=1.14
MMPmaj20 VPWR B pmajmid VPB pfet_01v8_hvt m=1 w=0.63 l=0.15 mult=1
+ sa=0.265 sb=0.265 sd=0.28 topography=normal area=0.063 perim=1.14
MMPmaj30 pmajmid CIN majb VPB pfet_01v8_hvt m=1 w=0.63 l=0.15 mult=1
+ sa=0.265 sb=0.265 sd=0.28 topography=normal area=0.063 perim=1.14
MMPmaj21 pmajmid A VPWR VPB pfet_01v8_hvt m=1 w=0.63 l=0.15 mult=1
+ sa=0.265 sb=0.265 sd=0.28 topography=normal area=0.063 perim=1.14
MMPs2s0 VPWR A sndPAp4 VPB pfet_01v8_hvt m=1 w=0.63 l=0.15 mult=1
+ sa=0.265 sb=0.265 sd=0.28 topography=normal area=0.063 perim=1.14
MMPs2s1 sndPAp4 B sndPBp4 VPB pfet_01v8_hvt m=1 w=0.63 l=0.15 mult=1
+ sa=0.265 sb=0.265 sd=0.28 topography=normal area=0.063 perim=1.14
MMPs2s2 sndPBp4 CIN sumb VPB pfet_01v8_hvt m=1 w=0.64 l=0.15 mult=1
+ sa=0.265 sb=0.265 sd=0.28 topography=normal area=0.063 perim=1.14
MMPs3s0 pint1 A VPWR VPB pfet_01v8_hvt m=1 w=0.64 l=0.15 mult=1
+ sa=0.265 sb=0.265 sd=0.28 topography=normal area=0.063 perim=1.14
MMPs3s1 pint1 B VPWR VPB pfet_01v8_hvt m=1 w=0.64 l=0.15 mult=1
+ sa=0.265 sb=0.265 sd=0.28 topography=normal area=0.063 perim=1.14
MMPs3s2 pint1 CIN VPWR VPB pfet_01v8_hvt m=1 w=0.64 l=0.15 mult=1
+ sa=0.265 sb=0.265 sd=0.28 topography=normal area=0.063 perim=1.14
MMPs1s pint1 majb sumb VPB pfet_01v8_hvt m=1 w=0.64 l=0.15 mult=1
+ sa=0.265 sb=0.265 sd=0.28 topography=normal area=0.063 perim=1.14
.ENDS

.SUBCKT sky130_fd_sc_hd__fa_4 A B CIN VGND VNB VPB VPWR COUT SUM
MMNs1s nint1 majb sumb VNB nfet_01v8 m=1 w=0.42 l=0.15 mult=1 sa=0.265
+ sb=0.265 sd=0.28 topography=normal area=0.063 perim=1.14
MMIN2 COUT majb VGND VNB nfet_01v8 m=4 w=0.65 l=0.15 mult=1 sa=0.265
+ sb=0.265 sd=0.28 topography=normal area=0.063 perim=1.14
MMIN3 SUM sumb VGND VNB nfet_01v8 m=4 w=0.65 l=0.15 mult=1 sa=0.265
+ sb=0.265 sd=0.28 topography=normal area=0.063 perim=1.14
MMNmaj10 majb B sndNAp1 VNB nfet_01v8 m=1 w=0.42 l=0.15 mult=1
+ sa=0.265 sb=0.265 sd=0.28 topography=normal area=0.063 perim=1.14
MMNmaj11 sndNAp1 A VGND VNB nfet_01v8 m=1 w=0.42 l=0.15 mult=1
+ sa=0.265 sb=0.265 sd=0.28 topography=normal area=0.063 perim=1.14
MMNmaj30 majb CIN nmajmid VNB nfet_01v8 m=1 w=0.42 l=0.15 mult=1
+ sa=0.265 sb=0.265 sd=0.28 topography=normal area=0.063 perim=1.14
MMNmaj21 nmajmid A VGND VNB nfet_01v8 m=1 w=0.42 l=0.15 mult=1
+ sa=0.265 sb=0.265 sd=0.28 topography=normal area=0.063 perim=1.14
MMNmaj20 VGND B nmajmid VNB nfet_01v8 m=1 w=0.42 l=0.15 mult=1
+ sa=0.265 sb=0.265 sd=0.28 topography=normal area=0.063 perim=1.14
MMNs2s0 VGND A sndNAn4 VNB nfet_01v8 m=1 w=0.42 l=0.15 mult=1 sa=0.265
+ sb=0.265 sd=0.28 topography=normal area=0.063 perim=1.14
MMNs2s1 sndNAn4 B sndNBn4 VNB nfet_01v8 m=1 w=0.42 l=0.15 mult=1
+ sa=0.265 sb=0.265 sd=0.28 topography=normal area=0.063 perim=1.14
MMNs2s2 sndNBn4 CIN sumb VNB nfet_01v8 m=1 w=0.42 l=0.15 mult=1
+ sa=0.265 sb=0.265 sd=0.28 topography=normal area=0.063 perim=1.14
MMNs3s0 nint1 A VGND VNB nfet_01v8 m=1 w=0.42 l=0.15 mult=1 sa=0.265
+ sb=0.265 sd=0.28 topography=normal area=0.063 perim=1.14
MMNs3s1 nint1 B VGND VNB nfet_01v8 m=1 w=0.42 l=0.15 mult=1 sa=0.265
+ sb=0.265 sd=0.28 topography=normal area=0.063 perim=1.14
MMNs3s2 nint1 CIN VGND VNB nfet_01v8 m=1 w=0.42 l=0.15 mult=1 sa=0.265
+ sb=0.265 sd=0.28 topography=normal area=0.063 perim=1.14
MMIP2 COUT majb VPWR VPB pfet_01v8_hvt m=4 w=1.0 l=0.15 mult=1
+ sa=0.265 sb=0.265 sd=0.28 topography=normal area=0.063 perim=1.14
MMIP3 SUM sumb VPWR VPB pfet_01v8_hvt m=4 w=1.0 l=0.15 mult=1 sa=0.265
+ sb=0.265 sd=0.28 topography=normal area=0.063 perim=1.14
MMPmaj10 VPWR A sndPAp1 VPB pfet_01v8_hvt m=1 w=0.63 l=0.15 mult=1
+ sa=0.265 sb=0.265 sd=0.28 topography=normal area=0.063 perim=1.14
MMPmaj11 sndPAp1 B majb VPB pfet_01v8_hvt m=1 w=0.63 l=0.15 mult=1
+ sa=0.265 sb=0.265 sd=0.28 topography=normal area=0.063 perim=1.14
MMPmaj20 VPWR B pmajmid VPB pfet_01v8_hvt m=1 w=0.64 l=0.15 mult=1
+ sa=0.265 sb=0.265 sd=0.28 topography=normal area=0.063 perim=1.14
MMPmaj30 pmajmid CIN majb VPB pfet_01v8_hvt m=1 w=0.64 l=0.15 mult=1
+ sa=0.265 sb=0.265 sd=0.28 topography=normal area=0.063 perim=1.14
MMPmaj21 pmajmid A VPWR VPB pfet_01v8_hvt m=1 w=0.64 l=0.15 mult=1
+ sa=0.265 sb=0.265 sd=0.28 topography=normal area=0.063 perim=1.14
MMPs2s0 VPWR A sndPAp4 VPB pfet_01v8_hvt m=1 w=0.63 l=0.15 mult=1
+ sa=0.265 sb=0.265 sd=0.28 topography=normal area=0.063 perim=1.14
MMPs2s1 sndPAp4 B sndPBp4 VPB pfet_01v8_hvt m=1 w=0.63 l=0.15 mult=1
+ sa=0.265 sb=0.265 sd=0.28 topography=normal area=0.063 perim=1.14
MMPs2s2 sndPBp4 CIN sumb VPB pfet_01v8_hvt m=1 w=0.64 l=0.15 mult=1
+ sa=0.265 sb=0.265 sd=0.28 topography=normal area=0.063 perim=1.14
MMPs3s0 pint1 A VPWR VPB pfet_01v8_hvt m=1 w=0.64 l=0.15 mult=1
+ sa=0.265 sb=0.265 sd=0.28 topography=normal area=0.063 perim=1.14
MMPs3s1 pint1 B VPWR VPB pfet_01v8_hvt m=1 w=0.64 l=0.15 mult=1
+ sa=0.265 sb=0.265 sd=0.28 topography=normal area=0.063 perim=1.14
MMPs3s2 pint1 CIN VPWR VPB pfet_01v8_hvt m=1 w=0.64 l=0.15 mult=1
+ sa=0.265 sb=0.265 sd=0.28 topography=normal area=0.063 perim=1.14
MMPs1s pint1 majb sumb VPB pfet_01v8_hvt m=1 w=0.64 l=0.15 mult=1
+ sa=0.265 sb=0.265 sd=0.28 topography=normal area=0.063 perim=1.14
.ENDS

.SUBCKT sky130_fd_sc_hd__fah_1 A B CI VGND VNB VPB VPWR COUT SUM
MMIN2 COUT net195 VGND VNB nfet_01v8 m=1 w=0.65 l=0.15 mult=1 sa=0.265
+ sb=0.265 sd=0.28 topography=normal area=0.063 perim=1.14
MMIN3 SUM net123 VGND VNB nfet_01v8 m=1 w=0.65 l=0.15 mult=1 sa=0.265
+ sb=0.265 sd=0.28 topography=normal area=0.063 perim=1.14
MI6 CIb mid2 net195 VNB nfet_01v8 m=1 w=0.64 l=0.15 mult=1 sa=0.265
+ sb=0.265 sd=0.28 topography=normal area=0.063 perim=1.14
MI5 Bb mid1 net195 VNB nfet_01v8 m=1 w=0.64 l=0.15 mult=1 sa=0.265
+ sb=0.265 sd=0.28 topography=normal area=0.063 perim=1.14
MI2 CIbb mid2 net123 VNB nfet_01v8 m=1 w=0.64 l=0.15 mult=1 sa=0.265
+ sb=0.265 sd=0.28 topography=normal area=0.063 perim=1.14
MI649 CIb mid1 net123 VNB nfet_01v8 m=1 w=0.64 l=0.15 mult=1 sa=0.265
+ sb=0.265 sd=0.28 topography=normal area=0.063 perim=1.14
MI17 Bb B VGND VNB nfet_01v8 m=1 w=0.65 l=0.15 mult=1 sa=0.265
+ sb=0.265 sd=0.28 topography=normal area=0.063 perim=1.14
MI46 CIbb CIb VGND VNB nfet_01v8 m=1 w=0.64 l=0.15 mult=1 sa=0.265
+ sb=0.265 sd=0.28 topography=normal area=0.063 perim=1.14
MI44 CIb CI VGND VNB nfet_01v8 m=1 w=0.64 l=0.15 mult=1 sa=0.265
+ sb=0.265 sd=0.28 topography=normal area=0.063 perim=1.14
MI8 Ab2 A VGND VNB nfet_01v8 m=1 w=0.64 l=0.15 mult=1 sa=0.265
+ sb=0.265 sd=0.28 topography=normal area=0.063 perim=1.14
MI9 Abb2 Ab2 VGND VNB nfet_01v8 m=1 w=0.65 l=0.15 mult=1 sa=0.265
+ sb=0.265 sd=0.28 topography=normal area=0.063 perim=1.14
MI14 Ab1 A VGND VNB nfet_01v8 m=1 w=0.64 l=0.15 mult=1 sa=0.265
+ sb=0.265 sd=0.28 topography=normal area=0.063 perim=1.14
MI20 Abb2 B mid1 VNB nfet_01v8 m=1 w=0.64 l=0.15 mult=1 sa=0.265
+ sb=0.265 sd=0.28 topography=normal area=0.063 perim=1.14
MI21 Ab1 Bb mid1 VNB nfet_01v8 m=1 w=0.64 l=0.15 mult=1 sa=0.265
+ sb=0.265 sd=0.28 topography=normal area=0.063 perim=1.14
MI24 Abb2 Bb mid2 VNB nfet_01v8 m=1 w=0.64 l=0.15 mult=1 sa=0.265
+ sb=0.265 sd=0.28 topography=normal area=0.063 perim=1.14
MI25 Ab1 B mid2 VNB nfet_01v8 m=1 w=0.64 l=0.15 mult=1 sa=0.265
+ sb=0.265 sd=0.28 topography=normal area=0.063 perim=1.14
MMIP2 COUT net195 VPWR VPB pfet_01v8_hvt m=1 w=1.0 l=0.15 mult=1
+ sa=0.265 sb=0.265 sd=0.28 topography=normal area=0.063 perim=1.14
MMIP3 SUM net123 VPWR VPB pfet_01v8_hvt m=1 w=1.0 l=0.15 mult=1
+ sa=0.265 sb=0.265 sd=0.28 topography=normal area=0.063 perim=1.14
MI4 CIb mid1 net195 VPB pfet_01v8_hvt m=1 w=0.84 l=0.15 mult=1
+ sa=0.265 sb=0.265 sd=0.28 topography=normal area=0.063 perim=1.14
MI3 Bb mid2 net195 VPB pfet_01v8_hvt m=1 w=0.84 l=0.15 mult=1 sa=0.265
+ sb=0.265 sd=0.28 topography=normal area=0.063 perim=1.14
MI1 CIbb mid1 net123 VPB pfet_01v8_hvt m=1 w=0.84 l=0.15 mult=1
+ sa=0.265 sb=0.265 sd=0.28 topography=normal area=0.063 perim=1.14
MI650 CIb mid2 net123 VPB pfet_01v8_hvt m=1 w=0.84 l=0.15 mult=1
+ sa=0.265 sb=0.265 sd=0.28 topography=normal area=0.063 perim=1.14
MI16 Bb B VPWR VPB pfet_01v8_hvt m=1 w=1.0 l=0.15 mult=1 sa=0.265
+ sb=0.265 sd=0.28 topography=normal area=0.063 perim=1.14
MI47 CIbb CIb VPWR VPB pfet_01v8_hvt m=1 w=1.0 l=0.15 mult=1 sa=0.265
+ sb=0.265 sd=0.28 topography=normal area=0.063 perim=1.14
MI45 CIb CI VPWR VPB pfet_01v8_hvt m=1 w=1.0 l=0.15 mult=1 sa=0.265
+ sb=0.265 sd=0.28 topography=normal area=0.063 perim=1.14
MI12 Ab2 A VPWR VPB pfet_01v8_hvt m=1 w=1.0 l=0.15 mult=1 sa=0.265
+ sb=0.265 sd=0.28 topography=normal area=0.063 perim=1.14
MI13 Abb2 Ab2 VPWR VPB pfet_01v8_hvt m=1 w=1.0 l=0.15 mult=1 sa=0.265
+ sb=0.265 sd=0.28 topography=normal area=0.063 perim=1.14
MI19 Ab1 A VPWR VPB pfet_01v8_hvt m=1 w=1.0 l=0.15 mult=1 sa=0.265
+ sb=0.265 sd=0.28 topography=normal area=0.063 perim=1.14
MI22 Abb2 Bb mid1 VPB pfet_01v8_hvt m=1 w=0.84 l=0.15 mult=1 sa=0.265
+ sb=0.265 sd=0.28 topography=normal area=0.063 perim=1.14
MI23 Ab1 B mid1 VPB pfet_01v8_hvt m=1 w=0.84 l=0.15 mult=1 sa=0.265
+ sb=0.265 sd=0.28 topography=normal area=0.063 perim=1.14
MI26 Abb2 B mid2 VPB pfet_01v8_hvt m=1 w=0.84 l=0.15 mult=1 sa=0.265
+ sb=0.265 sd=0.28 topography=normal area=0.063 perim=1.14
MI27 Ab1 Bb mid2 VPB pfet_01v8_hvt m=1 w=0.84 l=0.15 mult=1 sa=0.265
+ sb=0.265 sd=0.28 topography=normal area=0.063 perim=1.14
.ENDS

.SUBCKT sky130_fd_sc_hd__fahcin_1 A B CIN VGND VNB VPB VPWR COUT SUM
MMIP3 SUM net144 VPWR VPB pfet_01v8_hvt m=1 w=1.0 l=0.15 mult=1
+ sa=0.265 sb=0.265 sd=0.28 topography=normal area=0.063 perim=1.14
MI32 Bbb Bb VPWR VPB pfet_01v8_hvt m=1 w=1.0 l=0.15 mult=1 sa=0.265
+ sb=0.265 sd=0.28 topography=normal area=0.063 perim=1.14
MI27 Ab Bb mid2 VPB pfet_01v8_hvt m=1 w=0.84 l=0.15 mult=1 sa=0.265
+ sb=0.265 sd=0.28 topography=normal area=0.063 perim=1.14
MI26 Abb B mid2 VPB pfet_01v8_hvt m=1 w=0.84 l=0.15 mult=1 sa=0.265
+ sb=0.265 sd=0.28 topography=normal area=0.063 perim=1.14
MI22 Abb Bb mid1 VPB pfet_01v8_hvt m=1 w=0.84 l=0.15 mult=1 sa=0.265
+ sb=0.265 sd=0.28 topography=normal area=0.063 perim=1.14
MI23 Ab B mid1 VPB pfet_01v8_hvt m=1 w=0.84 l=0.15 mult=1 sa=0.265
+ sb=0.265 sd=0.28 topography=normal area=0.063 perim=1.14
MI19 CINb1 CIN VPWR VPB pfet_01v8_hvt m=1 w=1.0 l=0.15 mult=1 sa=0.265
+ sb=0.265 sd=0.28 topography=normal area=0.063 perim=1.14
MI13 CINbb2 CINb2 VPWR VPB pfet_01v8_hvt m=1 w=1.0 l=0.15 mult=1
+ sa=0.265 sb=0.265 sd=0.28 topography=normal area=0.063 perim=1.14
MI47 Abb Ab VPWR VPB pfet_01v8_hvt m=1 w=1.0 l=0.15 mult=1 sa=0.265
+ sb=0.265 sd=0.28 topography=normal area=0.063 perim=1.14
MI12 CINb2 CIN VPWR VPB pfet_01v8_hvt m=1 w=1.0 l=0.15 mult=1 sa=0.265
+ sb=0.265 sd=0.28 topography=normal area=0.063 perim=1.14
MI16 Bb B VPWR VPB pfet_01v8_hvt m=1 w=1.0 l=0.15 mult=1 sa=0.265
+ sb=0.265 sd=0.28 topography=normal area=0.063 perim=1.14
MI650 CINbb2 mid2 net144 VPB pfet_01v8_hvt m=1 w=0.84 l=0.15 mult=1
+ sa=0.265 sb=0.265 sd=0.28 topography=normal area=0.063 perim=1.14
MI45 Ab A VPWR VPB pfet_01v8_hvt m=1 w=1.0 l=0.15 mult=1 sa=0.265
+ sb=0.265 sd=0.28 topography=normal area=0.063 perim=1.14
MI1 CINb2 mid1 net144 VPB pfet_01v8_hvt m=1 w=0.84 l=0.15 mult=1
+ sa=0.265 sb=0.265 sd=0.28 topography=normal area=0.063 perim=1.14
MI3 Bbb mid2 COUT VPB pfet_01v8_hvt m=1 w=0.84 l=0.15 mult=1 sa=0.265
+ sb=0.265 sd=0.28 topography=normal area=0.063 perim=1.14
MI4 CINb1 mid1 COUT VPB pfet_01v8_hvt m=1 w=0.84 l=0.15 mult=1
+ sa=0.265 sb=0.265 sd=0.28 topography=normal area=0.063 perim=1.14
MMIN3 SUM net144 VGND VNB nfet_01v8 m=1 w=0.65 l=0.15 mult=1 sa=0.265
+ sb=0.265 sd=0.28 topography=normal area=0.063 perim=1.14
MI6 CINb1 mid2 COUT VNB nfet_01v8 m=1 w=0.64 l=0.15 mult=1 sa=0.265
+ sb=0.265 sd=0.28 topography=normal area=0.063 perim=1.14
MI25 Ab B mid2 VNB nfet_01v8 m=1 w=0.64 l=0.15 mult=1 sa=0.265
+ sb=0.265 sd=0.28 topography=normal area=0.063 perim=1.14
MI24 Abb Bb mid2 VNB nfet_01v8 m=1 w=0.64 l=0.15 mult=1 sa=0.265
+ sb=0.265 sd=0.28 topography=normal area=0.063 perim=1.14
MI21 Ab Bb mid1 VNB nfet_01v8 m=1 w=0.64 l=0.15 mult=1 sa=0.265
+ sb=0.265 sd=0.28 topography=normal area=0.063 perim=1.14
MI20 Abb B mid1 VNB nfet_01v8 m=1 w=0.64 l=0.15 mult=1 sa=0.265
+ sb=0.265 sd=0.28 topography=normal area=0.063 perim=1.14
MI14 CINb1 CIN VGND VNB nfet_01v8 m=1 w=0.64 l=0.15 mult=1 sa=0.265
+ sb=0.265 sd=0.28 topography=normal area=0.063 perim=1.14
MI9 CINbb2 CINb2 VGND VNB nfet_01v8 m=1 w=0.64 l=0.15 mult=1 sa=0.265
+ sb=0.265 sd=0.28 topography=normal area=0.063 perim=1.14
MI8 CINb2 CIN VGND VNB nfet_01v8 m=1 w=0.65 l=0.15 mult=1 sa=0.265
+ sb=0.265 sd=0.28 topography=normal area=0.063 perim=1.14
MI44 Ab A VGND VNB nfet_01v8 m=1 w=0.65 l=0.15 mult=1 sa=0.265
+ sb=0.265 sd=0.28 topography=normal area=0.063 perim=1.14
MI46 Abb Ab VGND VNB nfet_01v8 m=1 w=0.64 l=0.15 mult=1 sa=0.265
+ sb=0.265 sd=0.28 topography=normal area=0.063 perim=1.14
MI17 Bb B VGND VNB nfet_01v8 m=1 w=0.65 l=0.15 mult=1 sa=0.265
+ sb=0.265 sd=0.28 topography=normal area=0.063 perim=1.14
MI649 CINbb2 mid1 net144 VNB nfet_01v8 m=1 w=0.64 l=0.15 mult=1
+ sa=0.265 sb=0.265 sd=0.28 topography=normal area=0.063 perim=1.14
MI2 CINb2 mid2 net144 VNB nfet_01v8 m=1 w=0.64 l=0.15 mult=1 sa=0.265
+ sb=0.265 sd=0.28 topography=normal area=0.063 perim=1.14
MI31 Bbb mid1 COUT VNB nfet_01v8 m=1 w=0.64 l=0.15 mult=1 sa=0.265
+ sb=0.265 sd=0.28 topography=normal area=0.063 perim=1.14
MI33 Bbb Bb VGND VNB nfet_01v8 m=1 w=0.64 l=0.15 mult=1 sa=0.265
+ sb=0.265 sd=0.28 topography=normal area=0.063 perim=1.14
.ENDS

.SUBCKT sky130_fd_sc_hd__fahcon_1 A B CI VGND VNB VPB VPWR COUT_N SUM
MMIP3 SUM net146 VPWR VPB pfet_01v8_hvt m=1 w=1.0 l=0.15 mult=1
+ sa=0.265 sb=0.265 sd=0.28 topography=normal area=0.063 perim=1.14
MI32 Bb2 B VPWR VPB pfet_01v8_hvt m=1 w=1.0 l=0.15 mult=1 sa=0.265
+ sb=0.265 sd=0.28 topography=normal area=0.063 perim=1.14
MI27 Ab Bb1 mid2 VPB pfet_01v8_hvt m=1 w=0.84 l=0.15 mult=1 sa=0.265
+ sb=0.265 sd=0.28 topography=normal area=0.063 perim=1.14
MI26 Abb B mid2 VPB pfet_01v8_hvt m=1 w=0.84 l=0.15 mult=1 sa=0.265
+ sb=0.265 sd=0.28 topography=normal area=0.063 perim=1.14
MI22 Abb Bb1 mid1 VPB pfet_01v8_hvt m=1 w=0.84 l=0.15 mult=1 sa=0.265
+ sb=0.265 sd=0.28 topography=normal area=0.063 perim=1.14
MI23 Ab B mid1 VPB pfet_01v8_hvt m=1 w=0.84 l=0.15 mult=1 sa=0.265
+ sb=0.265 sd=0.28 topography=normal area=0.063 perim=1.14
MI19 CIb1 CI VPWR VPB pfet_01v8_hvt m=1 w=1.0 l=0.15 mult=1 sa=0.265
+ sb=0.265 sd=0.28 topography=normal area=0.063 perim=1.14
MI13 CIbb2 CIb2 VPWR VPB pfet_01v8_hvt m=1 w=1.0 l=0.15 mult=1
+ sa=0.265 sb=0.265 sd=0.28 topography=normal area=0.063 perim=1.14
MI47 Abb Ab VPWR VPB pfet_01v8_hvt m=1 w=1.0 l=0.15 mult=1 sa=0.265
+ sb=0.265 sd=0.28 topography=normal area=0.063 perim=1.14
MI12 CIb2 CI VPWR VPB pfet_01v8_hvt m=1 w=1.0 l=0.15 mult=1 sa=0.265
+ sb=0.265 sd=0.28 topography=normal area=0.063 perim=1.14
MI16 Bb1 B VPWR VPB pfet_01v8_hvt m=1 w=1.0 l=0.15 mult=1 sa=0.265
+ sb=0.265 sd=0.28 topography=normal area=0.063 perim=1.14
MI650 CIb2 mid2 net146 VPB pfet_01v8_hvt m=1 w=0.84 l=0.15 mult=1
+ sa=0.265 sb=0.265 sd=0.28 topography=normal area=0.063 perim=1.14
MI45 Ab A VPWR VPB pfet_01v8_hvt m=1 w=1.0 l=0.15 mult=1 sa=0.265
+ sb=0.265 sd=0.28 topography=normal area=0.063 perim=1.14
MI1 CIbb2 mid1 net146 VPB pfet_01v8_hvt m=1 w=0.84 l=0.15 mult=1
+ sa=0.265 sb=0.265 sd=0.28 topography=normal area=0.063 perim=1.14
MI3 Bb2 mid2 COUT_N VPB pfet_01v8_hvt m=1 w=0.84 l=0.15 mult=1
+ sa=0.265 sb=0.265 sd=0.28 topography=normal area=0.063 perim=1.14
MI4 CIb1 mid1 COUT_N VPB pfet_01v8_hvt m=1 w=0.84 l=0.15 mult=1
+ sa=0.265 sb=0.265 sd=0.28 topography=normal area=0.063 perim=1.14
MMIN3 SUM net146 VGND VNB nfet_01v8 m=1 w=0.65 l=0.15 mult=1 sa=0.265
+ sb=0.265 sd=0.28 topography=normal area=0.063 perim=1.14
MI6 CIb1 mid2 COUT_N VNB nfet_01v8 m=1 w=0.64 l=0.15 mult=1 sa=0.265
+ sb=0.265 sd=0.28 topography=normal area=0.063 perim=1.14
MI25 Ab B mid2 VNB nfet_01v8 m=1 w=0.64 l=0.15 mult=1 sa=0.265
+ sb=0.265 sd=0.28 topography=normal area=0.063 perim=1.14
MI24 Abb Bb1 mid2 VNB nfet_01v8 m=1 w=0.64 l=0.15 mult=1 sa=0.265
+ sb=0.265 sd=0.28 topography=normal area=0.063 perim=1.14
MI21 Ab Bb1 mid1 VNB nfet_01v8 m=1 w=0.64 l=0.15 mult=1 sa=0.265
+ sb=0.265 sd=0.28 topography=normal area=0.063 perim=1.14
MI20 Abb B mid1 VNB nfet_01v8 m=1 w=0.64 l=0.15 mult=1 sa=0.265
+ sb=0.265 sd=0.28 topography=normal area=0.063 perim=1.14
MI14 CIb1 CI VGND VNB nfet_01v8 m=1 w=0.64 l=0.15 mult=1 sa=0.265
+ sb=0.265 sd=0.28 topography=normal area=0.063 perim=1.14
MI9 CIbb2 CIb2 VGND VNB nfet_01v8 m=1 w=0.64 l=0.15 mult=1 sa=0.265
+ sb=0.265 sd=0.28 topography=normal area=0.063 perim=1.14
MI8 CIb2 CI VGND VNB nfet_01v8 m=1 w=0.65 l=0.15 mult=1 sa=0.265
+ sb=0.265 sd=0.28 topography=normal area=0.063 perim=1.14
MI44 Ab A VGND VNB nfet_01v8 m=1 w=0.65 l=0.15 mult=1 sa=0.265
+ sb=0.265 sd=0.28 topography=normal area=0.063 perim=1.14
MI46 Abb Ab VGND VNB nfet_01v8 m=1 w=0.64 l=0.15 mult=1 sa=0.265
+ sb=0.265 sd=0.28 topography=normal area=0.063 perim=1.14
MI17 Bb1 B VGND VNB nfet_01v8 m=1 w=0.65 l=0.15 mult=1 sa=0.265
+ sb=0.265 sd=0.28 topography=normal area=0.063 perim=1.14
MI649 CIb2 mid1 net146 VNB nfet_01v8 m=1 w=0.64 l=0.15 mult=1 sa=0.265
+ sb=0.265 sd=0.28 topography=normal area=0.063 perim=1.14
MI2 CIbb2 mid2 net146 VNB nfet_01v8 m=1 w=0.64 l=0.15 mult=1 sa=0.265
+ sb=0.265 sd=0.28 topography=normal area=0.063 perim=1.14
MI31 Bb2 mid1 COUT_N VNB nfet_01v8 m=1 w=0.64 l=0.15 mult=1 sa=0.265
+ sb=0.265 sd=0.28 topography=normal area=0.063 perim=1.14
MI33 Bb2 B VGND VNB nfet_01v8 m=1 w=0.64 l=0.15 mult=1 sa=0.265
+ sb=0.265 sd=0.28 topography=normal area=0.063 perim=1.14
.ENDS

.SUBCKT sky130_fd_sc_hd__fill_1 VGND VNB VPB VPWR
.ENDS

.SUBCKT sky130_fd_sc_hd__fill_2 VGND VNB VPB VPWR
.ENDS

.SUBCKT sky130_fd_sc_hd__fill_4 VGND VNB VPB VPWR
.ENDS

.SUBCKT sky130_fd_sc_hd__fill_8 VGND VNB VPB VPWR
.ENDS

.SUBCKT sky130_fd_sc_hd__ha_1 A B VGND VNB VPB VPWR COUT SUM
MMIN2 COUT majb VGND VNB nfet_01v8 m=1 w=0.65 l=0.15 mult=1 sa=0.265
+ sb=0.265 sd=0.28 topography=normal area=0.063 perim=1.14
MMIN3 SUM sumb VGND VNB nfet_01v8 m=1 w=0.65 l=0.15 mult=1 sa=0.265
+ sb=0.265 sd=0.28 topography=normal area=0.063 perim=1.14
MMNnand0 VGND A sndNA VNB nfet_01v8 m=1 w=0.42 l=0.15 mult=1 sa=0.265
+ sb=0.265 sd=0.28 topography=normal area=0.063 perim=1.14
MMNnand1 sndNA B majb VNB nfet_01v8 m=1 w=0.42 l=0.15 mult=1 sa=0.265
+ sb=0.265 sd=0.28 topography=normal area=0.063 perim=1.14
MMNs1 sumb majb nint1 VNB nfet_01v8 m=1 w=0.42 l=0.15 mult=1 sa=0.265
+ sb=0.265 sd=0.28 topography=normal area=0.063 perim=1.14
MMNs20 VGND A nint1 VNB nfet_01v8 m=1 w=0.42 l=0.15 mult=1 sa=0.265
+ sb=0.265 sd=0.28 topography=normal area=0.063 perim=1.14
MMNs21 VGND B nint1 VNB nfet_01v8 m=1 w=0.42 l=0.15 mult=1 sa=0.265
+ sb=0.265 sd=0.28 topography=normal area=0.063 perim=1.14
MMIP2 COUT majb VPWR VPB pfet_01v8_hvt m=1 w=1.0 l=0.15 mult=1
+ sa=0.265 sb=0.265 sd=0.28 topography=normal area=0.063 perim=1.14
MMIP3 SUM sumb VPWR VPB pfet_01v8_hvt m=1 w=1.0 l=0.15 mult=1 sa=0.265
+ sb=0.265 sd=0.28 topography=normal area=0.063 perim=1.14
MMPnand0 majb A VPWR VPB pfet_01v8_hvt m=1 w=0.42 l=0.15 mult=1
+ sa=0.265 sb=0.265 sd=0.28 topography=normal area=0.063 perim=1.14
MMPnand1 majb B VPWR VPB pfet_01v8_hvt m=1 w=0.42 l=0.15 mult=1
+ sa=0.265 sb=0.265 sd=0.28 topography=normal area=0.063 perim=1.14
MMPs1 VPWR majb sumb VPB pfet_01v8_hvt m=1 w=0.42 l=0.15 mult=1
+ sa=0.265 sb=0.265 sd=0.28 topography=normal area=0.063 perim=1.14
MMPs20 VPWR A sndPA VPB pfet_01v8_hvt m=1 w=0.42 l=0.15 mult=1
+ sa=0.265 sb=0.265 sd=0.28 topography=normal area=0.063 perim=1.14
MMPs21 sndPA B sumb VPB pfet_01v8_hvt m=1 w=0.42 l=0.15 mult=1
+ sa=0.265 sb=0.265 sd=0.28 topography=normal area=0.063 perim=1.14
.ENDS

.SUBCKT sky130_fd_sc_hd__ha_2 A B VGND VNB VPB VPWR COUT SUM
MMIN2 COUT majb VGND VNB nfet_01v8 m=2 w=0.65 l=0.15 mult=1 sa=0.265
+ sb=0.265 sd=0.28 topography=normal area=0.063 perim=1.14
MMIN3 SUM sumb VGND VNB nfet_01v8 m=2 w=0.65 l=0.15 mult=1 sa=0.265
+ sb=0.265 sd=0.28 topography=normal area=0.063 perim=1.14
MMNnand0 VGND A sndNA VNB nfet_01v8 m=1 w=0.42 l=0.15 mult=1 sa=0.265
+ sb=0.265 sd=0.28 topography=normal area=0.063 perim=1.14
MMNnand1 sndNA B majb VNB nfet_01v8 m=1 w=0.42 l=0.15 mult=1 sa=0.265
+ sb=0.265 sd=0.28 topography=normal area=0.063 perim=1.14
MMNs1 sumb majb nint1 VNB nfet_01v8 m=1 w=0.42 l=0.15 mult=1 sa=0.265
+ sb=0.265 sd=0.28 topography=normal area=0.063 perim=1.14
MMNs20 VGND A nint1 VNB nfet_01v8 m=1 w=0.42 l=0.15 mult=1 sa=0.265
+ sb=0.265 sd=0.28 topography=normal area=0.063 perim=1.14
MMNs21 VGND B nint1 VNB nfet_01v8 m=1 w=0.42 l=0.15 mult=1 sa=0.265
+ sb=0.265 sd=0.28 topography=normal area=0.063 perim=1.14
MMIP2 COUT majb VPWR VPB pfet_01v8_hvt m=2 w=1.0 l=0.15 mult=1
+ sa=0.265 sb=0.265 sd=0.28 topography=normal area=0.063 perim=1.14
MMIP3 SUM sumb VPWR VPB pfet_01v8_hvt m=2 w=1.0 l=0.15 mult=1 sa=0.265
+ sb=0.265 sd=0.28 topography=normal area=0.063 perim=1.14
MMPnand0 majb A VPWR VPB pfet_01v8_hvt m=1 w=0.64 l=0.15 mult=1
+ sa=0.265 sb=0.265 sd=0.28 topography=normal area=0.063 perim=1.14
MMPnand1 majb B VPWR VPB pfet_01v8_hvt m=1 w=0.64 l=0.15 mult=1
+ sa=0.265 sb=0.265 sd=0.28 topography=normal area=0.063 perim=1.14
MMPs1 VPWR majb sumb VPB pfet_01v8_hvt m=1 w=0.64 l=0.15 mult=1
+ sa=0.265 sb=0.265 sd=0.28 topography=normal area=0.063 perim=1.14
MMPs20 VPWR A sndPA VPB pfet_01v8_hvt m=1 w=0.64 l=0.15 mult=1
+ sa=0.265 sb=0.265 sd=0.28 topography=normal area=0.063 perim=1.14
MMPs21 sndPA B sumb VPB pfet_01v8_hvt m=1 w=0.64 l=0.15 mult=1
+ sa=0.265 sb=0.265 sd=0.28 topography=normal area=0.063 perim=1.14
.ENDS

.SUBCKT sky130_fd_sc_hd__ha_4 A B VGND VNB VPB VPWR COUT SUM
MMIN2 COUT majb VGND VNB nfet_01v8 m=4 w=0.65 l=0.15 mult=1 sa=0.265
+ sb=0.265 sd=0.28 topography=normal area=0.063 perim=1.14
MMIN3 SUM sumb VGND VNB nfet_01v8 m=4 w=0.65 l=0.15 mult=1 sa=0.265
+ sb=0.265 sd=0.28 topography=normal area=0.063 perim=1.14
MMNnand0 VGND A sndNA VNB nfet_01v8 m=2 w=0.65 l=0.15 mult=1 sa=0.265
+ sb=0.265 sd=0.28 topography=normal area=0.063 perim=1.14
MMNnand1 sndNA B majb VNB nfet_01v8 m=2 w=0.65 l=0.15 mult=1 sa=0.265
+ sb=0.265 sd=0.28 topography=normal area=0.063 perim=1.14
MMNs1 sumb majb nint1 VNB nfet_01v8 m=2 w=0.65 l=0.15 mult=1 sa=0.265
+ sb=0.265 sd=0.28 topography=normal area=0.063 perim=1.14
MMNs20 VGND A nint1 VNB nfet_01v8 m=2 w=0.65 l=0.15 mult=1 sa=0.265
+ sb=0.265 sd=0.28 topography=normal area=0.063 perim=1.14
MMNs21 VGND B nint1 VNB nfet_01v8 m=2 w=0.65 l=0.15 mult=1 sa=0.265
+ sb=0.265 sd=0.28 topography=normal area=0.063 perim=1.14
MMIP2 COUT majb VPWR VPB pfet_01v8_hvt m=4 w=1.0 l=0.15 mult=1
+ sa=0.265 sb=0.265 sd=0.28 topography=normal area=0.063 perim=1.14
MMIP3 SUM sumb VPWR VPB pfet_01v8_hvt m=4 w=1.0 l=0.15 mult=1 sa=0.265
+ sb=0.265 sd=0.28 topography=normal area=0.063 perim=1.14
MMPnand0 majb A VPWR VPB pfet_01v8_hvt m=2 w=1.0 l=0.15 mult=1
+ sa=0.265 sb=0.265 sd=0.28 topography=normal area=0.063 perim=1.14
MMPnand1 majb B VPWR VPB pfet_01v8_hvt m=2 w=1.0 l=0.15 mult=1
+ sa=0.265 sb=0.265 sd=0.28 topography=normal area=0.063 perim=1.14
MMPs1 VPWR majb sumb VPB pfet_01v8_hvt m=2 w=1.0 l=0.15 mult=1
+ sa=0.265 sb=0.265 sd=0.28 topography=normal area=0.063 perim=1.14
MMPs20 VPWR A sndPA VPB pfet_01v8_hvt m=2 w=1.0 l=0.15 mult=1 sa=0.265
+ sb=0.265 sd=0.28 topography=normal area=0.063 perim=1.14
MMPs21 sndPA B sumb VPB pfet_01v8_hvt m=2 w=1.0 l=0.15 mult=1 sa=0.265
+ sb=0.265 sd=0.28 topography=normal area=0.063 perim=1.14
.ENDS

.SUBCKT sky130_fd_sc_hd__inv_1 A VGND VNB VPB VPWR Y
MMIN1 Y A VGND VNB nfet_01v8 m=1 w=0.65 l=0.15 mult=1 sa=0.265
+ sb=0.265 sd=0.28 topography=normal area=0.063 perim=1.14
MMIP1 Y A VPWR VPB pfet_01v8_hvt m=1 w=1.0 l=0.15 mult=1 sa=0.265
+ sb=0.265 sd=0.28 topography=normal area=0.063 perim=1.14
.ENDS

.SUBCKT sky130_fd_sc_hd__inv_2 A VGND VNB VPB VPWR Y
MMIN1 Y A VGND VNB nfet_01v8 m=2 w=0.65 l=0.15 mult=1 sa=0.265
+ sb=0.265 sd=0.28 topography=normal area=0.063 perim=1.14
MMIP1 Y A VPWR VPB pfet_01v8_hvt m=2 w=1.0 l=0.15 mult=1 sa=0.265
+ sb=0.265 sd=0.28 topography=normal area=0.063 perim=1.14
.ENDS

.SUBCKT sky130_fd_sc_hd__inv_4 A VGND VNB VPB VPWR Y
MMIP1 Y A VPWR VPB pfet_01v8_hvt m=4 w=1.0 l=0.15 mult=1 sa=0.265
+ sb=0.265 sd=0.28 topography=normal area=0.063 perim=1.14
MMIN1 Y A VGND VNB nfet_01v8 m=4 w=0.65 l=0.15 mult=1 sa=0.265
+ sb=0.265 sd=0.28 topography=normal area=0.063 perim=1.14
.ENDS

.SUBCKT sky130_fd_sc_hd__inv_6 A VGND VNB VPB VPWR Y
MMIN1 Y A VGND VNB nfet_01v8 m=6 w=0.65 l=0.15 mult=1 sa=0.265
+ sb=0.265 sd=0.28 topography=normal area=0.063 perim=1.14
MMIP1 Y A VPWR VPB pfet_01v8_hvt m=6 w=1.0 l=0.15 mult=1 sa=0.265
+ sb=0.265 sd=0.28 topography=normal area=0.063 perim=1.14
.ENDS

.SUBCKT sky130_fd_sc_hd__inv_8 A VGND VNB VPB VPWR Y
MMIP1 Y A VPWR VPB pfet_01v8_hvt m=8 w=1.0 l=0.15 mult=1 sa=0.265
+ sb=0.265 sd=0.28 topography=normal area=0.063 perim=1.14
MMIN1 Y A VGND VNB nfet_01v8 m=8 w=0.65 l=0.15 mult=1 sa=0.265
+ sb=0.265 sd=0.28 topography=normal area=0.063 perim=1.14
.ENDS

.SUBCKT sky130_fd_sc_hd__inv_12 A VGND VNB VPB VPWR Y
MMIN1 Y A VGND VNB nfet_01v8 m=12 w=0.65 l=0.15 mult=1 sa=0.265
+ sb=0.265 sd=0.28 topography=normal area=0.063 perim=1.14
MMIP1 Y A VPWR VPB pfet_01v8_hvt m=12 w=1.0 l=0.15 mult=1 sa=0.265
+ sb=0.265 sd=0.28 topography=normal area=0.063 perim=1.14
.ENDS

.SUBCKT sky130_fd_sc_hd__inv_16 A VGND VNB VPB VPWR Y
MMIN1 Y A VGND VNB nfet_01v8 m=16 w=0.65 l=0.15 mult=1 sa=0.265
+ sb=0.265 sd=0.28 topography=normal area=0.063 perim=1.14
MMIP1 Y A VPWR VPB pfet_01v8_hvt m=16 w=1.0 l=0.15 mult=1 sa=0.265
+ sb=0.265 sd=0.28 topography=normal area=0.063 perim=1.14
.ENDS

.SUBCKT sky130_fd_sc_hd__lpflow_bleeder_1 SHORT VGND VNB VPB VPWR
MI2 net29 SHORT net25 VNB nfet_01v8 m=1 w=0.36 l=0.15 mult=1 sa=0.265
+ sb=0.265 sd=0.28 topography=normal area=0.063 perim=1.14
MI3 net25 SHORT net24 VNB nfet_01v8 m=1 w=0.36 l=0.15 mult=1 sa=0.265
+ sb=0.265 sd=0.28 topography=normal area=0.063 perim=1.14
MI1 VPWR SHORT net29 VNB nfet_01v8 m=1 w=0.36 l=0.15 mult=1 sa=0.265
+ sb=0.265 sd=0.28 topography=normal area=0.063 perim=1.14
MI4 net24 SHORT net16 VNB nfet_01v8 m=1 w=0.36 l=0.15 mult=1 sa=0.265
+ sb=0.265 sd=0.28 topography=normal area=0.063 perim=1.14
MI7 net16 SHORT VGND VNB nfet_01v8 m=1 w=0.36 l=0.15 mult=1 sa=0.265
+ sb=0.265 sd=0.28 topography=normal area=0.063 perim=1.14
.ENDS

.SUBCKT sky130_fd_sc_hd__lpflow_clkbufkapwr_1 A KAPWR VGND VNB VPB VPWR X
MMIN0 Ab A VGND VNB nfet_01v8 m=1 w=0.52 l=0.15 mult=1 sa=0.265
+ sb=0.265 sd=0.28 topography=normal area=0.063 perim=1.14
MMIN1 X Ab VGND VNB nfet_01v8 m=1 w=0.52 l=0.15 mult=1 sa=0.265
+ sb=0.265 sd=0.28 topography=normal area=0.063 perim=1.14
MMIP0 Ab A KAPWR VPB pfet_01v8_hvt m=1 w=0.79 l=0.15 mult=1 sa=0.265
+ sb=0.265 sd=0.28 topography=normal area=0.063 perim=1.14
MMIP1 X Ab KAPWR VPB pfet_01v8_hvt m=1 w=0.79 l=0.15 mult=1 sa=0.265
+ sb=0.265 sd=0.28 topography=normal area=0.063 perim=1.14
.ENDS

.SUBCKT sky130_fd_sc_hd__lpflow_clkbufkapwr_2 A KAPWR VGND VNB VPB VPWR X
MMIN0 Ab A VGND VNB nfet_01v8 m=1 w=0.42 l=0.15 mult=1 sa=0.265
+ sb=0.265 sd=0.28 topography=normal area=0.063 perim=1.14
MMIN1 X Ab VGND VNB nfet_01v8 m=2 w=0.42 l=0.15 mult=1 sa=0.265
+ sb=0.265 sd=0.28 topography=normal area=0.063 perim=1.14
MMIP0 Ab A KAPWR VPB pfet_01v8_hvt m=1 w=1.0 l=0.15 mult=1 sa=0.265
+ sb=0.265 sd=0.28 topography=normal area=0.063 perim=1.14
MMIP1 X Ab KAPWR VPB pfet_01v8_hvt m=2 w=1.0 l=0.15 mult=1 sa=0.265
+ sb=0.265 sd=0.28 topography=normal area=0.063 perim=1.14
.ENDS

.SUBCKT sky130_fd_sc_hd__lpflow_clkbufkapwr_4 A KAPWR VGND VNB VPB VPWR X
MMIN0 Ab A VGND VNB nfet_01v8 m=1 w=0.42 l=0.15 mult=1 sa=0.265
+ sb=0.265 sd=0.28 topography=normal area=0.063 perim=1.14
MMIN1 X Ab VGND VNB nfet_01v8 m=4 w=0.42 l=0.15 mult=1 sa=0.265
+ sb=0.265 sd=0.28 topography=normal area=0.063 perim=1.14
MMIP0 Ab A KAPWR VPB pfet_01v8_hvt m=1 w=1.0 l=0.15 mult=1 sa=0.265
+ sb=0.265 sd=0.28 topography=normal area=0.063 perim=1.14
MMIP1 X Ab KAPWR VPB pfet_01v8_hvt m=4 w=1.0 l=0.15 mult=1 sa=0.265
+ sb=0.265 sd=0.28 topography=normal area=0.063 perim=1.14
.ENDS

.SUBCKT sky130_fd_sc_hd__lpflow_clkbufkapwr_8 A KAPWR VGND VNB VPB VPWR X
MMIN0 Ab A VGND VNB nfet_01v8 m=2 w=0.42 l=0.15 mult=1 sa=0.265
+ sb=0.265 sd=0.28 topography=normal area=0.063 perim=1.14
MMIN1 X Ab VGND VNB nfet_01v8 m=8 w=0.42 l=0.15 mult=1 sa=0.265
+ sb=0.265 sd=0.28 topography=normal area=0.063 perim=1.14
MMIP0 Ab A KAPWR VPB pfet_01v8_hvt m=2 w=1.0 l=0.15 mult=1 sa=0.265
+ sb=0.265 sd=0.28 topography=normal area=0.063 perim=1.14
MMIP1 X Ab KAPWR VPB pfet_01v8_hvt m=8 w=1.0 l=0.15 mult=1 sa=0.265
+ sb=0.265 sd=0.28 topography=normal area=0.063 perim=1.14
.ENDS

.SUBCKT sky130_fd_sc_hd__lpflow_clkbufkapwr_16 A KAPWR VGND VNB VPB VPWR X
MMIN0 Ab A VGND VNB nfet_01v8 m=4 w=0.42 l=0.15 mult=1 sa=0.265
+ sb=0.265 sd=0.28 topography=normal area=0.063 perim=1.14
MMIN1 X Ab VGND VNB nfet_01v8 m=16 w=0.42 l=0.15 mult=1 sa=0.265
+ sb=0.265 sd=0.28 topography=normal area=0.063 perim=1.14
MMIP0 Ab A KAPWR VPB pfet_01v8_hvt m=4 w=1.0 l=0.15 mult=1 sa=0.265
+ sb=0.265 sd=0.28 topography=normal area=0.063 perim=1.14
MMIP1 X Ab KAPWR VPB pfet_01v8_hvt m=16 w=1.0 l=0.15 mult=1 sa=0.265
+ sb=0.265 sd=0.28 topography=normal area=0.063 perim=1.14
.ENDS

.SUBCKT sky130_fd_sc_hd__lpflow_clkinvkapwr_1 A KAPWR VGND VNB VPB VPWR Y
MMIN0 Y A VGND VNB nfet_01v8 m=1 w=0.42 l=0.15 mult=1 sa=0.265
+ sb=0.265 sd=0.28 topography=normal area=0.063 perim=1.14
MMIP0 Y A KAPWR VPB pfet_01v8_hvt m=2 w=0.84 l=0.15 mult=1 sa=0.265
+ sb=0.265 sd=0.28 topography=normal area=0.063 perim=1.14
.ENDS

.SUBCKT sky130_fd_sc_hd__lpflow_clkinvkapwr_2 A KAPWR VGND VNB VPB VPWR Y
MMIN0 Y A VGND VNB nfet_01v8 m=2 w=0.42 l=0.15 mult=1 sa=0.265
+ sb=0.265 sd=0.28 topography=normal area=0.063 perim=1.14
MMIP0 Y A KAPWR VPB pfet_01v8_hvt m=3 w=1.0 l=0.15 mult=1 sa=0.265
+ sb=0.265 sd=0.28 topography=normal area=0.063 perim=1.14
.ENDS

.SUBCKT sky130_fd_sc_hd__lpflow_clkinvkapwr_4 A KAPWR VGND VNB VPB VPWR Y
MMIN0 Y A VGND VNB nfet_01v8 m=4 w=0.42 l=0.15 mult=1 sa=0.265
+ sb=0.265 sd=0.28 topography=normal area=0.063 perim=1.14
MMIP0 Y A KAPWR VPB pfet_01v8_hvt m=6 w=1.0 l=0.15 mult=1 sa=0.265
+ sb=0.265 sd=0.28 topography=normal area=0.063 perim=1.14
.ENDS

.SUBCKT sky130_fd_sc_hd__lpflow_clkinvkapwr_8 A KAPWR VGND VNB VPB VPWR Y
MMIN0 Y A VGND VNB nfet_01v8 m=8 w=0.42 l=0.15 mult=1 sa=0.265
+ sb=0.265 sd=0.28 topography=normal area=0.063 perim=1.14
MMIP0 Y A KAPWR VPB pfet_01v8_hvt m=12 w=1.0 l=0.15 mult=1 sa=0.265
+ sb=0.265 sd=0.28 topography=normal area=0.063 perim=1.14
.ENDS

.SUBCKT sky130_fd_sc_hd__lpflow_clkinvkapwr_16 A KAPWR VGND VNB VPB VPWR Y
MMIN0 Y A VGND VNB nfet_01v8 m=16 w=0.42 l=0.15 mult=1 sa=0.265
+ sb=0.265 sd=0.28 topography=normal area=0.063 perim=1.14
MMIP0 Y A KAPWR VPB pfet_01v8_hvt m=24 w=1.0 l=0.15 mult=1 sa=0.265
+ sb=0.265 sd=0.28 topography=normal area=0.063 perim=1.14
.ENDS

.SUBCKT sky130_fd_sc_hd__lpflow_decapkapwr_3 KAPWR VGND VNB VPB VPWR
MI1 VGND KAPWR VGND VNB nfet_01v8 m=1 w=0.55 l=0.59 mult=1 sa=0.265
+ sb=0.265 sd=0.28 topography=normal area=0.063 perim=1.14
MI2 KAPWR VGND KAPWR VPB pfet_01v8_hvt m=1 w=0.87 l=0.59 mult=1
+ sa=0.265 sb=0.265 sd=0.28 topography=normal area=0.063 perim=1.14
.ENDS

.SUBCKT sky130_fd_sc_hd__lpflow_decapkapwr_4 KAPWR VGND VNB VPB VPWR
MI1 VGND KAPWR VGND VNB nfet_01v8 m=1 w=0.55 l=1.05 mult=1 sa=0.265
+ sb=0.265 sd=0.28 topography=normal area=0.063 perim=1.14
MI2 KAPWR VGND KAPWR VPB pfet_01v8_hvt m=1 w=0.87 l=1.05 mult=1
+ sa=0.265 sb=0.265 sd=0.28 topography=normal area=0.063 perim=1.14
.ENDS

.SUBCKT sky130_fd_sc_hd__lpflow_decapkapwr_6 KAPWR VGND VNB VPB VPWR
MI1 VGND KAPWR VGND VNB nfet_01v8 m=1 w=0.55 l=1.97 mult=1 sa=0.265
+ sb=0.265 sd=0.28 topography=normal area=0.063 perim=1.14
MI2 KAPWR VGND KAPWR VPB pfet_01v8_hvt m=1 w=0.87 l=1.97 mult=1
+ sa=0.265 sb=0.265 sd=0.28 topography=normal area=0.063 perim=1.14
.ENDS

.SUBCKT sky130_fd_sc_hd__lpflow_decapkapwr_8 KAPWR VGND VNB VPB VPWR
MI1 VGND KAPWR VGND VNB nfet_01v8 m=1 w=0.55 l=2.89 mult=1 sa=0.265
+ sb=0.265 sd=0.28 topography=normal area=0.063 perim=1.14
MI2 KAPWR VGND KAPWR VPB pfet_01v8_hvt m=1 w=0.87 l=2.89 mult=1
+ sa=0.265 sb=0.265 sd=0.28 topography=normal area=0.063 perim=1.14
.ENDS

.SUBCKT sky130_fd_sc_hd__lpflow_decapkapwr_12 KAPWR VGND VNB VPB VPWR
MI1 VGND KAPWR VGND VNB nfet_01v8 m=1 w=0.55 l=4.73 mult=1 sa=0.265
+ sb=0.265 sd=0.28 topography=normal area=0.063 perim=1.14
MI2 KAPWR VGND KAPWR VPB pfet_01v8_hvt m=1 w=0.87 l=4.73 mult=1
+ sa=0.265 sb=0.265 sd=0.28 topography=normal area=0.063 perim=1.14
.ENDS

.SUBCKT sky130_fd_sc_hd__lpflow_inputiso0n_1 A SLEEP_B VGND VNB VPB VPWR X
MI14 X net36 VGND VNB nfet_01v8 m=1 w=0.65 l=0.15 mult=1 sa=0.265
+ sb=0.265 sd=0.28 topography=normal area=0.063 perim=1.14
MMN0 net36 A sndA VNB nfet_01v8 m=1 w=0.42 l=0.15 mult=1 sa=0.265
+ sb=0.265 sd=0.28 topography=normal area=0.063 perim=1.14
MI13 sndA SLEEP_B VGND VNB nfet_01v8 m=1 w=0.42 l=0.15 mult=1 sa=0.265
+ sb=0.265 sd=0.28 topography=normal area=0.063 perim=1.14
MMP1 net36 SLEEP_B VPWR VPB pfet_01v8_hvt m=1 w=0.42 l=0.15 mult=1
+ sa=0.265 sb=0.265 sd=0.28 topography=normal area=0.063 perim=1.14
MI19 X net36 VPWR VPB pfet_01v8_hvt m=1 w=1.0 l=0.15 mult=1 sa=0.265
+ sb=0.265 sd=0.28 topography=normal area=0.063 perim=1.14
MI17 net36 A VPWR VPB pfet_01v8_hvt m=1 w=0.42 l=0.15 mult=1 sa=0.265
+ sb=0.265 sd=0.28 topography=normal area=0.063 perim=1.14
.ENDS

.SUBCKT sky130_fd_sc_hd__lpflow_inputiso0p_1 A SLEEP VGND VNB VPB VPWR X
MI8 net36 A VPWR VPB pfet_01v8_hvt m=1 w=0.42 l=0.15 mult=1 sa=0.265
+ sb=0.265 sd=0.28 topography=normal area=0.063 perim=1.14
MI7 net36 sleepb VPWR VPB pfet_01v8_hvt m=1 w=0.42 l=0.15 mult=1
+ sa=0.265 sb=0.265 sd=0.28 topography=normal area=0.063 perim=1.14
MI20 X net36 VPWR VPB pfet_01v8_hvt m=1 w=1.0 l=0.15 mult=1 sa=0.265
+ sb=0.265 sd=0.28 topography=normal area=0.063 perim=1.14
MI19 sleepb SLEEP VPWR VPB pfet_01v8_hvt m=1 w=0.42 l=0.15 mult=1
+ sa=0.265 sb=0.265 sd=0.28 topography=normal area=0.063 perim=1.14
MI10 net36 sleepb sndA VNB nfet_01v8 m=1 w=0.42 l=0.15 mult=1 sa=0.265
+ sb=0.265 sd=0.28 topography=normal area=0.063 perim=1.14
MI21 X net36 VGND VNB nfet_01v8 m=1 w=0.65 l=0.15 mult=1 sa=0.265
+ sb=0.265 sd=0.28 topography=normal area=0.063 perim=1.14
MI18 sleepb SLEEP VGND VNB nfet_01v8 m=1 w=0.42 l=0.15 mult=1 sa=0.265
+ sb=0.265 sd=0.28 topography=normal area=0.063 perim=1.14
MI11 sndA A VGND VNB nfet_01v8 m=1 w=0.42 l=0.15 mult=1 sa=0.265
+ sb=0.265 sd=0.28 topography=normal area=0.063 perim=1.14
.ENDS

.SUBCKT sky130_fd_sc_hd__lpflow_inputiso1n_1 A SLEEP_B VGND VNB VPB VPWR X
MI23 VPWR A sndPA VPB pfet_01v8_hvt m=1 w=0.42 l=0.15 mult=1 sa=0.265
+ sb=0.265 sd=0.28 topography=normal area=0.063 perim=1.14
MI8 VPWR net44 X VPB pfet_01v8_hvt m=1 w=1.0 l=0.15 mult=1 sa=0.265
+ sb=0.265 sd=0.28 topography=normal area=0.063 perim=1.14
MMIP0 net56 SLEEP_B VPWR VPB pfet_01v8_hvt m=1 w=0.42 l=0.15 mult=1
+ sa=0.265 sb=0.265 sd=0.28 topography=normal area=0.063 perim=1.14
MI7 sndPA net56 net44 VPB pfet_01v8_hvt m=1 w=0.42 l=0.15 mult=1
+ sa=0.265 sb=0.265 sd=0.28 topography=normal area=0.063 perim=1.14
MMIN0 net56 SLEEP_B VGND VNB nfet_01v8 m=1 w=0.42 l=0.15 mult=1
+ sa=0.265 sb=0.265 sd=0.28 topography=normal area=0.063 perim=1.14
MI25 net44 A VGND VNB nfet_01v8 m=1 w=0.42 l=0.15 mult=1 sa=0.265
+ sb=0.265 sd=0.28 topography=normal area=0.063 perim=1.14
MMIN2 X net44 VGND VNB nfet_01v8 m=1 w=0.65 l=0.15 mult=1 sa=0.265
+ sb=0.265 sd=0.28 topography=normal area=0.063 perim=1.14
MI9 net44 net56 VGND VNB nfet_01v8 m=1 w=0.42 l=0.15 mult=1 sa=0.265
+ sb=0.265 sd=0.28 topography=normal area=0.063 perim=1.14
.ENDS

.SUBCKT sky130_fd_sc_hd__lpflow_inputiso1p_1 A SLEEP VGND VNB VPB VPWR X
MMP0 VPWR SLEEP sndPA VPB pfet_01v8_hvt m=1 w=0.42 l=0.15 mult=1
+ sa=0.265 sb=0.265 sd=0.28 topography=normal area=0.063 perim=1.14
MI7 sndPA A net36 VPB pfet_01v8_hvt m=1 w=0.42 l=0.15 mult=1 sa=0.265
+ sb=0.265 sd=0.28 topography=normal area=0.063 perim=1.14
MI15 VPWR net36 X VPB pfet_01v8_hvt m=1 w=1.0 l=0.15 mult=1 sa=0.265
+ sb=0.265 sd=0.28 topography=normal area=0.063 perim=1.14
MI10 net36 A VGND VNB nfet_01v8 m=1 w=0.42 l=0.15 mult=1 sa=0.265
+ sb=0.265 sd=0.28 topography=normal area=0.063 perim=1.14
MI16 net36 SLEEP VGND VNB nfet_01v8 m=1 w=0.42 l=0.15 mult=1 sa=0.265
+ sb=0.265 sd=0.28 topography=normal area=0.063 perim=1.14
MI14 X net36 VGND VNB nfet_01v8 m=1 w=0.65 l=0.15 mult=1 sa=0.265
+ sb=0.265 sd=0.28 topography=normal area=0.063 perim=1.14
.ENDS

.SUBCKT sky130_fd_sc_hd__lpflow_inputisolatch_1 D SLEEP_B VGND VNB VPB VPWR Q
MI677 Q s0 VGND VNB nfet_01v8 m=1 w=0.65 l=0.15 mult=1 sa=0.265
+ sb=0.265 sd=0.28 topography=normal area=0.063 perim=1.14
MI636 sleepneg sleeppos VGND VNB nfet_01v8 m=1 w=0.42 l=0.15 mult=1
+ sa=0.265 sb=0.265 sd=0.28 topography=normal area=0.063 perim=1.14
MI674 net39 s0 VGND VNB nfet_01v8 m=1 w=0.65 l=0.15 mult=1 sa=0.265
+ sb=0.265 sd=0.28 topography=normal area=0.063 perim=1.14
MI19 s0 sleepneg net49 VNB nfet_01v8 m=1 w=0.36 l=0.15 mult=1 sa=0.265
+ sb=0.265 sd=0.28 topography=normal area=0.063 perim=1.14
MI20 net49 D VGND VNB nfet_01v8 m=1 w=0.42 l=0.15 mult=1 sa=0.265
+ sb=0.265 sd=0.28 topography=normal area=0.063 perim=1.14
MI655 s0 sleeppos net38 VNB nfet_01v8 m=1 w=0.36 l=0.15 mult=1
+ sa=0.265 sb=0.265 sd=0.28 topography=normal area=0.063 perim=1.14
MI654 net38 net39 VGND VNB nfet_01v8 m=1 w=0.36 l=0.15 mult=1 sa=0.265
+ sb=0.265 sd=0.28 topography=normal area=0.063 perim=1.14
MI670 sleeppos SLEEP_B VGND VNB nfet_01v8 m=1 w=0.42 l=0.15 mult=1
+ sa=0.265 sb=0.265 sd=0.28 topography=normal area=0.063 perim=1.14
MI643 sleeppos SLEEP_B VPWR VPB pfet_01v8_hvt m=1 w=0.55 l=0.15 mult=1
+ sa=0.265 sb=0.265 sd=0.28 topography=normal area=0.063 perim=1.14
MI635 sleepneg sleeppos VPWR VPB pfet_01v8_hvt m=1 w=0.55 l=0.15
+ mult=1 sa=0.265 sb=0.265 sd=0.28 topography=normal area=0.063
+ perim=1.14
MI662 net86 net39 VPWR VPB pfet_01v8_hvt m=1 w=0.42 l=0.15 mult=1
+ sa=0.265 sb=0.265 sd=0.28 topography=normal area=0.063 perim=1.14
MI664 s0 sleepneg net86 VPB pfet_01v8_hvt m=1 w=0.42 l=0.15 mult=1
+ sa=0.265 sb=0.265 sd=0.28 topography=normal area=0.063 perim=1.14
MI658 net39 s0 VPWR VPB pfet_01v8_hvt m=1 w=1.0 l=0.15 mult=1 sa=0.265
+ sb=0.265 sd=0.28 topography=normal area=0.063 perim=1.14
MI663 Q s0 VPWR VPB pfet_01v8_hvt m=1 w=1.0 l=0.15 mult=1 sa=0.265
+ sb=0.265 sd=0.28 topography=normal area=0.063 perim=1.14
MI17 s0 sleeppos net69 VPB pfet_01v8_hvt m=1 w=0.42 l=0.15 mult=1
+ sa=0.265 sb=0.265 sd=0.28 topography=normal area=0.063 perim=1.14
MI18 net69 D VPWR VPB pfet_01v8_hvt m=1 w=0.64 l=0.15 mult=1 sa=0.265
+ sb=0.265 sd=0.28 topography=normal area=0.063 perim=1.14
.ENDS

.SUBCKT sky130_fd_sc_hd__lpflow_isobufsrc_1 A SLEEP VGND VNB VPB VPWR X
MMP0 VPWR SLEEP sndPA VPB pfet_01v8_hvt m=1 w=1.0 l=0.15 mult=1
+ sa=0.265 sb=0.265 sd=0.28 topography=normal area=0.063 perim=1.14
MMP1 sndPA Ab X VPB pfet_01v8_hvt m=1 w=1.0 l=0.15 mult=1 sa=0.265
+ sb=0.265 sd=0.28 topography=normal area=0.063 perim=1.14
MMIP1 Ab A VPWR VPB pfet_01v8_hvt m=1 w=0.42 l=0.15 mult=1 sa=0.265
+ sb=0.265 sd=0.28 topography=normal area=0.063 perim=1.14
MMN0 X SLEEP VGND VNB nfet_01v8 m=1 w=0.65 l=0.15 mult=1 sa=0.265
+ sb=0.265 sd=0.28 topography=normal area=0.063 perim=1.14
MMN1 X Ab VGND VNB nfet_01v8 m=1 w=0.65 l=0.15 mult=1 sa=0.265
+ sb=0.265 sd=0.28 topography=normal area=0.063 perim=1.14
MMIN1 Ab A VGND VNB nfet_01v8 m=1 w=0.42 l=0.15 mult=1 sa=0.265
+ sb=0.265 sd=0.28 topography=normal area=0.063 perim=1.14
.ENDS

.SUBCKT sky130_fd_sc_hd__lpflow_isobufsrc_2 A SLEEP VGND VNB VPB VPWR X
MMP0 VPWR SLEEP sndPA VPB pfet_01v8_hvt m=2 w=1.0 l=0.15 mult=1
+ sa=0.265 sb=0.265 sd=0.28 topography=normal area=0.063 perim=1.14
MMP1 sndPA Ab X VPB pfet_01v8_hvt m=2 w=1.0 l=0.15 mult=1 sa=0.265
+ sb=0.265 sd=0.28 topography=normal area=0.063 perim=1.14
MMIP1 Ab A VPWR VPB pfet_01v8_hvt m=1 w=0.42 l=0.15 mult=1 sa=0.265
+ sb=0.265 sd=0.28 topography=normal area=0.063 perim=1.14
MMN0 X SLEEP VGND VNB nfet_01v8 m=2 w=0.65 l=0.15 mult=1 sa=0.265
+ sb=0.265 sd=0.28 topography=normal area=0.063 perim=1.14
MMN1 X Ab VGND VNB nfet_01v8 m=2 w=0.65 l=0.15 mult=1 sa=0.265
+ sb=0.265 sd=0.28 topography=normal area=0.063 perim=1.14
MMIN1 Ab A VGND VNB nfet_01v8 m=1 w=0.42 l=0.15 mult=1 sa=0.265
+ sb=0.265 sd=0.28 topography=normal area=0.063 perim=1.14
.ENDS

.SUBCKT sky130_fd_sc_hd__lpflow_isobufsrc_4 A SLEEP VGND VNB VPB VPWR X
MMP0 VPWR SLEEP sndPA VPB pfet_01v8_hvt m=4 w=1.0 l=0.15 mult=1
+ sa=0.265 sb=0.265 sd=0.28 topography=normal area=0.063 perim=1.14
MMP1 sndPA Ab X VPB pfet_01v8_hvt m=4 w=1.0 l=0.15 mult=1 sa=0.265
+ sb=0.265 sd=0.28 topography=normal area=0.063 perim=1.14
MMIP1 Ab A VPWR VPB pfet_01v8_hvt m=1 w=1.0 l=0.15 mult=1 sa=0.265
+ sb=0.265 sd=0.28 topography=normal area=0.063 perim=1.14
MMN0 X SLEEP VGND VNB nfet_01v8 m=4 w=0.65 l=0.15 mult=1 sa=0.265
+ sb=0.265 sd=0.28 topography=normal area=0.063 perim=1.14
MMN1 X Ab VGND VNB nfet_01v8 m=4 w=0.65 l=0.15 mult=1 sa=0.265
+ sb=0.265 sd=0.28 topography=normal area=0.063 perim=1.14
MMIN1 Ab A VGND VNB nfet_01v8 m=1 w=0.65 l=0.15 mult=1 sa=0.265
+ sb=0.265 sd=0.28 topography=normal area=0.063 perim=1.14
.ENDS

.SUBCKT sky130_fd_sc_hd__lpflow_isobufsrc_8 A SLEEP VGND VNB VPB VPWR X
MMP0 VPWR Ab sndPA VPB pfet_01v8_hvt m=8 w=1.0 l=0.15 mult=1 sa=0.265
+ sb=0.265 sd=0.28 topography=normal area=0.063 perim=1.14
MMP1 sndPA SLEEP X VPB pfet_01v8_hvt m=8 w=1.0 l=0.15 mult=1 sa=0.265
+ sb=0.265 sd=0.28 topography=normal area=0.063 perim=1.14
MMIP1 Ab A VPWR VPB pfet_01v8_hvt m=2 w=1.0 l=0.15 mult=1 sa=0.265
+ sb=0.265 sd=0.28 topography=normal area=0.063 perim=1.14
MMN0 X SLEEP VGND VNB nfet_01v8 m=8 w=0.65 l=0.15 mult=1 sa=0.265
+ sb=0.265 sd=0.28 topography=normal area=0.063 perim=1.14
MMN1 X Ab VGND VNB nfet_01v8 m=8 w=0.65 l=0.15 mult=1 sa=0.265
+ sb=0.265 sd=0.28 topography=normal area=0.063 perim=1.14
MMIN1 Ab A VGND VNB nfet_01v8 m=2 w=0.65 l=0.15 mult=1 sa=0.265
+ sb=0.265 sd=0.28 topography=normal area=0.063 perim=1.14
.ENDS

.SUBCKT sky130_fd_sc_hd__lpflow_isobufsrc_16 A SLEEP VGND VNB VPB VPWR X
MMP0 VPWR Ab sndPA VPB pfet_01v8_hvt m=16 w=1.0 l=0.15 mult=1 sa=0.265
+ sb=0.265 sd=0.28 topography=normal area=0.063 perim=1.14
MMP1 sndPA SLEEP X VPB pfet_01v8_hvt m=16 w=1.0 l=0.15 mult=1 sa=0.265
+ sb=0.265 sd=0.28 topography=normal area=0.063 perim=1.14
MMIP1 Ab A VPWR VPB pfet_01v8_hvt m=4 w=1.0 l=0.15 mult=1 sa=0.265
+ sb=0.265 sd=0.28 topography=normal area=0.063 perim=1.14
MMN0 X SLEEP VGND VNB nfet_01v8 m=16 w=0.65 l=0.15 mult=1 sa=0.265
+ sb=0.265 sd=0.28 topography=normal area=0.063 perim=1.14
MMN1 X Ab VGND VNB nfet_01v8 m=16 w=0.65 l=0.15 mult=1 sa=0.265
+ sb=0.265 sd=0.28 topography=normal area=0.063 perim=1.14
MMIN1 Ab A VGND VNB nfet_01v8 m=4 w=0.65 l=0.15 mult=1 sa=0.265
+ sb=0.265 sd=0.28 topography=normal area=0.063 perim=1.14
.ENDS

.SUBCKT sky130_fd_sc_hd__lpflow_isobufsrckapwr_16 A SLEEP KAPWR VGND VNB VPB VPWR X
MMP0 VPWR SLEEP sndPA VPB pfet_01v8_hvt m=4 w=1.0 l=0.15 mult=1
+ sa=0.265 sb=0.265 sd=0.28 topography=normal area=0.063 perim=1.14
MMP1 sndPA net58 net66 VPB pfet_01v8_hvt m=4 w=1.0 l=0.15 mult=1
+ sa=0.265 sb=0.265 sd=0.28 topography=normal area=0.063 perim=1.14
MMIP1 net58 A VPWR VPB pfet_01v8_hvt m=1 w=1.0 l=0.15 mult=1 sa=0.265
+ sb=0.265 sd=0.28 topography=normal area=0.063 perim=1.14
MMIP0 Ab net66 KAPWR VPB pfet_01v8_hvt m=4 w=1.0 l=0.15 mult=1
+ sa=0.265 sb=0.265 sd=0.28 topography=normal area=0.063 perim=1.14
MI9 X Ab KAPWR VPB pfet_01v8_hvt m=16 w=1.0 l=0.15 mult=1 sa=0.265
+ sb=0.265 sd=0.28 topography=normal area=0.063 perim=1.14
MMN0 net66 SLEEP VGND VNB nfet_01v8 m=4 w=0.65 l=0.15 mult=1 sa=0.265
+ sb=0.265 sd=0.28 topography=normal area=0.063 perim=1.14
MMN1 net66 net58 VGND VNB nfet_01v8 m=4 w=0.65 l=0.15 mult=1 sa=0.265
+ sb=0.265 sd=0.28 topography=normal area=0.063 perim=1.14
MMIN1 net58 A VGND VNB nfet_01v8 m=1 w=0.65 l=0.15 mult=1 sa=0.265
+ sb=0.265 sd=0.28 topography=normal area=0.063 perim=1.14
MMIN0 Ab net66 VGND VNB nfet_01v8 m=4 w=0.42 l=0.15 mult=1 sa=0.265
+ sb=0.265 sd=0.28 topography=normal area=0.063 perim=1.14
MI8 X Ab VGND VNB nfet_01v8 m=16 w=0.42 l=0.15 mult=1 sa=0.265
+ sb=0.265 sd=0.28 topography=normal area=0.063 perim=1.14
.ENDS

.SUBCKT sky130_fd_sc_hd__lpflow_lsbuf_lh_hl_isowell_tap_1 A VGND VPB VPWRIN VPWR X
M1000 X a_1028_32# VPWR VPB pfet_01v8_hvt w=790000u l=150000u
+ ad=2.1725e+11p pd=2.13e+06u as=4.7795e+11p ps=4.37e+06u
M1001 VPWR a_620_911# a_714_58# VPB pfet_01v8_hvt w=790000u l=150000u
+ ad=0p pd=0u as=2.1725e+11p ps=2.13e+06u
M1002 a_1028_32# a_620_911# VPWR VPB pfet_01v8_hvt w=790000u l=150000u
+ ad=2.133e+11p pd=2.12e+06u as=0p ps=0u
M1003 X a_1028_32# VGND VGND nfet_01v8 w=650000u l=150000u
+ ad=1.8525e+11p pd=1.87e+06u as=1.4178e+12p ps=1.319e+07u
M1004 a_620_911# a_505_297# VGND VGND nfet_01v8 w=650000u l=150000u
+ ad=3.64e+11p pd=3.72e+06u as=0p ps=0u
M1005 a_714_58# A VGND VGND nfet_01v8 w=650000u l=150000u ad=3.64e+11p
+ pd=3.72e+06u as=0p ps=0u
M1006 a_714_58# A VGND VGND nfet_01v8 w=650000u l=150000u ad=0p pd=0u
+ as=0p ps=0u
M1007 VGND a_505_297# a_620_911# VGND nfet_01v8 w=650000u l=150000u
+ ad=0p pd=0u as=0p ps=0u
M1008 a_1028_32# a_620_911# VGND VGND nfet_01v8 w=650000u l=150000u
+ ad=1.7225e+11p pd=1.83e+06u as=0p ps=0u
M1009 a_505_297# A VPWRIN VPWRIN pfet_01v8_hvt w=1e+06u l=150000u
+ ad=2.75e+11p pd=2.55e+06u as=2.75e+11p ps=2.55e+06u
M1010 a_505_297# A VGND VGND nfet_01v8 w=420000u l=150000u
+ ad=1.113e+11p pd=1.37e+06u as=0p ps=0u
M1011 VGND A a_714_58# VGND nfet_01v8 w=650000u l=150000u ad=0p pd=0u
+ as=0p ps=0u
M1012 VGND A a_714_58# VGND nfet_01v8 w=650000u l=150000u ad=0p pd=0u
+ as=0p ps=0u
M1013 VGND a_505_297# a_620_911# VGND nfet_01v8 w=650000u l=150000u
+ ad=0p pd=0u as=0p ps=0u
M1014 a_620_911# a_505_297# VGND VGND nfet_01v8 w=650000u l=150000u
+ ad=0p pd=0u as=0p ps=0u
M1015 VPWR a_714_58# a_620_911# VPB pfet_01v8_hvt w=790000u l=150000u
+ ad=0p pd=0u as=2.1725e+11p ps=2.13e+06u
.ENDS

.SUBCKT sky130_fd_sc_hd__lpflow_lsbuf_lh_hl_isowell_tap_2 A VGND VPB VPWRIN VPWR X
M1000 VPWR a_620_911# a_714_47# VPB pfet_01v8_hvt w=790000u l=150000u
+ ad=8.352e+11p pd=7.41e+06u as=2.1725e+11p ps=2.13e+06u
M1001 a_1032_911# a_620_911# VPWR VPB pfet_01v8_hvt w=790000u
+ l=150000u ad=2.133e+11p pd=2.12e+06u as=0p ps=0u
M1002 a_620_911# a_505_297# VGND VGND nfet_01v8 w=650000u l=150000u
+ ad=3.64e+11p pd=3.72e+06u as=1.62905e+12p ps=1.514e+07u
M1003 a_714_47# A VGND VGND nfet_01v8 w=650000u l=150000u ad=3.64e+11p
+ pd=3.72e+06u as=0p ps=0u
M1004 a_714_47# A VGND VGND nfet_01v8 w=650000u l=150000u ad=0p pd=0u
+ as=0p ps=0u
M1005 X a_1032_911# VGND VGND nfet_01v8 w=650000u l=150000u
+ ad=2.405e+11p pd=2.04e+06u as=0p ps=0u
M1006 VPWR a_1032_911# X VPB pfet_01v8_hvt w=1e+06u l=150000u ad=0p
+ pd=0u as=3.7e+11p ps=2.74e+06u
M1007 VGND A a_714_47# VGND nfet_01v8 w=650000u l=150000u ad=0p pd=0u
+ as=0p ps=0u
M1008 VGND a_505_297# a_620_911# VGND nfet_01v8 w=650000u l=150000u
+ ad=0p pd=0u as=0p ps=0u
M1009 a_1032_911# a_620_911# VGND VGND nfet_01v8 w=650000u l=150000u
+ ad=1.7225e+11p pd=1.83e+06u as=0p ps=0u
M1010 VGND A a_714_47# VGND nfet_01v8 w=650000u l=150000u ad=0p pd=0u
+ as=0p ps=0u
M1011 a_505_297# A VPWRIN VPWRIN pfet_01v8_hvt w=1e+06u l=150000u
+ ad=2.75e+11p pd=2.55e+06u as=2.75e+11p ps=2.55e+06u
M1012 a_505_297# A VGND VGND nfet_01v8 w=420000u l=150000u
+ ad=1.113e+11p pd=1.37e+06u as=0p ps=0u
M1013 X a_1032_911# VPWR VPB pfet_01v8_hvt w=1e+06u l=150000u ad=0p
+ pd=0u as=0p ps=0u
M1014 VGND a_1032_911# X VGND nfet_01v8 w=650000u l=150000u ad=0p
+ pd=0u as=0p ps=0u
M1015 VGND a_505_297# a_620_911# VGND nfet_01v8 w=650000u l=150000u
+ ad=0p pd=0u as=0p ps=0u
M1016 a_620_911# a_505_297# VGND VGND nfet_01v8 w=650000u l=150000u
+ ad=0p pd=0u as=0p ps=0u
M1017 VPWR a_714_47# a_620_911# VPB pfet_01v8_hvt w=790000u l=150000u
+ ad=0p pd=0u as=2.1725e+11p ps=2.13e+06u
.ENDS

.SUBCKT sky130_fd_sc_hd__lpflow_lsbuf_lh_hl_isowell_tap_4 A VGND VPB VPWRIN VPWR X
M1000 VPWR a_620_911# a_714_47# VPB pfet_01v8_hvt w=790000u l=150000u
+ ad=1.1152e+12p pd=9.97e+06u as=2.1725e+11p ps=2.13e+06u
M1001 a_1032_911# a_620_911# VPWR VPB pfet_01v8_hvt w=790000u
+ l=150000u ad=2.133e+11p pd=2.12e+06u as=0p ps=0u
M1002 X a_1032_911# VPWR VPB pfet_01v8_hvt w=1e+06u l=150000u
+ ad=6.5e+11p pd=5.3e+06u as=0p ps=0u
M1003 a_620_911# a_505_297# VGND VGND nfet_01v8 w=650000u l=150000u
+ ad=3.64e+11p pd=3.72e+06u as=1.81105e+12p ps=1.7e+07u
M1004 a_714_47# A VGND VGND nfet_01v8 w=650000u l=150000u ad=3.64e+11p
+ pd=3.72e+06u as=0p ps=0u
M1005 a_714_47# A VGND VGND nfet_01v8 w=650000u l=150000u ad=0p pd=0u
+ as=0p ps=0u
M1006 X a_1032_911# VGND VGND nfet_01v8 w=650000u l=150000u
+ ad=4.225e+11p pd=3.9e+06u as=0p ps=0u
M1007 X a_1032_911# VGND VGND nfet_01v8 w=650000u l=150000u ad=0p
+ pd=0u as=0p ps=0u
M1008 VPWR a_1032_911# X VPB pfet_01v8_hvt w=1e+06u l=150000u ad=0p
+ pd=0u as=0p ps=0u
M1009 VGND A a_714_47# VGND nfet_01v8 w=650000u l=150000u ad=0p pd=0u
+ as=0p ps=0u
M1010 VGND a_505_297# a_620_911# VGND nfet_01v8 w=650000u l=150000u
+ ad=0p pd=0u as=0p ps=0u
M1011 a_1032_911# a_620_911# VGND VGND nfet_01v8 w=650000u l=150000u
+ ad=1.7225e+11p pd=1.83e+06u as=0p ps=0u
M1012 VGND A a_714_47# VGND nfet_01v8 w=650000u l=150000u ad=0p pd=0u
+ as=0p ps=0u
M1013 a_505_297# A VPWRIN VPWRIN pfet_01v8_hvt w=1e+06u l=150000u
+ ad=2.75e+11p pd=2.55e+06u as=2.75e+11p ps=2.55e+06u
M1014 a_505_297# A VGND VGND nfet_01v8 w=420000u l=150000u
+ ad=1.113e+11p pd=1.37e+06u as=0p ps=0u
M1015 X a_1032_911# VPWR VPB pfet_01v8_hvt w=1e+06u l=150000u ad=0p
+ pd=0u as=0p ps=0u
M1016 VPWR a_1032_911# X VPB pfet_01v8_hvt w=1e+06u l=150000u ad=0p
+ pd=0u as=0p ps=0u
M1017 VGND a_1032_911# X VGND nfet_01v8 w=650000u l=150000u ad=0p
+ pd=0u as=0p ps=0u
M1018 VGND a_1032_911# X VGND nfet_01v8 w=650000u l=150000u ad=0p
+ pd=0u as=0p ps=0u
M1019 VGND a_505_297# a_620_911# VGND nfet_01v8 w=650000u l=150000u
+ ad=0p pd=0u as=0p ps=0u
M1020 a_620_911# a_505_297# VGND VGND nfet_01v8 w=650000u l=150000u
+ ad=0p pd=0u as=0p ps=0u
M1021 VPWR a_714_47# a_620_911# VPB pfet_01v8_hvt w=790000u l=150000u
+ ad=0p pd=0u as=2.1725e+11p ps=2.13e+06u
.ENDS

.SUBCKT sky130_fd_sc_hd__lpflow_lsbuf_lh_isowell_4 A LOWLVPWR VGND VNB VPB VPWR X
MI2 net72 cross1 VPWR VPB pfet_01v8_hvt m=1 w=0.79 l=0.15 mult=1
+ sa=0.265 sb=0.265 sd=0.28 topography=normal area=0.063 perim=1.14
MI3 cross1 net72 VPWR VPB pfet_01v8_hvt m=1 w=0.79 l=0.15 mult=1
+ sa=0.265 sb=0.265 sd=0.28 topography=normal area=0.063 perim=1.14
MI20 Ab A LOWLVPWR LOWLVPWR pfet_01v8_hvt m=1 w=1.0 l=0.15 mult=1
+ sa=0.265 sb=0.265 sd=0.28 topography=normal area=0.063 perim=1.14
MI24 X net60 VPWR VPB pfet_01v8_hvt m=4 w=1.0 l=0.15 mult=1 sa=0.265
+ sb=0.265 sd=0.28 topography=normal area=0.063 perim=1.14
MI28 net60 cross1 VPWR VPB pfet_01v8_hvt m=1 w=0.79 l=0.15 mult=1
+ sa=0.265 sb=0.265 sd=0.28 topography=normal area=0.063 perim=1.14
MI5 cross1 Ab VGND VNB nfet_01v8 m=4 w=0.65 l=0.15 mult=1 sa=0.265
+ sb=0.265 sd=0.28 topography=normal area=0.063 perim=1.14
MI4 net72 A VGND VNB nfet_01v8 m=4 w=0.65 l=0.15 mult=1 sa=0.265
+ sb=0.265 sd=0.28 topography=normal area=0.063 perim=1.14
MI23 Ab A VGND VNB nfet_01v8 m=1 w=0.42 l=0.15 mult=1 sa=0.265
+ sb=0.265 sd=0.28 topography=normal area=0.063 perim=1.14
MI25 X net60 VGND VNB nfet_01v8 m=4 w=0.65 l=0.15 mult=1 sa=0.265
+ sb=0.265 sd=0.28 topography=normal area=0.063 perim=1.14
MI29 net60 cross1 VGND VNB nfet_01v8 m=1 w=0.65 l=0.15 mult=1 sa=0.265
+ sb=0.265 sd=0.28 topography=normal area=0.063 perim=1.14
.ENDS

.SUBCKT sky130_fd_sc_hd__lpflow_lsbuf_lh_isowell_tap_1 A LOWLVPWR VGND VPB VPWR X
M1000 X a_1028_32# VPWR VPB pfet_01v8_hvt w=790000u l=150000u
+ ad=2.1725e+11p pd=2.13e+06u as=4.7795e+11p ps=4.37e+06u
M1001 VPWR a_620_911# a_714_58# VPB pfet_01v8_hvt w=790000u l=150000u
+ ad=0p pd=0u as=2.1725e+11p ps=2.13e+06u
M1002 a_1028_32# a_620_911# VPWR VPB pfet_01v8_hvt w=790000u l=150000u
+ ad=2.133e+11p pd=2.12e+06u as=0p ps=0u
M1003 X a_1028_32# VGND VGND nfet_01v8 w=650000u l=150000u
+ ad=1.8525e+11p pd=1.87e+06u as=1.4178e+12p ps=1.319e+07u
M1004 a_620_911# a_505_297# VGND VGND nfet_01v8 w=650000u l=150000u
+ ad=3.64e+11p pd=3.72e+06u as=0p ps=0u
M1005 a_714_58# A VGND VGND nfet_01v8 w=650000u l=150000u ad=3.64e+11p
+ pd=3.72e+06u as=0p ps=0u
M1006 a_714_58# A VGND VGND nfet_01v8 w=650000u l=150000u ad=0p pd=0u
+ as=0p ps=0u
M1007 VGND a_505_297# a_620_911# VGND nfet_01v8 w=650000u l=150000u
+ ad=0p pd=0u as=0p ps=0u
M1008 a_1028_32# a_620_911# VGND VGND nfet_01v8 w=650000u l=150000u
+ ad=1.7225e+11p pd=1.83e+06u as=0p ps=0u
M1009 a_505_297# A LOWLVPWR LOWLVPWR pfet_01v8_hvt w=1e+06u l=150000u
+ ad=2.75e+11p pd=2.55e+06u as=2.75e+11p ps=2.55e+06u
M1010 a_505_297# A VGND VGND nfet_01v8 w=420000u l=150000u
+ ad=1.113e+11p pd=1.37e+06u as=0p ps=0u
M1011 VGND A a_714_58# VGND nfet_01v8 w=650000u l=150000u ad=0p pd=0u
+ as=0p ps=0u
M1012 VGND A a_714_58# VGND nfet_01v8 w=650000u l=150000u ad=0p pd=0u
+ as=0p ps=0u
M1013 VGND a_505_297# a_620_911# VGND nfet_01v8 w=650000u l=150000u
+ ad=0p pd=0u as=0p ps=0u
M1014 a_620_911# a_505_297# VGND VGND nfet_01v8 w=650000u l=150000u
+ ad=0p pd=0u as=0p ps=0u
M1015 VPWR a_714_58# a_620_911# VPB pfet_01v8_hvt w=790000u l=150000u
+ ad=0p pd=0u as=2.1725e+11p ps=2.13e+06u
.ENDS

.SUBCKT sky130_fd_sc_hd__lpflow_lsbuf_lh_isowell_tap_2 A LOWLVPWR VGND VPB VPWR X
M1000 VPWR a_620_911# a_714_47# VPB pfet_01v8_hvt w=790000u l=150000u
+ ad=8.352e+11p pd=7.41e+06u as=2.1725e+11p ps=2.13e+06u
M1001 a_1032_911# a_620_911# VPWR VPB pfet_01v8_hvt w=790000u
+ l=150000u ad=2.133e+11p pd=2.12e+06u as=0p ps=0u
M1002 a_620_911# a_505_297# VGND VGND nfet_01v8 w=650000u l=150000u
+ ad=3.64e+11p pd=3.72e+06u as=1.62905e+12p ps=1.514e+07u
M1003 a_714_47# A VGND VGND nfet_01v8 w=650000u l=150000u ad=3.64e+11p
+ pd=3.72e+06u as=0p ps=0u
M1004 a_714_47# A VGND VGND nfet_01v8 w=650000u l=150000u ad=0p pd=0u
+ as=0p ps=0u
M1005 X a_1032_911# VGND VGND nfet_01v8 w=650000u l=150000u
+ ad=2.405e+11p pd=2.04e+06u as=0p ps=0u
M1006 VPWR a_1032_911# X VPB pfet_01v8_hvt w=1e+06u l=150000u ad=0p
+ pd=0u as=3.7e+11p ps=2.74e+06u
M1007 VGND A a_714_47# VGND nfet_01v8 w=650000u l=150000u ad=0p pd=0u
+ as=0p ps=0u
M1008 VGND a_505_297# a_620_911# VGND nfet_01v8 w=650000u l=150000u
+ ad=0p pd=0u as=0p ps=0u
M1009 a_1032_911# a_620_911# VGND VGND nfet_01v8 w=650000u l=150000u
+ ad=1.7225e+11p pd=1.83e+06u as=0p ps=0u
M1010 VGND A a_714_47# VGND nfet_01v8 w=650000u l=150000u ad=0p pd=0u
+ as=0p ps=0u
M1011 a_505_297# A LOWLVPWR LOWLVPWR pfet_01v8_hvt w=1e+06u l=150000u
+ ad=2.75e+11p pd=2.55e+06u as=2.75e+11p ps=2.55e+06u
M1012 a_505_297# A VGND VGND nfet_01v8 w=420000u l=150000u
+ ad=1.113e+11p pd=1.37e+06u as=0p ps=0u
M1013 X a_1032_911# VPWR VPB pfet_01v8_hvt w=1e+06u l=150000u ad=0p
+ pd=0u as=0p ps=0u
M1014 VGND a_1032_911# X VGND nfet_01v8 w=650000u l=150000u ad=0p
+ pd=0u as=0p ps=0u
M1015 VGND a_505_297# a_620_911# VGND nfet_01v8 w=650000u l=150000u
+ ad=0p pd=0u as=0p ps=0u
M1016 a_620_911# a_505_297# VGND VGND nfet_01v8 w=650000u l=150000u
+ ad=0p pd=0u as=0p ps=0u
M1017 VPWR a_714_47# a_620_911# VPB pfet_01v8_hvt w=790000u l=150000u
+ ad=0p pd=0u as=2.1725e+11p ps=2.13e+06u
.ENDS

.SUBCKT sky130_fd_sc_hd__lpflow_lsbuf_lh_isowell_tap_4 A LOWLVPWR VGND VPB VPWR X
M1000 VPWR a_620_911# a_714_47# VPB pfet_01v8_hvt w=790000u l=150000u
+ ad=1.1152e+12p pd=9.97e+06u as=2.1725e+11p ps=2.13e+06u
M1001 a_1032_911# a_620_911# VPWR VPB pfet_01v8_hvt w=790000u
+ l=150000u ad=2.133e+11p pd=2.12e+06u as=0p ps=0u
M1002 X a_1032_911# VPWR VPB pfet_01v8_hvt w=1e+06u l=150000u
+ ad=6.5e+11p pd=5.3e+06u as=0p ps=0u
M1003 a_620_911# a_505_297# VGND VGND nfet_01v8 w=650000u l=150000u
+ ad=3.64e+11p pd=3.72e+06u as=1.81105e+12p ps=1.7e+07u
M1004 a_714_47# A VGND VGND nfet_01v8 w=650000u l=150000u ad=3.64e+11p
+ pd=3.72e+06u as=0p ps=0u
M1005 a_714_47# A VGND VGND nfet_01v8 w=650000u l=150000u ad=0p pd=0u
+ as=0p ps=0u
M1006 X a_1032_911# VGND VGND nfet_01v8 w=650000u l=150000u
+ ad=4.225e+11p pd=3.9e+06u as=0p ps=0u
M1007 X a_1032_911# VGND VGND nfet_01v8 w=650000u l=150000u ad=0p
+ pd=0u as=0p ps=0u
M1008 VPWR a_1032_911# X VPB pfet_01v8_hvt w=1e+06u l=150000u ad=0p
+ pd=0u as=0p ps=0u
M1009 VGND A a_714_47# VGND nfet_01v8 w=650000u l=150000u ad=0p pd=0u
+ as=0p ps=0u
M1010 VGND a_505_297# a_620_911# VGND nfet_01v8 w=650000u l=150000u
+ ad=0p pd=0u as=0p ps=0u
M1011 a_1032_911# a_620_911# VGND VGND nfet_01v8 w=650000u l=150000u
+ ad=1.7225e+11p pd=1.83e+06u as=0p ps=0u
M1012 VGND A a_714_47# VGND nfet_01v8 w=650000u l=150000u ad=0p pd=0u
+ as=0p ps=0u
M1013 a_505_297# A LOWLVPWR LOWLVPWR pfet_01v8_hvt w=1e+06u l=150000u
+ ad=2.75e+11p pd=2.55e+06u as=2.75e+11p ps=2.55e+06u
M1014 a_505_297# A VGND VGND nfet_01v8 w=420000u l=150000u
+ ad=1.113e+11p pd=1.37e+06u as=0p ps=0u
M1015 X a_1032_911# VPWR VPB pfet_01v8_hvt w=1e+06u l=150000u ad=0p
+ pd=0u as=0p ps=0u
M1016 VPWR a_1032_911# X VPB pfet_01v8_hvt w=1e+06u l=150000u ad=0p
+ pd=0u as=0p ps=0u
M1017 VGND a_1032_911# X VGND nfet_01v8 w=650000u l=150000u ad=0p
+ pd=0u as=0p ps=0u
M1018 VGND a_1032_911# X VGND nfet_01v8 w=650000u l=150000u ad=0p
+ pd=0u as=0p ps=0u
M1019 VGND a_505_297# a_620_911# VGND nfet_01v8 w=650000u l=150000u
+ ad=0p pd=0u as=0p ps=0u
M1020 a_620_911# a_505_297# VGND VGND nfet_01v8 w=650000u l=150000u
+ ad=0p pd=0u as=0p ps=0u
M1021 VPWR a_714_47# a_620_911# VPB pfet_01v8_hvt w=790000u l=150000u
+ ad=0p pd=0u as=2.1725e+11p ps=2.13e+06u
.ENDS

.SUBCKT sky130_fd_sc_hd__macro_sparecell VGND VNB VPB VPWR LO
XI1 VGND VNB VPB VPWR net59 LO / sky130_fd_sc_hd__conb_1
XI2 LO LO VGND VNB VPB VPWR nd2right / sky130_fd_sc_hd__nand2_2
XI3 LO LO VGND VNB VPB VPWR nd2left / sky130_fd_sc_hd__nand2_2
XI4 nd2right nd2right VGND VNB VPB VPWR nor2right / sky130_fd_sc_hd__nor2_2
XI5 nd2left nd2left VGND VNB VPB VPWR nor2left / sky130_fd_sc_hd__nor2_2
XI6 nor2right VGND VNB VPB VPWR invright / sky130_fd_sc_hd__inv_2
XI7 nor2left VGND VNB VPB VPWR invleft / sky130_fd_sc_hd__inv_2
.ENDS

.SUBCKT sky130_fd_sc_hd__maj3_1 A B C VGND VNB VPB VPWR X
MMIN2 X y VGND VNB nfet_01v8 m=1 w=0.65 l=0.15 mult=1 sa=0.265
+ sb=0.265 sd=0.28 topography=normal area=0.063 perim=1.14
MMN10 y B sndNBa VNB nfet_01v8 m=1 w=0.42 l=0.15 mult=1 sa=0.265
+ sb=0.265 sd=0.28 topography=normal area=0.063 perim=1.14
MMN11 sndNBa A VGND VNB nfet_01v8 m=1 w=0.42 l=0.15 mult=1 sa=0.265
+ sb=0.265 sd=0.28 topography=normal area=0.063 perim=1.14
MMN20 y B sndNBc VNB nfet_01v8 m=1 w=0.42 l=0.15 mult=1 sa=0.265
+ sb=0.265 sd=0.28 topography=normal area=0.063 perim=1.14
MMN21 sndNBc C VGND VNB nfet_01v8 m=1 w=0.42 l=0.15 mult=1 sa=0.265
+ sb=0.265 sd=0.28 topography=normal area=0.063 perim=1.14
MMN30 y C sndNCa VNB nfet_01v8 m=1 w=0.42 l=0.15 mult=1 sa=0.265
+ sb=0.265 sd=0.28 topography=normal area=0.063 perim=1.14
MMN31 sndNCa A VGND VNB nfet_01v8 m=1 w=0.42 l=0.15 mult=1 sa=0.265
+ sb=0.265 sd=0.28 topography=normal area=0.063 perim=1.14
MMIP2 X y VPWR VPB pfet_01v8_hvt m=1 w=1.0 l=0.15 mult=1 sa=0.265
+ sb=0.265 sd=0.28 topography=normal area=0.063 perim=1.14
MMP10 VPWR A sndPAb VPB pfet_01v8_hvt m=1 w=0.42 l=0.15 mult=1
+ sa=0.265 sb=0.265 sd=0.28 topography=normal area=0.063 perim=1.14
MMP11 sndPAb B y VPB pfet_01v8_hvt m=1 w=0.42 l=0.15 mult=1 sa=0.265
+ sb=0.265 sd=0.28 topography=normal area=0.063 perim=1.14
MMP20 VPWR C sndPCb VPB pfet_01v8_hvt m=1 w=0.42 l=0.15 mult=1
+ sa=0.265 sb=0.265 sd=0.28 topography=normal area=0.063 perim=1.14
MMP21 sndPCb B y VPB pfet_01v8_hvt m=1 w=0.42 l=0.15 mult=1 sa=0.265
+ sb=0.265 sd=0.28 topography=normal area=0.063 perim=1.14
MMP30 VPWR A sndPAc VPB pfet_01v8_hvt m=1 w=0.42 l=0.15 mult=1
+ sa=0.265 sb=0.265 sd=0.28 topography=normal area=0.063 perim=1.14
MMP31 sndPAc C y VPB pfet_01v8_hvt m=1 w=0.42 l=0.15 mult=1 sa=0.265
+ sb=0.265 sd=0.28 topography=normal area=0.063 perim=1.14
.ENDS

.SUBCKT sky130_fd_sc_hd__maj3_2 A B C VGND VNB VPB VPWR X
MMIN2 X y VGND VNB nfet_01v8 m=2 w=0.65 l=0.15 mult=1 sa=0.265
+ sb=0.265 sd=0.28 topography=normal area=0.063 perim=1.14
MMN10 y B sndNBa VNB nfet_01v8 m=1 w=0.42 l=0.15 mult=1 sa=0.265
+ sb=0.265 sd=0.28 topography=normal area=0.063 perim=1.14
MMN11 sndNBa A VGND VNB nfet_01v8 m=1 w=0.42 l=0.15 mult=1 sa=0.265
+ sb=0.265 sd=0.28 topography=normal area=0.063 perim=1.14
MMN20 y B sndNBc VNB nfet_01v8 m=1 w=0.42 l=0.15 mult=1 sa=0.265
+ sb=0.265 sd=0.28 topography=normal area=0.063 perim=1.14
MMN21 sndNBc C VGND VNB nfet_01v8 m=1 w=0.42 l=0.15 mult=1 sa=0.265
+ sb=0.265 sd=0.28 topography=normal area=0.063 perim=1.14
MMN30 y C sndNCa VNB nfet_01v8 m=1 w=0.42 l=0.15 mult=1 sa=0.265
+ sb=0.265 sd=0.28 topography=normal area=0.063 perim=1.14
MMN31 sndNCa A VGND VNB nfet_01v8 m=1 w=0.42 l=0.15 mult=1 sa=0.265
+ sb=0.265 sd=0.28 topography=normal area=0.063 perim=1.14
MMIP2 X y VPWR VPB pfet_01v8_hvt m=2 w=1.0 l=0.15 mult=1 sa=0.265
+ sb=0.265 sd=0.28 topography=normal area=0.063 perim=1.14
MMP10 VPWR A sndPAb VPB pfet_01v8_hvt m=1 w=0.64 l=0.15 mult=1
+ sa=0.265 sb=0.265 sd=0.28 topography=normal area=0.063 perim=1.14
MMP11 sndPAb B y VPB pfet_01v8_hvt m=1 w=0.64 l=0.15 mult=1 sa=0.265
+ sb=0.265 sd=0.28 topography=normal area=0.063 perim=1.14
MMP20 VPWR C sndPCb VPB pfet_01v8_hvt m=1 w=0.64 l=0.15 mult=1
+ sa=0.265 sb=0.265 sd=0.28 topography=normal area=0.063 perim=1.14
MMP21 sndPCb B y VPB pfet_01v8_hvt m=1 w=0.64 l=0.15 mult=1 sa=0.265
+ sb=0.265 sd=0.28 topography=normal area=0.063 perim=1.14
MMP30 VPWR A sndPAc VPB pfet_01v8_hvt m=1 w=0.64 l=0.15 mult=1
+ sa=0.265 sb=0.265 sd=0.28 topography=normal area=0.063 perim=1.14
MMP31 sndPAc C y VPB pfet_01v8_hvt m=1 w=0.64 l=0.15 mult=1 sa=0.265
+ sb=0.265 sd=0.28 topography=normal area=0.063 perim=1.14
.ENDS

.SUBCKT sky130_fd_sc_hd__maj3_4 A B C VGND VNB VPB VPWR X
MMIN2 X y VGND VNB nfet_01v8 m=4 w=0.65 l=0.15 mult=1 sa=0.265
+ sb=0.265 sd=0.28 topography=normal area=0.063 perim=1.14
MMN10 y B sndNBa VNB nfet_01v8 m=1 w=0.65 l=0.15 mult=1 sa=0.265
+ sb=0.265 sd=0.28 topography=normal area=0.063 perim=1.14
MMN11 sndNBa A VGND VNB nfet_01v8 m=1 w=0.65 l=0.15 mult=1 sa=0.265
+ sb=0.265 sd=0.28 topography=normal area=0.063 perim=1.14
MMN20 y B sndNBc VNB nfet_01v8 m=1 w=0.65 l=0.15 mult=1 sa=0.265
+ sb=0.265 sd=0.28 topography=normal area=0.063 perim=1.14
MMN21 sndNBc C VGND VNB nfet_01v8 m=1 w=0.65 l=0.15 mult=1 sa=0.265
+ sb=0.265 sd=0.28 topography=normal area=0.063 perim=1.14
MMN30 y C sndNCa VNB nfet_01v8 m=1 w=0.65 l=0.15 mult=1 sa=0.265
+ sb=0.265 sd=0.28 topography=normal area=0.063 perim=1.14
MMN31 sndNCa A VGND VNB nfet_01v8 m=1 w=0.65 l=0.15 mult=1 sa=0.265
+ sb=0.265 sd=0.28 topography=normal area=0.063 perim=1.14
MMIP2 X y VPWR VPB pfet_01v8_hvt m=4 w=1.0 l=0.15 mult=1 sa=0.265
+ sb=0.265 sd=0.28 topography=normal area=0.063 perim=1.14
MMP10 VPWR A sndPAb VPB pfet_01v8_hvt m=1 w=1.0 l=0.15 mult=1 sa=0.265
+ sb=0.265 sd=0.28 topography=normal area=0.063 perim=1.14
MMP11 sndPAb B y VPB pfet_01v8_hvt m=1 w=1.0 l=0.15 mult=1 sa=0.265
+ sb=0.265 sd=0.28 topography=normal area=0.063 perim=1.14
MMP20 VPWR C sndPCb VPB pfet_01v8_hvt m=1 w=1.0 l=0.15 mult=1 sa=0.265
+ sb=0.265 sd=0.28 topography=normal area=0.063 perim=1.14
MMP21 sndPCb B y VPB pfet_01v8_hvt m=1 w=1.0 l=0.15 mult=1 sa=0.265
+ sb=0.265 sd=0.28 topography=normal area=0.063 perim=1.14
MMP30 VPWR A sndPAc VPB pfet_01v8_hvt m=1 w=1.0 l=0.15 mult=1 sa=0.265
+ sb=0.265 sd=0.28 topography=normal area=0.063 perim=1.14
MMP31 sndPAc C y VPB pfet_01v8_hvt m=1 w=1.0 l=0.15 mult=1 sa=0.265
+ sb=0.265 sd=0.28 topography=normal area=0.063 perim=1.14
.ENDS

.SUBCKT sky130_fd_sc_hd__mux2_1 A0 A1 S VGND VNB VPB VPWR X
MMNA00 xb A0 smdNA0 VNB nfet_01v8 m=1 w=0.42 l=0.15 mult=1 sa=0.265
+ sb=0.265 sd=0.28 topography=normal area=0.063 perim=1.14
MMNA01 smdNA0 Sb VGND VNB nfet_01v8 m=1 w=0.42 l=0.15 mult=1 sa=0.265
+ sb=0.265 sd=0.28 topography=normal area=0.063 perim=1.14
MMNA10 xb A1 sndNA1 VNB nfet_01v8 m=1 w=0.42 l=0.15 mult=1 sa=0.265
+ sb=0.265 sd=0.28 topography=normal area=0.063 perim=1.14
MMNA11 sndNA1 S VGND VNB nfet_01v8 m=1 w=0.42 l=0.15 mult=1 sa=0.265
+ sb=0.265 sd=0.28 topography=normal area=0.063 perim=1.14
MMIN1 Sb S VGND VNB nfet_01v8 m=1 w=0.42 l=0.15 mult=1 sa=0.265
+ sb=0.265 sd=0.28 topography=normal area=0.063 perim=1.14
MMIN2 X xb VGND VNB nfet_01v8 m=1 w=0.65 l=0.15 mult=1 sa=0.265
+ sb=0.265 sd=0.28 topography=normal area=0.063 perim=1.14
MMPA00 VPWR S sndPS VPB pfet_01v8_hvt m=1 w=0.42 l=0.15 mult=1
+ sa=0.265 sb=0.265 sd=0.28 topography=normal area=0.063 perim=1.14
MMPA01 sndPS A0 xb VPB pfet_01v8_hvt m=1 w=0.42 l=0.15 mult=1 sa=0.265
+ sb=0.265 sd=0.28 topography=normal area=0.063 perim=1.14
MMPA10 VPWR Sb sndPSb VPB pfet_01v8_hvt m=1 w=0.42 l=0.15 mult=1
+ sa=0.265 sb=0.265 sd=0.28 topography=normal area=0.063 perim=1.14
MMPA11 sndPSb A1 xb VPB pfet_01v8_hvt m=1 w=0.42 l=0.15 mult=1
+ sa=0.265 sb=0.265 sd=0.28 topography=normal area=0.063 perim=1.14
MMIP1 Sb S VPWR VPB pfet_01v8_hvt m=1 w=0.42 l=0.15 mult=1 sa=0.265
+ sb=0.265 sd=0.28 topography=normal area=0.063 perim=1.14
MMIP2 X xb VPWR VPB pfet_01v8_hvt m=1 w=1.0 l=0.15 mult=1 sa=0.265
+ sb=0.265 sd=0.28 topography=normal area=0.063 perim=1.14
.ENDS

.SUBCKT sky130_fd_sc_hd__mux2_2 A0 A1 S VGND VNB VPB VPWR X
MMNA00 xb A0 smdNA0 VNB nfet_01v8 m=1 w=0.42 l=0.15 mult=1 sa=0.265
+ sb=0.265 sd=0.28 topography=normal area=0.063 perim=1.14
MMNA01 smdNA0 Sb VGND VNB nfet_01v8 m=1 w=0.42 l=0.15 mult=1 sa=0.265
+ sb=0.265 sd=0.28 topography=normal area=0.063 perim=1.14
MMNA10 xb A1 sndNA1 VNB nfet_01v8 m=1 w=0.42 l=0.15 mult=1 sa=0.265
+ sb=0.265 sd=0.28 topography=normal area=0.063 perim=1.14
MMNA11 sndNA1 S VGND VNB nfet_01v8 m=1 w=0.42 l=0.15 mult=1 sa=0.265
+ sb=0.265 sd=0.28 topography=normal area=0.063 perim=1.14
MMIN1 Sb S VGND VNB nfet_01v8 m=1 w=0.42 l=0.15 mult=1 sa=0.265
+ sb=0.265 sd=0.28 topography=normal area=0.063 perim=1.14
MMIN2 X xb VGND VNB nfet_01v8 m=2 w=0.65 l=0.15 mult=1 sa=0.265
+ sb=0.265 sd=0.28 topography=normal area=0.063 perim=1.14
MMPA00 VPWR S sndPS VPB pfet_01v8_hvt m=1 w=0.64 l=0.15 mult=1
+ sa=0.265 sb=0.265 sd=0.28 topography=normal area=0.063 perim=1.14
MMPA01 sndPS A0 xb VPB pfet_01v8_hvt m=1 w=0.64 l=0.15 mult=1 sa=0.265
+ sb=0.265 sd=0.28 topography=normal area=0.063 perim=1.14
MMPA10 VPWR Sb sndPSb VPB pfet_01v8_hvt m=1 w=0.64 l=0.15 mult=1
+ sa=0.265 sb=0.265 sd=0.28 topography=normal area=0.063 perim=1.14
MMPA11 sndPSb A1 xb VPB pfet_01v8_hvt m=1 w=0.64 l=0.15 mult=1
+ sa=0.265 sb=0.265 sd=0.28 topography=normal area=0.063 perim=1.14
MMIP1 Sb S VPWR VPB pfet_01v8_hvt m=1 w=0.64 l=0.15 mult=1 sa=0.265
+ sb=0.265 sd=0.28 topography=normal area=0.063 perim=1.14
MMIP2 X xb VPWR VPB pfet_01v8_hvt m=2 w=1.0 l=0.15 mult=1 sa=0.265
+ sb=0.265 sd=0.28 topography=normal area=0.063 perim=1.14
.ENDS

.SUBCKT sky130_fd_sc_hd__mux2_4 A0 A1 S VGND VNB VPB VPWR X
MMNA00 xb A0 smdNA0 VNB nfet_01v8 m=1 w=0.65 l=0.15 mult=1 sa=0.265
+ sb=0.265 sd=0.28 topography=normal area=0.063 perim=1.14
MMNA01 smdNA0 Sb VGND VNB nfet_01v8 m=1 w=0.65 l=0.15 mult=1 sa=0.265
+ sb=0.265 sd=0.28 topography=normal area=0.063 perim=1.14
MMNA10 xb A1 sndNA1 VNB nfet_01v8 m=1 w=0.65 l=0.15 mult=1 sa=0.265
+ sb=0.265 sd=0.28 topography=normal area=0.063 perim=1.14
MMNA11 sndNA1 S VGND VNB nfet_01v8 m=1 w=0.65 l=0.15 mult=1 sa=0.265
+ sb=0.265 sd=0.28 topography=normal area=0.063 perim=1.14
MMIN1 Sb S VGND VNB nfet_01v8 m=1 w=0.65 l=0.15 mult=1 sa=0.265
+ sb=0.265 sd=0.28 topography=normal area=0.063 perim=1.14
MMIN2 X xb VGND VNB nfet_01v8 m=4 w=0.65 l=0.15 mult=1 sa=0.265
+ sb=0.265 sd=0.28 topography=normal area=0.063 perim=1.14
MMPA00 VPWR S sndPS VPB pfet_01v8_hvt m=1 w=1.0 l=0.15 mult=1 sa=0.265
+ sb=0.265 sd=0.28 topography=normal area=0.063 perim=1.14
MMPA01 sndPS A0 xb VPB pfet_01v8_hvt m=1 w=1.0 l=0.15 mult=1 sa=0.265
+ sb=0.265 sd=0.28 topography=normal area=0.063 perim=1.14
MMPA10 VPWR Sb sndPSb VPB pfet_01v8_hvt m=1 w=1.0 l=0.15 mult=1
+ sa=0.265 sb=0.265 sd=0.28 topography=normal area=0.063 perim=1.14
MMPA11 sndPSb A1 xb VPB pfet_01v8_hvt m=1 w=1.0 l=0.15 mult=1 sa=0.265
+ sb=0.265 sd=0.28 topography=normal area=0.063 perim=1.14
MMIP1 Sb S VPWR VPB pfet_01v8_hvt m=1 w=1.0 l=0.15 mult=1 sa=0.265
+ sb=0.265 sd=0.28 topography=normal area=0.063 perim=1.14
MMIP2 X xb VPWR VPB pfet_01v8_hvt m=4 w=1.0 l=0.15 mult=1 sa=0.265
+ sb=0.265 sd=0.28 topography=normal area=0.063 perim=1.14
.ENDS

.SUBCKT sky130_fd_sc_hd__mux2_8 A0 A1 S VGND VNB VPB VPWR X
MMNA00 xb A0 smdNA0 VNB nfet_01v8 m=2 w=0.64 l=0.15 mult=1 sa=0.265
+ sb=0.265 sd=0.28 topography=normal area=0.063 perim=1.14
MMNA01 smdNA0 Sb VGND VNB nfet_01v8 m=2 w=0.64 l=0.15 mult=1 sa=0.265
+ sb=0.265 sd=0.28 topography=normal area=0.063 perim=1.14
MMNA10 xb A1 sndNA1 VNB nfet_01v8 m=2 w=0.64 l=0.15 mult=1 sa=0.265
+ sb=0.265 sd=0.28 topography=normal area=0.063 perim=1.14
MMNA11 sndNA1 S VGND VNB nfet_01v8 m=2 w=0.64 l=0.15 mult=1 sa=0.265
+ sb=0.265 sd=0.28 topography=normal area=0.063 perim=1.14
MMIN1 Sb S VGND VNB nfet_01v8 m=1 w=0.65 l=0.15 mult=1 sa=0.265
+ sb=0.265 sd=0.28 topography=normal area=0.063 perim=1.14
MMIN2 X xb VGND VNB nfet_01v8 m=8 w=0.65 l=0.15 mult=1 sa=0.265
+ sb=0.265 sd=0.28 topography=normal area=0.063 perim=1.14
MMPA00 VPWR S sndPS VPB pfet_01v8_hvt m=2 w=1.0 l=0.15 mult=1 sa=0.265
+ sb=0.265 sd=0.28 topography=normal area=0.063 perim=1.14
MMPA01 sndPS A0 xb VPB pfet_01v8_hvt m=2 w=1.0 l=0.15 mult=1 sa=0.265
+ sb=0.265 sd=0.28 topography=normal area=0.063 perim=1.14
MMPA10 VPWR Sb sndPSb VPB pfet_01v8_hvt m=2 w=1.0 l=0.15 mult=1
+ sa=0.265 sb=0.265 sd=0.28 topography=normal area=0.063 perim=1.14
MMPA11 sndPSb A1 xb VPB pfet_01v8_hvt m=2 w=1.0 l=0.15 mult=1 sa=0.265
+ sb=0.265 sd=0.28 topography=normal area=0.063 perim=1.14
MMIP1 Sb S VPWR VPB pfet_01v8_hvt m=1 w=1.0 l=0.15 mult=1 sa=0.265
+ sb=0.265 sd=0.28 topography=normal area=0.063 perim=1.14
MMIP2 X xb VPWR VPB pfet_01v8_hvt m=8 w=1.0 l=0.15 mult=1 sa=0.265
+ sb=0.265 sd=0.28 topography=normal area=0.063 perim=1.14
.ENDS

.SUBCKT sky130_fd_sc_hd__mux2i_1 A0 A1 S VGND VNB VPB VPWR Y
MMNA00 Y A0 smdNA0 VNB nfet_01v8 m=1 w=0.65 l=0.15 mult=1 sa=0.265
+ sb=0.265 sd=0.28 topography=normal area=0.063 perim=1.14
MMNA01 smdNA0 Sb VGND VNB nfet_01v8 m=1 w=0.65 l=0.15 mult=1 sa=0.265
+ sb=0.265 sd=0.28 topography=normal area=0.063 perim=1.14
MMNA10 Y A1 sndNA1 VNB nfet_01v8 m=1 w=0.65 l=0.15 mult=1 sa=0.265
+ sb=0.265 sd=0.28 topography=normal area=0.063 perim=1.14
MMNA11 sndNA1 S VGND VNB nfet_01v8 m=1 w=0.65 l=0.15 mult=1 sa=0.265
+ sb=0.265 sd=0.28 topography=normal area=0.063 perim=1.14
MMIN1 Sb S VGND VNB nfet_01v8 m=1 w=0.65 l=0.15 mult=1 sa=0.265
+ sb=0.265 sd=0.28 topography=normal area=0.063 perim=1.14
MMPA00 VPWR S sndPS VPB pfet_01v8_hvt m=1 w=1.0 l=0.15 mult=1 sa=0.265
+ sb=0.265 sd=0.28 topography=normal area=0.063 perim=1.14
MMPA01 sndPS A0 Y VPB pfet_01v8_hvt m=1 w=1.0 l=0.15 mult=1 sa=0.265
+ sb=0.265 sd=0.28 topography=normal area=0.063 perim=1.14
MMPA10 VPWR Sb sndPSb VPB pfet_01v8_hvt m=1 w=1.0 l=0.15 mult=1
+ sa=0.265 sb=0.265 sd=0.28 topography=normal area=0.063 perim=1.14
MMPA11 sndPSb A1 Y VPB pfet_01v8_hvt m=1 w=1.0 l=0.15 mult=1 sa=0.265
+ sb=0.265 sd=0.28 topography=normal area=0.063 perim=1.14
MMIP1 Sb S VPWR VPB pfet_01v8_hvt m=1 w=1.0 l=0.15 mult=1 sa=0.265
+ sb=0.265 sd=0.28 topography=normal area=0.063 perim=1.14
.ENDS

.SUBCKT sky130_fd_sc_hd__mux2i_2 A0 A1 S VGND VNB VPB VPWR Y
MMNA00 Y A0 smdNA0 VNB nfet_01v8 m=2 w=0.65 l=0.15 mult=1 sa=0.265
+ sb=0.265 sd=0.28 topography=normal area=0.063 perim=1.14
MMNA01 smdNA0 Sb VGND VNB nfet_01v8 m=2 w=0.65 l=0.15 mult=1 sa=0.265
+ sb=0.265 sd=0.28 topography=normal area=0.063 perim=1.14
MMNA10 Y A1 sndNA1 VNB nfet_01v8 m=2 w=0.65 l=0.15 mult=1 sa=0.265
+ sb=0.265 sd=0.28 topography=normal area=0.063 perim=1.14
MMNA11 sndNA1 S VGND VNB nfet_01v8 m=2 w=0.65 l=0.15 mult=1 sa=0.265
+ sb=0.265 sd=0.28 topography=normal area=0.063 perim=1.14
MMIN1 Sb S VGND VNB nfet_01v8 m=1 w=0.65 l=0.15 mult=1 sa=0.265
+ sb=0.265 sd=0.28 topography=normal area=0.063 perim=1.14
MMPA00 VPWR S sndPS VPB pfet_01v8_hvt m=2 w=1.0 l=0.15 mult=1 sa=0.265
+ sb=0.265 sd=0.28 topography=normal area=0.063 perim=1.14
MMPA01 sndPS A0 Y VPB pfet_01v8_hvt m=2 w=1.0 l=0.15 mult=1 sa=0.265
+ sb=0.265 sd=0.28 topography=normal area=0.063 perim=1.14
MMPA10 VPWR Sb sndPSb VPB pfet_01v8_hvt m=2 w=1.0 l=0.15 mult=1
+ sa=0.265 sb=0.265 sd=0.28 topography=normal area=0.063 perim=1.14
MMPA11 sndPSb A1 Y VPB pfet_01v8_hvt m=2 w=1.0 l=0.15 mult=1 sa=0.265
+ sb=0.265 sd=0.28 topography=normal area=0.063 perim=1.14
MMIP1 Sb S VPWR VPB pfet_01v8_hvt m=1 w=1.0 l=0.15 mult=1 sa=0.265
+ sb=0.265 sd=0.28 topography=normal area=0.063 perim=1.14
.ENDS

.SUBCKT sky130_fd_sc_hd__mux2i_4 A0 A1 S VGND VNB VPB VPWR Y
MMNA00 Y A0 smdNA0 VNB nfet_01v8 m=4 w=0.65 l=0.15 mult=1 sa=0.265
+ sb=0.265 sd=0.28 topography=normal area=0.063 perim=1.14
MMNA01 smdNA0 Sb VGND VNB nfet_01v8 m=4 w=0.65 l=0.15 mult=1 sa=0.265
+ sb=0.265 sd=0.28 topography=normal area=0.063 perim=1.14
MMNA10 Y A1 sndNA1 VNB nfet_01v8 m=4 w=0.65 l=0.15 mult=1 sa=0.265
+ sb=0.265 sd=0.28 topography=normal area=0.063 perim=1.14
MMNA11 sndNA1 S VGND VNB nfet_01v8 m=4 w=0.65 l=0.15 mult=1 sa=0.265
+ sb=0.265 sd=0.28 topography=normal area=0.063 perim=1.14
MMIN1 Sb S VGND VNB nfet_01v8 m=1 w=0.65 l=0.15 mult=1 sa=0.265
+ sb=0.265 sd=0.28 topography=normal area=0.063 perim=1.14
MMPA00 VPWR S sndPS VPB pfet_01v8_hvt m=4 w=1.0 l=0.15 mult=1 sa=0.265
+ sb=0.265 sd=0.28 topography=normal area=0.063 perim=1.14
MMPA01 sndPS A0 Y VPB pfet_01v8_hvt m=4 w=1.0 l=0.15 mult=1 sa=0.265
+ sb=0.265 sd=0.28 topography=normal area=0.063 perim=1.14
MMPA10 VPWR Sb sndPSb VPB pfet_01v8_hvt m=4 w=1.0 l=0.15 mult=1
+ sa=0.265 sb=0.265 sd=0.28 topography=normal area=0.063 perim=1.14
MMPA11 sndPSb A1 Y VPB pfet_01v8_hvt m=4 w=1.0 l=0.15 mult=1 sa=0.265
+ sb=0.265 sd=0.28 topography=normal area=0.063 perim=1.14
MMIP1 Sb S VPWR VPB pfet_01v8_hvt m=1 w=1.0 l=0.15 mult=1 sa=0.265
+ sb=0.265 sd=0.28 topography=normal area=0.063 perim=1.14
.ENDS

.SUBCKT sky130_fd_sc_hd__mux4_1 A0 A1 A2 A3 S0 S1 VGND VNB VPB VPWR X
MMNA00 sndNS0ba0 S0b xlowb VNB nfet_01v8 m=1 w=0.42 l=0.15 mult=1
+ sa=0.265 sb=0.265 sd=0.28 topography=normal area=0.028 perim=0.76
MMNA01 VGND A0 sndNS0ba0 VNB nfet_01v8 m=1 w=0.42 l=0.15 mult=1
+ sa=0.265 sb=0.265 sd=0.28 topography=normal area=0.028 perim=0.76
MMNA10 sndNS0a1 S0 xlowb VNB nfet_01v8 m=1 w=0.42 l=0.15 mult=1
+ sa=0.265 sb=0.265 sd=0.28 topography=normal area=0.028 perim=0.76
MMNA11 VGND A1 sndNS0a1 VNB nfet_01v8 m=1 w=0.42 l=0.15 mult=1
+ sa=0.265 sb=0.265 sd=0.28 topography=normal area=0.028 perim=0.76
MMNA20 sndNS0ba2 S0b xhib VNB nfet_01v8 m=1 w=0.42 l=0.15 mult=1
+ sa=0.265 sb=0.265 sd=0.28 topography=normal area=0.028 perim=0.76
MMNA21 VGND A2 sndNS0ba2 VNB nfet_01v8 m=1 w=0.42 l=0.15 mult=1
+ sa=0.265 sb=0.265 sd=0.28 topography=normal area=0.028 perim=0.76
MMNA30 sndNS0a3 S0 xhib VNB nfet_01v8 m=1 w=0.42 l=0.15 mult=1
+ sa=0.265 sb=0.265 sd=0.28 topography=normal area=0.028 perim=0.76
MMNA31 VGND A3 sndNS0a3 VNB nfet_01v8 m=1 w=0.42 l=0.15 mult=1
+ sa=0.265 sb=0.265 sd=0.28 topography=normal area=0.028 perim=0.76
MMNs1o xb S1b xlowb VNB nfet_01v8 m=1 w=0.42 l=0.15 mult=1 sa=0.265
+ sb=0.265 sd=0.28 topography=normal area=0.028 perim=0.76
MMNs2o xb S1 xhib VNB nfet_01v8 m=1 w=0.42 l=0.15 mult=1 sa=0.265
+ sb=0.265 sd=0.28 topography=normal area=0.028 perim=0.76
MMIN1 VGND S1 S1b VNB nfet_01v8 m=1 w=0.42 l=0.15 mult=1 sa=0.265
+ sb=0.265 sd=0.28 topography=normal area=0.028 perim=0.76
MMIN2 VGND S0 S0b VNB nfet_01v8 m=1 w=0.42 l=0.15 mult=1 sa=0.265
+ sb=0.265 sd=0.28 topography=normal area=0.028 perim=0.76
MMIN4 VGND xb X VNB nfet_01v8 m=1 w=0.65 l=0.15 mult=1 sa=0.265
+ sb=0.265 sd=0.28 topography=normal area=0.028 perim=0.76
MMPA00 sndPA0a0 A0 VPWR VPB pfet_01v8_hvt m=1 w=0.42 l=0.15 mult=1
+ sa=0.265 sb=0.265 sd=0.28 topography=normal area=0.028 perim=0.76
MMPA01 xlowb S0 sndPA0a0 VPB pfet_01v8_hvt m=1 w=0.42 l=0.15 mult=1
+ sa=0.265 sb=0.265 sd=0.28 topography=normal area=0.028 perim=0.76
MMPA10 sndPA1a1 A1 VPWR VPB pfet_01v8_hvt m=1 w=0.42 l=0.15 mult=1
+ sa=0.265 sb=0.265 sd=0.28 topography=normal area=0.028 perim=0.76
MMPA11 xlowb S0b sndPA1a1 VPB pfet_01v8_hvt m=1 w=0.42 l=0.15 mult=1
+ sa=0.265 sb=0.265 sd=0.28 topography=normal area=0.028 perim=0.76
MMPA20 sndPA2a2 A2 VPWR VPB pfet_01v8_hvt m=1 w=0.42 l=0.15 mult=1
+ sa=0.265 sb=0.265 sd=0.28 topography=normal area=0.028 perim=0.76
MMPA21 xhib S0 sndPA2a2 VPB pfet_01v8_hvt m=1 w=0.42 l=0.15 mult=1
+ sa=0.265 sb=0.265 sd=0.28 topography=normal area=0.028 perim=0.76
MMPA30 sndPA3a3 A3 VPWR VPB pfet_01v8_hvt m=1 w=0.42 l=0.15 mult=1
+ sa=0.265 sb=0.265 sd=0.28 topography=normal area=0.028 perim=0.76
MMPA31 xhib S0b sndPA3a3 VPB pfet_01v8_hvt m=1 w=0.42 l=0.15 mult=1
+ sa=0.265 sb=0.265 sd=0.28 topography=normal area=0.028 perim=0.76
MMPs1o xb S1 xlowb VPB pfet_01v8_hvt m=1 w=0.42 l=0.15 mult=1 sa=0.265
+ sb=0.265 sd=0.28 topography=normal area=0.028 perim=0.76
MMPs2o xb S1b xhib VPB pfet_01v8_hvt m=1 w=0.42 l=0.15 mult=1 sa=0.265
+ sb=0.265 sd=0.28 topography=normal area=0.028 perim=0.76
MMIP1 VPWR S1 S1b VPB pfet_01v8_hvt m=1 w=0.42 l=0.15 mult=1 sa=0.265
+ sb=0.265 sd=0.28 topography=normal area=0.028 perim=0.76
MMIP2 VPWR S0 S0b VPB pfet_01v8_hvt m=1 w=0.42 l=0.15 mult=1 sa=0.265
+ sb=0.265 sd=0.28 topography=normal area=0.028 perim=0.76
MMIP4 VPWR xb X VPB pfet_01v8_hvt m=1 w=1.0 l=0.15 mult=1 sa=0.265
+ sb=0.265 sd=0.28 topography=normal area=0.028 perim=0.76
.ENDS

.SUBCKT sky130_fd_sc_hd__mux4_2 A0 A1 A2 A3 S0 S1 VGND VNB VPB VPWR X
MMNA00 sndNS0ba0 S0b xlowb VNB nfet_01v8 m=1 w=0.36 l=0.15 mult=1
+ sa=0.265 sb=0.265 sd=0.28 topography=normal area=0.028 perim=0.76
MMNA01 VGND A0 sndNS0ba0 VNB nfet_01v8 m=1 w=0.42 l=0.15 mult=1
+ sa=0.265 sb=0.265 sd=0.28 topography=normal area=0.028 perim=0.76
MMNA10 sndNS0a1 S0 xlowb VNB nfet_01v8 m=1 w=0.36 l=0.15 mult=1
+ sa=0.265 sb=0.265 sd=0.28 topography=normal area=0.028 perim=0.76
MMNA11 VGND A1 sndNS0a1 VNB nfet_01v8 m=1 w=0.42 l=0.15 mult=1
+ sa=0.265 sb=0.265 sd=0.28 topography=normal area=0.028 perim=0.76
MMNA20 sndNS0ba2 S0b xhib VNB nfet_01v8 m=1 w=0.36 l=0.15 mult=1
+ sa=0.265 sb=0.265 sd=0.28 topography=normal area=0.028 perim=0.76
MMNA21 VGND A2 sndNS0ba2 VNB nfet_01v8 m=1 w=0.42 l=0.15 mult=1
+ sa=0.265 sb=0.265 sd=0.28 topography=normal area=0.028 perim=0.76
MMNA30 sndNS0a3 S0 xhib VNB nfet_01v8 m=1 w=0.36 l=0.15 mult=1
+ sa=0.265 sb=0.265 sd=0.28 topography=normal area=0.028 perim=0.76
MMNA31 VGND A3 sndNS0a3 VNB nfet_01v8 m=1 w=0.42 l=0.15 mult=1
+ sa=0.265 sb=0.265 sd=0.28 topography=normal area=0.028 perim=0.76
MMNs1o xb S1b xlowb VNB nfet_01v8 m=1 w=0.42 l=0.15 mult=1 sa=0.265
+ sb=0.265 sd=0.28 topography=normal area=0.028 perim=0.76
MMNs2o xb S1 xhib VNB nfet_01v8 m=1 w=0.42 l=0.15 mult=1 sa=0.265
+ sb=0.265 sd=0.28 topography=normal area=0.028 perim=0.76
MMIN1 VGND S1 S1b VNB nfet_01v8 m=1 w=0.42 l=0.15 mult=1 sa=0.265
+ sb=0.265 sd=0.28 topography=normal area=0.028 perim=0.76
MMIN2 VGND S0 S0b VNB nfet_01v8 m=1 w=0.42 l=0.15 mult=1 sa=0.265
+ sb=0.265 sd=0.28 topography=normal area=0.028 perim=0.76
MMIN4 VGND xb X VNB nfet_01v8 m=2 w=0.65 l=0.15 mult=1 sa=0.265
+ sb=0.265 sd=0.28 topography=normal area=0.028 perim=0.76
MMPA00 sndPA0a0 A0 VPWR VPB pfet_01v8_hvt m=1 w=0.64 l=0.15 mult=1
+ sa=0.265 sb=0.265 sd=0.28 topography=normal area=0.028 perim=0.76
MMPA01 xlowb S0 sndPA0a0 VPB pfet_01v8_hvt m=1 w=0.42 l=0.15 mult=1
+ sa=0.265 sb=0.265 sd=0.28 topography=normal area=0.028 perim=0.76
MMPA10 sndPA1a1 A1 VPWR VPB pfet_01v8_hvt m=1 w=0.64 l=0.15 mult=1
+ sa=0.265 sb=0.265 sd=0.28 topography=normal area=0.028 perim=0.76
MMPA11 xlowb S0b sndPA1a1 VPB pfet_01v8_hvt m=1 w=0.42 l=0.15 mult=1
+ sa=0.265 sb=0.265 sd=0.28 topography=normal area=0.028 perim=0.76
MMPA20 sndPA2a2 A2 VPWR VPB pfet_01v8_hvt m=1 w=0.64 l=0.15 mult=1
+ sa=0.265 sb=0.265 sd=0.28 topography=normal area=0.028 perim=0.76
MMPA21 xhib S0 sndPA2a2 VPB pfet_01v8_hvt m=1 w=0.42 l=0.15 mult=1
+ sa=0.265 sb=0.265 sd=0.28 topography=normal area=0.028 perim=0.76
MMPA30 sndPA3a3 A3 VPWR VPB pfet_01v8_hvt m=1 w=0.64 l=0.15 mult=1
+ sa=0.265 sb=0.265 sd=0.28 topography=normal area=0.028 perim=0.76
MMPA31 xhib S0b sndPA3a3 VPB pfet_01v8_hvt m=1 w=0.42 l=0.15 mult=1
+ sa=0.265 sb=0.265 sd=0.28 topography=normal area=0.028 perim=0.76
MMPs1o xb S1 xlowb VPB pfet_01v8_hvt m=1 w=0.54 l=0.15 mult=1 sa=0.265
+ sb=0.265 sd=0.28 topography=normal area=0.028 perim=0.76
MMPs2o xb S1b xhib VPB pfet_01v8_hvt m=1 w=0.54 l=0.15 mult=1 sa=0.265
+ sb=0.265 sd=0.28 topography=normal area=0.028 perim=0.76
MMIP1 VPWR S1 S1b VPB pfet_01v8_hvt m=1 w=0.64 l=0.15 mult=1 sa=0.265
+ sb=0.265 sd=0.28 topography=normal area=0.028 perim=0.76
MMIP2 VPWR S0 S0b VPB pfet_01v8_hvt m=1 w=0.64 l=0.15 mult=1 sa=0.265
+ sb=0.265 sd=0.28 topography=normal area=0.028 perim=0.76
MMIP4 VPWR xb X VPB pfet_01v8_hvt m=2 w=1.0 l=0.15 mult=1 sa=0.265
+ sb=0.265 sd=0.28 topography=normal area=0.028 perim=0.76
.ENDS

.SUBCKT sky130_fd_sc_hd__mux4_4 A0 A1 A2 A3 S0 S1 VGND VNB VPB VPWR X
MMNA00 sndNS0ba0 S0b xlowb VNB nfet_01v8 m=1 w=0.36 l=0.15 mult=1
+ sa=0.265 sb=0.265 sd=0.28 topography=normal area=0.028 perim=0.76
MMNA01 VGND A0 sndNS0ba0 VNB nfet_01v8 m=1 w=0.42 l=0.15 mult=1
+ sa=0.265 sb=0.265 sd=0.28 topography=normal area=0.028 perim=0.76
MMNA10 sndNS0a1 S0 xlowb VNB nfet_01v8 m=1 w=0.36 l=0.15 mult=1
+ sa=0.265 sb=0.265 sd=0.28 topography=normal area=0.028 perim=0.76
MMNA11 VGND A1 sndNS0a1 VNB nfet_01v8 m=1 w=0.42 l=0.15 mult=1
+ sa=0.265 sb=0.265 sd=0.28 topography=normal area=0.028 perim=0.76
MMNA20 sndNS0ba2 S0b xhib VNB nfet_01v8 m=1 w=0.36 l=0.15 mult=1
+ sa=0.265 sb=0.265 sd=0.28 topography=normal area=0.028 perim=0.76
MMNA21 VGND A2 sndNS0ba2 VNB nfet_01v8 m=1 w=0.42 l=0.15 mult=1
+ sa=0.265 sb=0.265 sd=0.28 topography=normal area=0.028 perim=0.76
MMNA30 sndNS0a3 S0 xhib VNB nfet_01v8 m=1 w=0.36 l=0.15 mult=1
+ sa=0.265 sb=0.265 sd=0.28 topography=normal area=0.028 perim=0.76
MMNA31 VGND A3 sndNS0a3 VNB nfet_01v8 m=1 w=0.42 l=0.15 mult=1
+ sa=0.265 sb=0.265 sd=0.28 topography=normal area=0.028 perim=0.76
MMNs1o xb S1b xlowb VNB nfet_01v8 m=1 w=0.42 l=0.15 mult=1 sa=0.265
+ sb=0.265 sd=0.28 topography=normal area=0.028 perim=0.76
MMNs2o xb S1 xhib VNB nfet_01v8 m=1 w=0.42 l=0.15 mult=1 sa=0.265
+ sb=0.265 sd=0.28 topography=normal area=0.028 perim=0.76
MMIN1 VGND S1 S1b VNB nfet_01v8 m=1 w=0.42 l=0.15 mult=1 sa=0.265
+ sb=0.265 sd=0.28 topography=normal area=0.028 perim=0.76
MMIN2 VGND S0 S0b VNB nfet_01v8 m=1 w=0.42 l=0.15 mult=1 sa=0.265
+ sb=0.265 sd=0.28 topography=normal area=0.028 perim=0.76
MMIN4 VGND xb X VNB nfet_01v8 m=4 w=0.65 l=0.15 mult=1 sa=0.265
+ sb=0.265 sd=0.28 topography=normal area=0.028 perim=0.76
MMPA00 sndPA0a0 A0 VPWR VPB pfet_01v8_hvt m=1 w=0.64 l=0.15 mult=1
+ sa=0.265 sb=0.265 sd=0.28 topography=normal area=0.028 perim=0.76
MMPA01 xlowb S0 sndPA0a0 VPB pfet_01v8_hvt m=1 w=0.42 l=0.15 mult=1
+ sa=0.265 sb=0.265 sd=0.28 topography=normal area=0.028 perim=0.76
MMPA10 sndPA1a1 A1 VPWR VPB pfet_01v8_hvt m=1 w=0.64 l=0.15 mult=1
+ sa=0.265 sb=0.265 sd=0.28 topography=normal area=0.028 perim=0.76
MMPA11 xlowb S0b sndPA1a1 VPB pfet_01v8_hvt m=1 w=0.42 l=0.15 mult=1
+ sa=0.265 sb=0.265 sd=0.28 topography=normal area=0.028 perim=0.76
MMPA20 sndPA2a2 A2 VPWR VPB pfet_01v8_hvt m=1 w=0.64 l=0.15 mult=1
+ sa=0.265 sb=0.265 sd=0.28 topography=normal area=0.028 perim=0.76
MMPA21 xhib S0 sndPA2a2 VPB pfet_01v8_hvt m=1 w=0.42 l=0.15 mult=1
+ sa=0.265 sb=0.265 sd=0.28 topography=normal area=0.028 perim=0.76
MMPA30 sndPA3a3 A3 VPWR VPB pfet_01v8_hvt m=1 w=0.64 l=0.15 mult=1
+ sa=0.265 sb=0.265 sd=0.28 topography=normal area=0.028 perim=0.76
MMPA31 xhib S0b sndPA3a3 VPB pfet_01v8_hvt m=1 w=0.42 l=0.15 mult=1
+ sa=0.265 sb=0.265 sd=0.28 topography=normal area=0.028 perim=0.76
MMPs1o xb S1 xlowb VPB pfet_01v8_hvt m=1 w=0.54 l=0.15 mult=1 sa=0.265
+ sb=0.265 sd=0.28 topography=normal area=0.028 perim=0.76
MMPs2o xb S1b xhib VPB pfet_01v8_hvt m=1 w=0.54 l=0.15 mult=1 sa=0.265
+ sb=0.265 sd=0.28 topography=normal area=0.028 perim=0.76
MMIP1 VPWR S1 S1b VPB pfet_01v8_hvt m=1 w=0.64 l=0.15 mult=1 sa=0.265
+ sb=0.265 sd=0.28 topography=normal area=0.028 perim=0.76
MMIP2 VPWR S0 S0b VPB pfet_01v8_hvt m=1 w=0.64 l=0.15 mult=1 sa=0.265
+ sb=0.265 sd=0.28 topography=normal area=0.028 perim=0.76
MMIP4 VPWR xb X VPB pfet_01v8_hvt m=4 w=1.0 l=0.15 mult=1 sa=0.265
+ sb=0.265 sd=0.28 topography=normal area=0.028 perim=0.76
.ENDS

.SUBCKT sky130_fd_sc_hd__nand2_1 A B VGND VNB VPB VPWR Y
MMP0 Y A VPWR VPB pfet_01v8_hvt m=1 w=1.0 l=0.15 mult=1 sa=0.265
+ sb=0.265 sd=0.28 topography=normal area=0.063 perim=1.14
MMP1 Y B VPWR VPB pfet_01v8_hvt m=1 w=1.0 l=0.15 mult=1 sa=0.265
+ sb=0.265 sd=0.28 topography=normal area=0.063 perim=1.14
MMN0 Y A sndA VNB nfet_01v8 m=1 w=0.65 l=0.15 mult=1 sa=0.265 sb=0.265
+ sd=0.28 topography=normal area=0.063 perim=1.14
MMN1 sndA B VGND VNB nfet_01v8 m=1 w=0.65 l=0.15 mult=1 sa=0.265
+ sb=0.265 sd=0.28 topography=normal area=0.063 perim=1.14
.ENDS

.SUBCKT sky130_fd_sc_hd__nand2_2 A B VGND VNB VPB VPWR Y
MMP0 Y A VPWR VPB pfet_01v8_hvt m=2 w=1.0 l=0.15 mult=1 sa=0.265
+ sb=0.265 sd=0.28 topography=normal area=0.063 perim=1.14
MMP1 Y B VPWR VPB pfet_01v8_hvt m=2 w=1.0 l=0.15 mult=1 sa=0.265
+ sb=0.265 sd=0.28 topography=normal area=0.063 perim=1.14
MMN0 Y A sndA VNB nfet_01v8 m=2 w=0.65 l=0.15 mult=1 sa=0.265 sb=0.265
+ sd=0.28 topography=normal area=0.063 perim=1.14
MMN1 sndA B VGND VNB nfet_01v8 m=2 w=0.65 l=0.15 mult=1 sa=0.265
+ sb=0.265 sd=0.28 topography=normal area=0.063 perim=1.14
.ENDS

.SUBCKT sky130_fd_sc_hd__nand2_4 A B VGND VNB VPB VPWR Y
MMP0 Y A VPWR VPB pfet_01v8_hvt m=4 w=1.0 l=0.15 mult=1 sa=0.265
+ sb=0.265 sd=0.28 topography=normal area=0.063 perim=1.14
MMP1 Y B VPWR VPB pfet_01v8_hvt m=4 w=1.0 l=0.15 mult=1 sa=0.265
+ sb=0.265 sd=0.28 topography=normal area=0.063 perim=1.14
MMN0 Y A sndA VNB nfet_01v8 m=4 w=0.65 l=0.15 mult=1 sa=0.265 sb=0.265
+ sd=0.28 topography=normal area=0.063 perim=1.14
MMN1 sndA B VGND VNB nfet_01v8 m=4 w=0.65 l=0.15 mult=1 sa=0.265
+ sb=0.265 sd=0.28 topography=normal area=0.063 perim=1.14
.ENDS

.SUBCKT sky130_fd_sc_hd__nand2_8 A B VGND VNB VPB VPWR Y
MMP0 Y A VPWR VPB pfet_01v8_hvt m=8 w=1.0 l=0.15 mult=1 sa=0.265
+ sb=0.265 sd=0.28 topography=normal area=0.063 perim=1.14
MMP1 Y B VPWR VPB pfet_01v8_hvt m=8 w=1.0 l=0.15 mult=1 sa=0.265
+ sb=0.265 sd=0.28 topography=normal area=0.063 perim=1.14
MMN0 Y A sndA VNB nfet_01v8 m=8 w=0.65 l=0.15 mult=1 sa=0.265 sb=0.265
+ sd=0.28 topography=normal area=0.063 perim=1.14
MMN1 sndA B VGND VNB nfet_01v8 m=8 w=0.65 l=0.15 mult=1 sa=0.265
+ sb=0.265 sd=0.28 topography=normal area=0.063 perim=1.14
.ENDS

.SUBCKT sky130_fd_sc_hd__nand2b_1 A_N B VGND VNB VPB VPWR Y
MMP0 Y A VPWR VPB pfet_01v8_hvt m=1 w=1.0 l=0.15 mult=1 sa=0.265
+ sb=0.265 sd=0.28 topography=normal area=0.063 perim=1.14
MMP1 Y B VPWR VPB pfet_01v8_hvt m=1 w=1.0 l=0.15 mult=1 sa=0.265
+ sb=0.265 sd=0.28 topography=normal area=0.063 perim=1.14
MMIP0 A A_N VPWR VPB pfet_01v8_hvt m=1 w=0.42 l=0.15 mult=1 sa=0.265
+ sb=0.265 sd=0.28 topography=normal area=0.063 perim=1.14
MMN0 Y A sndA VNB nfet_01v8 m=1 w=0.65 l=0.15 mult=1 sa=0.265 sb=0.265
+ sd=0.28 topography=normal area=0.063 perim=1.14
MMN1 sndA B VGND VNB nfet_01v8 m=1 w=0.65 l=0.15 mult=1 sa=0.265
+ sb=0.265 sd=0.28 topography=normal area=0.063 perim=1.14
MMIN0 A A_N VGND VNB nfet_01v8 m=1 w=0.42 l=0.15 mult=1 sa=0.265
+ sb=0.265 sd=0.28 topography=normal area=0.063 perim=1.14
.ENDS

.SUBCKT sky130_fd_sc_hd__nand2b_2 A_N B VGND VNB VPB VPWR Y
MMP0 Y A VPWR VPB pfet_01v8_hvt m=2 w=1.0 l=0.15 mult=1 sa=0.265
+ sb=0.265 sd=0.28 topography=normal area=0.063 perim=1.14
MMP1 Y B VPWR VPB pfet_01v8_hvt m=2 w=1.0 l=0.15 mult=1 sa=0.265
+ sb=0.265 sd=0.28 topography=normal area=0.063 perim=1.14
MMIP0 A A_N VPWR VPB pfet_01v8_hvt m=1 w=0.42 l=0.15 mult=1 sa=0.265
+ sb=0.265 sd=0.28 topography=normal area=0.063 perim=1.14
MMN0 Y A sndA VNB nfet_01v8 m=2 w=0.65 l=0.15 mult=1 sa=0.265 sb=0.265
+ sd=0.28 topography=normal area=0.063 perim=1.14
MMN1 sndA B VGND VNB nfet_01v8 m=2 w=0.65 l=0.15 mult=1 sa=0.265
+ sb=0.265 sd=0.28 topography=normal area=0.063 perim=1.14
MMIN0 A A_N VGND VNB nfet_01v8 m=1 w=0.42 l=0.15 mult=1 sa=0.265
+ sb=0.265 sd=0.28 topography=normal area=0.063 perim=1.14
.ENDS

.SUBCKT sky130_fd_sc_hd__nand2b_4 A_N B VGND VNB VPB VPWR Y
MMP0 Y A VPWR VPB pfet_01v8_hvt m=4 w=1.0 l=0.15 mult=1 sa=0.265
+ sb=0.265 sd=0.28 topography=normal area=0.063 perim=1.14
MMP1 Y B VPWR VPB pfet_01v8_hvt m=4 w=1.0 l=0.15 mult=1 sa=0.265
+ sb=0.265 sd=0.28 topography=normal area=0.063 perim=1.14
MMIP0 A A_N VPWR VPB pfet_01v8_hvt m=1 w=1.0 l=0.15 mult=1 sa=0.265
+ sb=0.265 sd=0.28 topography=normal area=0.063 perim=1.14
MMN0 Y A sndA VNB nfet_01v8 m=4 w=0.65 l=0.15 mult=1 sa=0.265 sb=0.265
+ sd=0.28 topography=normal area=0.063 perim=1.14
MMN1 sndA B VGND VNB nfet_01v8 m=4 w=0.65 l=0.15 mult=1 sa=0.265
+ sb=0.265 sd=0.28 topography=normal area=0.063 perim=1.14
MMIN0 A A_N VGND VNB nfet_01v8 m=1 w=0.65 l=0.15 mult=1 sa=0.265
+ sb=0.265 sd=0.28 topography=normal area=0.063 perim=1.14
.ENDS

.SUBCKT sky130_fd_sc_hd__nand3_1 A B C VGND VNB VPB VPWR Y
MMP0 Y A VPWR VPB pfet_01v8_hvt m=1 w=1.0 l=0.15 mult=1 sa=0.265
+ sb=0.265 sd=0.28 topography=normal area=0.063 perim=1.14
MMP1 Y B VPWR VPB pfet_01v8_hvt m=1 w=1.0 l=0.15 mult=1 sa=0.265
+ sb=0.265 sd=0.28 topography=normal area=0.063 perim=1.14
MMP2 Y C VPWR VPB pfet_01v8_hvt m=1 w=1.0 l=0.15 mult=1 sa=0.265
+ sb=0.265 sd=0.28 topography=normal area=0.063 perim=1.14
MMN0 Y A sndA VNB nfet_01v8 m=1 w=0.65 l=0.15 mult=1 sa=0.265 sb=0.265
+ sd=0.28 topography=normal area=0.063 perim=1.14
MMN1 sndA B sndB VNB nfet_01v8 m=1 w=0.65 l=0.15 mult=1 sa=0.265
+ sb=0.265 sd=0.28 topography=normal area=0.063 perim=1.14
MMN2 sndB C VGND VNB nfet_01v8 m=1 w=0.65 l=0.15 mult=1 sa=0.265
+ sb=0.265 sd=0.28 topography=normal area=0.063 perim=1.14
.ENDS

.SUBCKT sky130_fd_sc_hd__nand3_2 A B C VGND VNB VPB VPWR Y
MMP0 Y A VPWR VPB pfet_01v8_hvt m=2 w=1.0 l=0.15 mult=1 sa=0.265
+ sb=0.265 sd=0.28 topography=normal area=0.063 perim=1.14
MMP1 Y B VPWR VPB pfet_01v8_hvt m=2 w=1.0 l=0.15 mult=1 sa=0.265
+ sb=0.265 sd=0.28 topography=normal area=0.063 perim=1.14
MMP2 Y C VPWR VPB pfet_01v8_hvt m=2 w=1.0 l=0.15 mult=1 sa=0.265
+ sb=0.265 sd=0.28 topography=normal area=0.063 perim=1.14
MMN0 Y A sndA VNB nfet_01v8 m=2 w=0.65 l=0.15 mult=1 sa=0.265 sb=0.265
+ sd=0.28 topography=normal area=0.063 perim=1.14
MMN1 sndA B sndB VNB nfet_01v8 m=2 w=0.65 l=0.15 mult=1 sa=0.265
+ sb=0.265 sd=0.28 topography=normal area=0.063 perim=1.14
MMN2 sndB C VGND VNB nfet_01v8 m=2 w=0.65 l=0.15 mult=1 sa=0.265
+ sb=0.265 sd=0.28 topography=normal area=0.063 perim=1.14
.ENDS

.SUBCKT sky130_fd_sc_hd__nand3_4 A B C VGND VNB VPB VPWR Y
MMP0 Y A VPWR VPB pfet_01v8_hvt m=4 w=1.0 l=0.15 mult=1 sa=0.265
+ sb=0.265 sd=0.28 topography=normal area=0.063 perim=1.14
MMP1 Y B VPWR VPB pfet_01v8_hvt m=4 w=1.0 l=0.15 mult=1 sa=0.265
+ sb=0.265 sd=0.28 topography=normal area=0.063 perim=1.14
MMP2 Y C VPWR VPB pfet_01v8_hvt m=4 w=1.0 l=0.15 mult=1 sa=0.265
+ sb=0.265 sd=0.28 topography=normal area=0.063 perim=1.14
MMN0 Y A sndA VNB nfet_01v8 m=4 w=0.65 l=0.15 mult=1 sa=0.265 sb=0.265
+ sd=0.28 topography=normal area=0.063 perim=1.14
MMN1 sndA B sndB VNB nfet_01v8 m=4 w=0.65 l=0.15 mult=1 sa=0.265
+ sb=0.265 sd=0.28 topography=normal area=0.063 perim=1.14
MMN2 sndB C VGND VNB nfet_01v8 m=4 w=0.65 l=0.15 mult=1 sa=0.265
+ sb=0.265 sd=0.28 topography=normal area=0.063 perim=1.14
.ENDS

.SUBCKT sky130_fd_sc_hd__nand3b_1 A_N B C VGND VNB VPB VPWR Y
MMP0 Y A VPWR VPB pfet_01v8_hvt m=1 w=1.0 l=0.15 mult=1 sa=0.265
+ sb=0.265 sd=0.28 topography=normal area=0.063 perim=1.14
MMP1 Y B VPWR VPB pfet_01v8_hvt m=1 w=1.0 l=0.15 mult=1 sa=0.265
+ sb=0.265 sd=0.28 topography=normal area=0.063 perim=1.14
MMP2 Y C VPWR VPB pfet_01v8_hvt m=1 w=1.0 l=0.15 mult=1 sa=0.265
+ sb=0.265 sd=0.28 topography=normal area=0.063 perim=1.14
MMIP0 A A_N VPWR VPB pfet_01v8_hvt m=1 w=0.42 l=0.15 mult=1 sa=0.265
+ sb=0.265 sd=0.28 topography=normal area=0.063 perim=1.14
MMN0 Y A sndA VNB nfet_01v8 m=1 w=0.65 l=0.15 mult=1 sa=0.265 sb=0.265
+ sd=0.28 topography=normal area=0.063 perim=1.14
MMN1 sndA B sndB VNB nfet_01v8 m=1 w=0.65 l=0.15 mult=1 sa=0.265
+ sb=0.265 sd=0.28 topography=normal area=0.063 perim=1.14
MMN2 sndB C VGND VNB nfet_01v8 m=1 w=0.65 l=0.15 mult=1 sa=0.265
+ sb=0.265 sd=0.28 topography=normal area=0.063 perim=1.14
MMIN0 A A_N VGND VNB nfet_01v8 m=1 w=0.42 l=0.15 mult=1 sa=0.265
+ sb=0.265 sd=0.28 topography=normal area=0.063 perim=1.14
.ENDS

.SUBCKT sky130_fd_sc_hd__nand3b_2 A_N B C VGND VNB VPB VPWR Y
MMP0 Y A VPWR VPB pfet_01v8_hvt m=2 w=1.0 l=0.15 mult=1 sa=0.265
+ sb=0.265 sd=0.28 topography=normal area=0.063 perim=1.14
MMP1 Y B VPWR VPB pfet_01v8_hvt m=2 w=1.0 l=0.15 mult=1 sa=0.265
+ sb=0.265 sd=0.28 topography=normal area=0.063 perim=1.14
MMP2 Y C VPWR VPB pfet_01v8_hvt m=2 w=1.0 l=0.15 mult=1 sa=0.265
+ sb=0.265 sd=0.28 topography=normal area=0.063 perim=1.14
MMIP0 A A_N VPWR VPB pfet_01v8_hvt m=1 w=0.42 l=0.15 mult=1 sa=0.265
+ sb=0.265 sd=0.28 topography=normal area=0.063 perim=1.14
MMN0 Y A sndA VNB nfet_01v8 m=2 w=0.65 l=0.15 mult=1 sa=0.265 sb=0.265
+ sd=0.28 topography=normal area=0.063 perim=1.14
MMN1 sndA B sndB VNB nfet_01v8 m=2 w=0.65 l=0.15 mult=1 sa=0.265
+ sb=0.265 sd=0.28 topography=normal area=0.063 perim=1.14
MMN2 sndB C VGND VNB nfet_01v8 m=2 w=0.65 l=0.15 mult=1 sa=0.265
+ sb=0.265 sd=0.28 topography=normal area=0.063 perim=1.14
MMIN0 A A_N VGND VNB nfet_01v8 m=1 w=0.42 l=0.15 mult=1 sa=0.265
+ sb=0.265 sd=0.28 topography=normal area=0.063 perim=1.14
.ENDS

.SUBCKT sky130_fd_sc_hd__nand3b_4 A_N B C VGND VNB VPB VPWR Y
MMP0 Y A VPWR VPB pfet_01v8_hvt m=4 w=1.0 l=0.15 mult=1 sa=0.265
+ sb=0.265 sd=0.28 topography=normal area=0.063 perim=1.14
MMP1 Y B VPWR VPB pfet_01v8_hvt m=4 w=1.0 l=0.15 mult=1 sa=0.265
+ sb=0.265 sd=0.28 topography=normal area=0.063 perim=1.14
MMP2 Y C VPWR VPB pfet_01v8_hvt m=4 w=1.0 l=0.15 mult=1 sa=0.265
+ sb=0.265 sd=0.28 topography=normal area=0.063 perim=1.14
MMIP0 A A_N VPWR VPB pfet_01v8_hvt m=1 w=1.0 l=0.15 mult=1 sa=0.265
+ sb=0.265 sd=0.28 topography=normal area=0.063 perim=1.14
MMN0 Y A sndA VNB nfet_01v8 m=4 w=0.65 l=0.15 mult=1 sa=0.265 sb=0.265
+ sd=0.28 topography=normal area=0.063 perim=1.14
MMN1 sndA B sndB VNB nfet_01v8 m=4 w=0.65 l=0.15 mult=1 sa=0.265
+ sb=0.265 sd=0.28 topography=normal area=0.063 perim=1.14
MMN2 sndB C VGND VNB nfet_01v8 m=4 w=0.65 l=0.15 mult=1 sa=0.265
+ sb=0.265 sd=0.28 topography=normal area=0.063 perim=1.14
MMIN0 A A_N VGND VNB nfet_01v8 m=1 w=0.65 l=0.15 mult=1 sa=0.265
+ sb=0.265 sd=0.28 topography=normal area=0.063 perim=1.14
.ENDS

.SUBCKT sky130_fd_sc_hd__nand4_1 A B C D VGND VNB VPB VPWR Y
MMP0 Y A VPWR VPB pfet_01v8_hvt m=1 w=1.0 l=0.15 mult=1 sa=0.265
+ sb=0.265 sd=0.28 topography=normal area=0.063 perim=1.14
MMP1 Y B VPWR VPB pfet_01v8_hvt m=1 w=1.0 l=0.15 mult=1 sa=0.265
+ sb=0.265 sd=0.28 topography=normal area=0.063 perim=1.14
MMP3 Y D VPWR VPB pfet_01v8_hvt m=1 w=1.0 l=0.15 mult=1 sa=0.265
+ sb=0.265 sd=0.28 topography=normal area=0.063 perim=1.14
MMP2 Y C VPWR VPB pfet_01v8_hvt m=1 w=1.0 l=0.15 mult=1 sa=0.265
+ sb=0.265 sd=0.28 topography=normal area=0.063 perim=1.14
MMN0 Y A sndA VNB nfet_01v8 m=1 w=0.65 l=0.15 mult=1 sa=0.265 sb=0.265
+ sd=0.28 topography=normal area=0.063 perim=1.14
MMN1 sndA B sndB VNB nfet_01v8 m=1 w=0.65 l=0.15 mult=1 sa=0.265
+ sb=0.265 sd=0.28 topography=normal area=0.063 perim=1.14
MMN2 sndB C sndC VNB nfet_01v8 m=1 w=0.65 l=0.15 mult=1 sa=0.265
+ sb=0.265 sd=0.28 topography=normal area=0.063 perim=1.14
MMN3 sndC D VGND VNB nfet_01v8 m=1 w=0.65 l=0.15 mult=1 sa=0.265
+ sb=0.265 sd=0.28 topography=normal area=0.063 perim=1.14
.ENDS

.SUBCKT sky130_fd_sc_hd__nand4_2 A B C D VGND VNB VPB VPWR Y
MMP0 Y A VPWR VPB pfet_01v8_hvt m=2 w=1.0 l=0.15 mult=1 sa=0.265
+ sb=0.265 sd=0.28 topography=normal area=0.063 perim=1.14
MMP1 Y B VPWR VPB pfet_01v8_hvt m=2 w=1.0 l=0.15 mult=1 sa=0.265
+ sb=0.265 sd=0.28 topography=normal area=0.063 perim=1.14
MMP3 Y D VPWR VPB pfet_01v8_hvt m=2 w=1.0 l=0.15 mult=1 sa=0.265
+ sb=0.265 sd=0.28 topography=normal area=0.063 perim=1.14
MMP2 Y C VPWR VPB pfet_01v8_hvt m=2 w=1.0 l=0.15 mult=1 sa=0.265
+ sb=0.265 sd=0.28 topography=normal area=0.063 perim=1.14
MMN0 Y A sndA VNB nfet_01v8 m=2 w=0.65 l=0.15 mult=1 sa=0.265 sb=0.265
+ sd=0.28 topography=normal area=0.063 perim=1.14
MMN1 sndA B sndB VNB nfet_01v8 m=2 w=0.65 l=0.15 mult=1 sa=0.265
+ sb=0.265 sd=0.28 topography=normal area=0.063 perim=1.14
MMN2 sndB C sndC VNB nfet_01v8 m=2 w=0.65 l=0.15 mult=1 sa=0.265
+ sb=0.265 sd=0.28 topography=normal area=0.063 perim=1.14
MMN3 sndC D VGND VNB nfet_01v8 m=2 w=0.65 l=0.15 mult=1 sa=0.265
+ sb=0.265 sd=0.28 topography=normal area=0.063 perim=1.14
.ENDS

.SUBCKT sky130_fd_sc_hd__nand4_4 A B C D VGND VNB VPB VPWR Y
MMP0 Y A VPWR VPB pfet_01v8_hvt m=4 w=1.0 l=0.15 mult=1 sa=0.265
+ sb=0.265 sd=0.28 topography=normal area=0.063 perim=1.14
MMP1 Y B VPWR VPB pfet_01v8_hvt m=4 w=1.0 l=0.15 mult=1 sa=0.265
+ sb=0.265 sd=0.28 topography=normal area=0.063 perim=1.14
MMP3 Y D VPWR VPB pfet_01v8_hvt m=4 w=1.0 l=0.15 mult=1 sa=0.265
+ sb=0.265 sd=0.28 topography=normal area=0.063 perim=1.14
MMP2 Y C VPWR VPB pfet_01v8_hvt m=4 w=1.0 l=0.15 mult=1 sa=0.265
+ sb=0.265 sd=0.28 topography=normal area=0.063 perim=1.14
MMN0 Y A sndA VNB nfet_01v8 m=4 w=0.65 l=0.15 mult=1 sa=0.265 sb=0.265
+ sd=0.28 topography=normal area=0.063 perim=1.14
MMN1 sndA B sndB VNB nfet_01v8 m=4 w=0.65 l=0.15 mult=1 sa=0.265
+ sb=0.265 sd=0.28 topography=normal area=0.063 perim=1.14
MMN2 sndB C sndC VNB nfet_01v8 m=4 w=0.65 l=0.15 mult=1 sa=0.265
+ sb=0.265 sd=0.28 topography=normal area=0.063 perim=1.14
MMN3 sndC D VGND VNB nfet_01v8 m=4 w=0.65 l=0.15 mult=1 sa=0.265
+ sb=0.265 sd=0.28 topography=normal area=0.063 perim=1.14
.ENDS

.SUBCKT sky130_fd_sc_hd__nand4b_1 A_N B C D VGND VNB VPB VPWR Y
MMP0 Y A VPWR VPB pfet_01v8_hvt m=1 w=1.0 l=0.15 mult=1 sa=0.265
+ sb=0.265 sd=0.28 topography=normal area=0.063 perim=1.14
MMP1 Y B VPWR VPB pfet_01v8_hvt m=1 w=1.0 l=0.15 mult=1 sa=0.265
+ sb=0.265 sd=0.28 topography=normal area=0.063 perim=1.14
MMP2 Y C VPWR VPB pfet_01v8_hvt m=1 w=1.0 l=0.15 mult=1 sa=0.265
+ sb=0.265 sd=0.28 topography=normal area=0.063 perim=1.14
MMP3 Y D VPWR VPB pfet_01v8_hvt m=1 w=1.0 l=0.15 mult=1 sa=0.265
+ sb=0.265 sd=0.28 topography=normal area=0.063 perim=1.14
MMIP0 A A_N VPWR VPB pfet_01v8_hvt m=1 w=0.42 l=0.15 mult=1 sa=0.265
+ sb=0.265 sd=0.28 topography=normal area=0.063 perim=1.14
MMN0 Y A sndA VNB nfet_01v8 m=1 w=0.65 l=0.15 mult=1 sa=0.265 sb=0.265
+ sd=0.28 topography=normal area=0.063 perim=1.14
MMN1 sndA B sndB VNB nfet_01v8 m=1 w=0.65 l=0.15 mult=1 sa=0.265
+ sb=0.265 sd=0.28 topography=normal area=0.063 perim=1.14
MMN2 sndB C sndC VNB nfet_01v8 m=1 w=0.65 l=0.15 mult=1 sa=0.265
+ sb=0.265 sd=0.28 topography=normal area=0.063 perim=1.14
MMN3 sndC D VGND VNB nfet_01v8 m=1 w=0.65 l=0.15 mult=1 sa=0.265
+ sb=0.265 sd=0.28 topography=normal area=0.063 perim=1.14
MMIN0 A A_N VGND VNB nfet_01v8 m=1 w=0.42 l=0.15 mult=1 sa=0.265
+ sb=0.265 sd=0.28 topography=normal area=0.063 perim=1.14
.ENDS

.SUBCKT sky130_fd_sc_hd__nand4b_2 A_N B C D VGND VNB VPB VPWR Y
MMP0 Y A VPWR VPB pfet_01v8_hvt m=2 w=1.0 l=0.15 mult=1 sa=0.265
+ sb=0.265 sd=0.28 topography=normal area=0.063 perim=1.14
MMP1 Y B VPWR VPB pfet_01v8_hvt m=2 w=1.0 l=0.15 mult=1 sa=0.265
+ sb=0.265 sd=0.28 topography=normal area=0.063 perim=1.14
MMP2 Y C VPWR VPB pfet_01v8_hvt m=2 w=1.0 l=0.15 mult=1 sa=0.265
+ sb=0.265 sd=0.28 topography=normal area=0.063 perim=1.14
MMP3 Y D VPWR VPB pfet_01v8_hvt m=2 w=1.0 l=0.15 mult=1 sa=0.265
+ sb=0.265 sd=0.28 topography=normal area=0.063 perim=1.14
MMIP0 A A_N VPWR VPB pfet_01v8_hvt m=1 w=0.42 l=0.15 mult=1 sa=0.265
+ sb=0.265 sd=0.28 topography=normal area=0.063 perim=1.14
MMN0 Y A sndA VNB nfet_01v8 m=2 w=0.65 l=0.15 mult=1 sa=0.265 sb=0.265
+ sd=0.28 topography=normal area=0.063 perim=1.14
MMN1 sndA B sndB VNB nfet_01v8 m=2 w=0.65 l=0.15 mult=1 sa=0.265
+ sb=0.265 sd=0.28 topography=normal area=0.063 perim=1.14
MMN2 sndB C sndC VNB nfet_01v8 m=2 w=0.65 l=0.15 mult=1 sa=0.265
+ sb=0.265 sd=0.28 topography=normal area=0.063 perim=1.14
MMN3 sndC D VGND VNB nfet_01v8 m=2 w=0.65 l=0.15 mult=1 sa=0.265
+ sb=0.265 sd=0.28 topography=normal area=0.063 perim=1.14
MMIN0 A A_N VGND VNB nfet_01v8 m=1 w=0.42 l=0.15 mult=1 sa=0.265
+ sb=0.265 sd=0.28 topography=normal area=0.063 perim=1.14
.ENDS

.SUBCKT sky130_fd_sc_hd__nand4b_4 A_N B C D VGND VNB VPB VPWR Y
MMP0 Y A VPWR VPB pfet_01v8_hvt m=4 w=1.0 l=0.15 mult=1 sa=0.265
+ sb=0.265 sd=0.28 topography=normal area=0.063 perim=1.14
MMP1 Y B VPWR VPB pfet_01v8_hvt m=4 w=1.0 l=0.15 mult=1 sa=0.265
+ sb=0.265 sd=0.28 topography=normal area=0.063 perim=1.14
MMP2 Y C VPWR VPB pfet_01v8_hvt m=4 w=1.0 l=0.15 mult=1 sa=0.265
+ sb=0.265 sd=0.28 topography=normal area=0.063 perim=1.14
MMP3 Y D VPWR VPB pfet_01v8_hvt m=4 w=1.0 l=0.15 mult=1 sa=0.265
+ sb=0.265 sd=0.28 topography=normal area=0.063 perim=1.14
MMIP0 A A_N VPWR VPB pfet_01v8_hvt m=1 w=1.0 l=0.15 mult=1 sa=0.265
+ sb=0.265 sd=0.28 topography=normal area=0.063 perim=1.14
MMN0 Y A sndA VNB nfet_01v8 m=4 w=0.65 l=0.15 mult=1 sa=0.265 sb=0.265
+ sd=0.28 topography=normal area=0.063 perim=1.14
MMN1 sndA B sndB VNB nfet_01v8 m=4 w=0.65 l=0.15 mult=1 sa=0.265
+ sb=0.265 sd=0.28 topography=normal area=0.063 perim=1.14
MMN2 sndB C sndC VNB nfet_01v8 m=4 w=0.65 l=0.15 mult=1 sa=0.265
+ sb=0.265 sd=0.28 topography=normal area=0.063 perim=1.14
MMN3 sndC D VGND VNB nfet_01v8 m=4 w=0.65 l=0.15 mult=1 sa=0.265
+ sb=0.265 sd=0.28 topography=normal area=0.063 perim=1.14
MMIN0 A A_N VGND VNB nfet_01v8 m=1 w=0.65 l=0.15 mult=1 sa=0.265
+ sb=0.265 sd=0.28 topography=normal area=0.063 perim=1.14
.ENDS

.SUBCKT sky130_fd_sc_hd__nand4bb_1 A_N B_N C D VGND VNB VPB VPWR Y
MMP0 Y A VPWR VPB pfet_01v8_hvt m=1 w=1.0 l=0.15 mult=1 sa=0.265
+ sb=0.265 sd=0.28 topography=normal area=0.063 perim=1.14
MMP1 Y B VPWR VPB pfet_01v8_hvt m=1 w=1.0 l=0.15 mult=1 sa=0.265
+ sb=0.265 sd=0.28 topography=normal area=0.063 perim=1.14
MMP2 Y C VPWR VPB pfet_01v8_hvt m=1 w=1.0 l=0.15 mult=1 sa=0.265
+ sb=0.265 sd=0.28 topography=normal area=0.063 perim=1.14
MMP3 Y D VPWR VPB pfet_01v8_hvt m=1 w=1.0 l=0.15 mult=1 sa=0.265
+ sb=0.265 sd=0.28 topography=normal area=0.063 perim=1.14
MMIP0 A A_N VPWR VPB pfet_01v8_hvt m=1 w=0.42 l=0.15 mult=1 sa=0.265
+ sb=0.265 sd=0.28 topography=normal area=0.063 perim=1.14
MMIP1 B B_N VPWR VPB pfet_01v8_hvt m=1 w=0.42 l=0.15 mult=1 sa=0.265
+ sb=0.265 sd=0.28 topography=normal area=0.063 perim=1.14
MMN0 Y A sndA VNB nfet_01v8 m=1 w=0.65 l=0.15 mult=1 sa=0.265 sb=0.265
+ sd=0.28 topography=normal area=0.063 perim=1.14
MMN1 sndA B sndB VNB nfet_01v8 m=1 w=0.65 l=0.15 mult=1 sa=0.265
+ sb=0.265 sd=0.28 topography=normal area=0.063 perim=1.14
MMN2 sndB C sndC VNB nfet_01v8 m=1 w=0.65 l=0.15 mult=1 sa=0.265
+ sb=0.265 sd=0.28 topography=normal area=0.063 perim=1.14
MMN3 sndC D VGND VNB nfet_01v8 m=1 w=0.65 l=0.15 mult=1 sa=0.265
+ sb=0.265 sd=0.28 topography=normal area=0.063 perim=1.14
MMIN0 A A_N VGND VNB nfet_01v8 m=1 w=0.42 l=0.15 mult=1 sa=0.265
+ sb=0.265 sd=0.28 topography=normal area=0.063 perim=1.14
MMIN1 B B_N VGND VNB nfet_01v8 m=1 w=0.42 l=0.15 mult=1 sa=0.265
+ sb=0.265 sd=0.28 topography=normal area=0.063 perim=1.14
.ENDS

.SUBCKT sky130_fd_sc_hd__nand4bb_2 A_N B_N C D VGND VNB VPB VPWR Y
MMP0 Y A VPWR VPB pfet_01v8_hvt m=2 w=1.0 l=0.15 mult=1 sa=0.265
+ sb=0.265 sd=0.28 topography=normal area=0.063 perim=1.14
MMP1 Y B VPWR VPB pfet_01v8_hvt m=2 w=1.0 l=0.15 mult=1 sa=0.265
+ sb=0.265 sd=0.28 topography=normal area=0.063 perim=1.14
MMP2 Y C VPWR VPB pfet_01v8_hvt m=2 w=1.0 l=0.15 mult=1 sa=0.265
+ sb=0.265 sd=0.28 topography=normal area=0.063 perim=1.14
MMP3 Y D VPWR VPB pfet_01v8_hvt m=2 w=1.0 l=0.15 mult=1 sa=0.265
+ sb=0.265 sd=0.28 topography=normal area=0.063 perim=1.14
MMIP0 A A_N VPWR VPB pfet_01v8_hvt m=1 w=0.42 l=0.15 mult=1 sa=0.265
+ sb=0.265 sd=0.28 topography=normal area=0.063 perim=1.14
MMIP1 B B_N VPWR VPB pfet_01v8_hvt m=1 w=0.42 l=0.15 mult=1 sa=0.265
+ sb=0.265 sd=0.28 topography=normal area=0.063 perim=1.14
MMN0 Y A sndA VNB nfet_01v8 m=2 w=0.65 l=0.15 mult=1 sa=0.265 sb=0.265
+ sd=0.28 topography=normal area=0.063 perim=1.14
MMN1 sndA B sndB VNB nfet_01v8 m=2 w=0.65 l=0.15 mult=1 sa=0.265
+ sb=0.265 sd=0.28 topography=normal area=0.063 perim=1.14
MMN2 sndB C sndC VNB nfet_01v8 m=2 w=0.65 l=0.15 mult=1 sa=0.265
+ sb=0.265 sd=0.28 topography=normal area=0.063 perim=1.14
MMN3 sndC D VGND VNB nfet_01v8 m=2 w=0.65 l=0.15 mult=1 sa=0.265
+ sb=0.265 sd=0.28 topography=normal area=0.063 perim=1.14
MMIN0 A A_N VGND VNB nfet_01v8 m=1 w=0.42 l=0.15 mult=1 sa=0.265
+ sb=0.265 sd=0.28 topography=normal area=0.063 perim=1.14
MMIN1 B B_N VGND VNB nfet_01v8 m=1 w=0.42 l=0.15 mult=1 sa=0.265
+ sb=0.265 sd=0.28 topography=normal area=0.063 perim=1.14
.ENDS

.SUBCKT sky130_fd_sc_hd__nand4bb_4 A_N B_N C D VGND VNB VPB VPWR Y
MMP0 Y A VPWR VPB pfet_01v8_hvt m=4 w=1.0 l=0.15 mult=1 sa=0.265
+ sb=0.265 sd=0.28 topography=normal area=0.063 perim=1.14
MMP1 Y B VPWR VPB pfet_01v8_hvt m=4 w=1.0 l=0.15 mult=1 sa=0.265
+ sb=0.265 sd=0.28 topography=normal area=0.063 perim=1.14
MMP2 Y C VPWR VPB pfet_01v8_hvt m=4 w=1.0 l=0.15 mult=1 sa=0.265
+ sb=0.265 sd=0.28 topography=normal area=0.063 perim=1.14
MMP3 Y D VPWR VPB pfet_01v8_hvt m=4 w=1.0 l=0.15 mult=1 sa=0.265
+ sb=0.265 sd=0.28 topography=normal area=0.063 perim=1.14
MMIP0 A A_N VPWR VPB pfet_01v8_hvt m=1 w=1.0 l=0.15 mult=1 sa=0.265
+ sb=0.265 sd=0.28 topography=normal area=0.063 perim=1.14
MMIP1 B B_N VPWR VPB pfet_01v8_hvt m=1 w=1.0 l=0.15 mult=1 sa=0.265
+ sb=0.265 sd=0.28 topography=normal area=0.063 perim=1.14
MMN0 Y A sndA VNB nfet_01v8 m=4 w=0.65 l=0.15 mult=1 sa=0.265 sb=0.265
+ sd=0.28 topography=normal area=0.063 perim=1.14
MMN1 sndA B sndB VNB nfet_01v8 m=4 w=0.65 l=0.15 mult=1 sa=0.265
+ sb=0.265 sd=0.28 topography=normal area=0.063 perim=1.14
MMN2 sndB C sndC VNB nfet_01v8 m=4 w=0.65 l=0.15 mult=1 sa=0.265
+ sb=0.265 sd=0.28 topography=normal area=0.063 perim=1.14
MMN3 sndC D VGND VNB nfet_01v8 m=4 w=0.65 l=0.15 mult=1 sa=0.265
+ sb=0.265 sd=0.28 topography=normal area=0.063 perim=1.14
MMIN0 A A_N VGND VNB nfet_01v8 m=1 w=0.65 l=0.15 mult=1 sa=0.265
+ sb=0.265 sd=0.28 topography=normal area=0.063 perim=1.14
MMIN1 B B_N VGND VNB nfet_01v8 m=1 w=0.65 l=0.15 mult=1 sa=0.265
+ sb=0.265 sd=0.28 topography=normal area=0.063 perim=1.14
.ENDS

.SUBCKT sky130_fd_sc_hd__nor2_1 A B VGND VNB VPB VPWR Y
MMP0 VPWR A sndPA VPB pfet_01v8_hvt m=1 w=1.0 l=0.15 mult=1 sa=0.265
+ sb=0.265 sd=0.28 topography=normal area=0.063 perim=1.14
MMP1 sndPA B Y VPB pfet_01v8_hvt m=1 w=1.0 l=0.15 mult=1 sa=0.265
+ sb=0.265 sd=0.28 topography=normal area=0.063 perim=1.14
MMN0 Y A VGND VNB nfet_01v8 m=1 w=0.65 l=0.15 mult=1 sa=0.265 sb=0.265
+ sd=0.28 topography=normal area=0.063 perim=1.14
MMN1 Y B VGND VNB nfet_01v8 m=1 w=0.65 l=0.15 mult=1 sa=0.265 sb=0.265
+ sd=0.28 topography=normal area=0.063 perim=1.14
.ENDS

.SUBCKT sky130_fd_sc_hd__nor2_2 A B VGND VNB VPB VPWR Y
MMP0 VPWR A sndPA VPB pfet_01v8_hvt m=2 w=1.0 l=0.15 mult=1 sa=0.265
+ sb=0.265 sd=0.28 topography=normal area=0.063 perim=1.14
MMP1 sndPA B Y VPB pfet_01v8_hvt m=2 w=1.0 l=0.15 mult=1 sa=0.265
+ sb=0.265 sd=0.28 topography=normal area=0.063 perim=1.14
MMN0 Y A VGND VNB nfet_01v8 m=2 w=0.65 l=0.15 mult=1 sa=0.265 sb=0.265
+ sd=0.28 topography=normal area=0.063 perim=1.14
MMN1 Y B VGND VNB nfet_01v8 m=2 w=0.65 l=0.15 mult=1 sa=0.265 sb=0.265
+ sd=0.28 topography=normal area=0.063 perim=1.14
.ENDS

.SUBCKT sky130_fd_sc_hd__nor2_4 A B VGND VNB VPB VPWR Y
MMP0 VPWR A sndPA VPB pfet_01v8_hvt m=4 w=1.0 l=0.15 mult=1 sa=0.265
+ sb=0.265 sd=0.28 topography=normal area=0.063 perim=1.14
MMP1 sndPA B Y VPB pfet_01v8_hvt m=4 w=1.0 l=0.15 mult=1 sa=0.265
+ sb=0.265 sd=0.28 topography=normal area=0.063 perim=1.14
MMN0 Y A VGND VNB nfet_01v8 m=4 w=0.65 l=0.15 mult=1 sa=0.265 sb=0.265
+ sd=0.28 topography=normal area=0.063 perim=1.14
MMN1 Y B VGND VNB nfet_01v8 m=4 w=0.65 l=0.15 mult=1 sa=0.265 sb=0.265
+ sd=0.28 topography=normal area=0.063 perim=1.14
.ENDS

.SUBCKT sky130_fd_sc_hd__nor2_8 A B VGND VNB VPB VPWR Y
MMP0 VPWR A sndPA VPB pfet_01v8_hvt m=8 w=1.0 l=0.15 mult=1 sa=0.265
+ sb=0.265 sd=0.28 topography=normal area=0.063 perim=1.14
MMP1 sndPA B Y VPB pfet_01v8_hvt m=8 w=1.0 l=0.15 mult=1 sa=0.265
+ sb=0.265 sd=0.28 topography=normal area=0.063 perim=1.14
MMN0 Y A VGND VNB nfet_01v8 m=8 w=0.65 l=0.15 mult=1 sa=0.265 sb=0.265
+ sd=0.28 topography=normal area=0.063 perim=1.14
MMN1 Y B VGND VNB nfet_01v8 m=8 w=0.65 l=0.15 mult=1 sa=0.265 sb=0.265
+ sd=0.28 topography=normal area=0.063 perim=1.14
.ENDS

.SUBCKT sky130_fd_sc_hd__nor2b_1 A B_N VGND VNB VPB VPWR Y
MMP0 VPWR A sndPA VPB pfet_01v8_hvt m=1 w=1.0 l=0.15 mult=1 sa=0.265
+ sb=0.265 sd=0.28 topography=normal area=0.063 perim=1.14
MMP1 sndPA B Y VPB pfet_01v8_hvt m=1 w=1.0 l=0.15 mult=1 sa=0.265
+ sb=0.265 sd=0.28 topography=normal area=0.063 perim=1.14
MMIP1 B B_N VPWR VPB pfet_01v8_hvt m=1 w=0.42 l=0.15 mult=1 sa=0.265
+ sb=0.265 sd=0.28 topography=normal area=0.063 perim=1.14
MMN0 Y A VGND VNB nfet_01v8 m=1 w=0.65 l=0.15 mult=1 sa=0.265 sb=0.265
+ sd=0.28 topography=normal area=0.063 perim=1.14
MMN1 Y B VGND VNB nfet_01v8 m=1 w=0.65 l=0.15 mult=1 sa=0.265 sb=0.265
+ sd=0.28 topography=normal area=0.063 perim=1.14
MMIN1 B B_N VGND VNB nfet_01v8 m=1 w=0.42 l=0.15 mult=1 sa=0.265
+ sb=0.265 sd=0.28 topography=normal area=0.063 perim=1.14
.ENDS

.SUBCKT sky130_fd_sc_hd__nor2b_2 A B_N VGND VNB VPB VPWR Y
MMP0 VPWR A sndPA VPB pfet_01v8_hvt m=2 w=1.0 l=0.15 mult=1 sa=0.265
+ sb=0.265 sd=0.28 topography=normal area=0.063 perim=1.14
MMP1 sndPA B Y VPB pfet_01v8_hvt m=2 w=1.0 l=0.15 mult=1 sa=0.265
+ sb=0.265 sd=0.28 topography=normal area=0.063 perim=1.14
MMIP1 B B_N VPWR VPB pfet_01v8_hvt m=1 w=0.42 l=0.15 mult=1 sa=0.265
+ sb=0.265 sd=0.28 topography=normal area=0.063 perim=1.14
MMN0 Y A VGND VNB nfet_01v8 m=2 w=0.65 l=0.15 mult=1 sa=0.265 sb=0.265
+ sd=0.28 topography=normal area=0.063 perim=1.14
MMN1 Y B VGND VNB nfet_01v8 m=2 w=0.65 l=0.15 mult=1 sa=0.265 sb=0.265
+ sd=0.28 topography=normal area=0.063 perim=1.14
MMIN1 B B_N VGND VNB nfet_01v8 m=1 w=0.42 l=0.15 mult=1 sa=0.265
+ sb=0.265 sd=0.28 topography=normal area=0.063 perim=1.14
.ENDS

.SUBCKT sky130_fd_sc_hd__nor2b_4 A B_N VGND VNB VPB VPWR Y
MMP0 VPWR A sndPA VPB pfet_01v8_hvt m=4 w=1.0 l=0.15 mult=1 sa=0.265
+ sb=0.265 sd=0.28 topography=normal area=0.063 perim=1.14
MMP1 sndPA B Y VPB pfet_01v8_hvt m=4 w=1.0 l=0.15 mult=1 sa=0.265
+ sb=0.265 sd=0.28 topography=normal area=0.063 perim=1.14
MMIP1 B B_N VPWR VPB pfet_01v8_hvt m=1 w=1.0 l=0.15 mult=1 sa=0.265
+ sb=0.265 sd=0.28 topography=normal area=0.063 perim=1.14
MMN0 Y A VGND VNB nfet_01v8 m=4 w=0.65 l=0.15 mult=1 sa=0.265 sb=0.265
+ sd=0.28 topography=normal area=0.063 perim=1.14
MMN1 Y B VGND VNB nfet_01v8 m=4 w=0.65 l=0.15 mult=1 sa=0.265 sb=0.265
+ sd=0.28 topography=normal area=0.063 perim=1.14
MMIN1 B B_N VGND VNB nfet_01v8 m=1 w=0.65 l=0.15 mult=1 sa=0.265
+ sb=0.265 sd=0.28 topography=normal area=0.063 perim=1.14
.ENDS

.SUBCKT sky130_fd_sc_hd__nor3_1 A B C VGND VNB VPB VPWR Y
MMP0 VPWR A sndPA VPB pfet_01v8_hvt m=1 w=1.0 l=0.15 mult=1 sa=0.265
+ sb=0.265 sd=0.28 topography=normal area=0.063 perim=1.14
MMP1 sndPA B sndPB VPB pfet_01v8_hvt m=1 w=1.0 l=0.15 mult=1 sa=0.265
+ sb=0.265 sd=0.28 topography=normal area=0.063 perim=1.14
MMP2 sndPB C Y VPB pfet_01v8_hvt m=1 w=1.0 l=0.15 mult=1 sa=0.265
+ sb=0.265 sd=0.28 topography=normal area=0.063 perim=1.14
MMN0 Y A VGND VNB nfet_01v8 m=1 w=0.65 l=0.15 mult=1 sa=0.265 sb=0.265
+ sd=0.28 topography=normal area=0.063 perim=1.14
MMN1 Y B VGND VNB nfet_01v8 m=1 w=0.65 l=0.15 mult=1 sa=0.265 sb=0.265
+ sd=0.28 topography=normal area=0.063 perim=1.14
MMN2 Y C VGND VNB nfet_01v8 m=1 w=0.65 l=0.15 mult=1 sa=0.265 sb=0.265
+ sd=0.28 topography=normal area=0.063 perim=1.14
.ENDS

.SUBCKT sky130_fd_sc_hd__nor3_2 A B C VGND VNB VPB VPWR Y
MMP0 VPWR A sndPA VPB pfet_01v8_hvt m=2 w=1.0 l=0.15 mult=1 sa=0.265
+ sb=0.265 sd=0.28 topography=normal area=0.063 perim=1.14
MMP1 sndPA B sndPB VPB pfet_01v8_hvt m=2 w=1.0 l=0.15 mult=1 sa=0.265
+ sb=0.265 sd=0.28 topography=normal area=0.063 perim=1.14
MMP2 sndPB C Y VPB pfet_01v8_hvt m=2 w=1.0 l=0.15 mult=1 sa=0.265
+ sb=0.265 sd=0.28 topography=normal area=0.063 perim=1.14
MMN0 Y A VGND VNB nfet_01v8 m=2 w=0.65 l=0.15 mult=1 sa=0.265 sb=0.265
+ sd=0.28 topography=normal area=0.063 perim=1.14
MMN1 Y B VGND VNB nfet_01v8 m=2 w=0.65 l=0.15 mult=1 sa=0.265 sb=0.265
+ sd=0.28 topography=normal area=0.063 perim=1.14
MMN2 Y C VGND VNB nfet_01v8 m=2 w=0.65 l=0.15 mult=1 sa=0.265 sb=0.265
+ sd=0.28 topography=normal area=0.063 perim=1.14
.ENDS

.SUBCKT sky130_fd_sc_hd__nor3_4 A B C VGND VNB VPB VPWR Y
MMP0 VPWR A sndPA VPB pfet_01v8_hvt m=4 w=1.0 l=0.15 mult=1 sa=0.265
+ sb=0.265 sd=0.28 topography=normal area=0.063 perim=1.14
MMP1 sndPA B sndPB VPB pfet_01v8_hvt m=4 w=1.0 l=0.15 mult=1 sa=0.265
+ sb=0.265 sd=0.28 topography=normal area=0.063 perim=1.14
MMP2 sndPB C Y VPB pfet_01v8_hvt m=4 w=1.0 l=0.15 mult=1 sa=0.265
+ sb=0.265 sd=0.28 topography=normal area=0.063 perim=1.14
MMN0 Y A VGND VNB nfet_01v8 m=4 w=0.65 l=0.15 mult=1 sa=0.265 sb=0.265
+ sd=0.28 topography=normal area=0.063 perim=1.14
MMN1 Y B VGND VNB nfet_01v8 m=4 w=0.65 l=0.15 mult=1 sa=0.265 sb=0.265
+ sd=0.28 topography=normal area=0.063 perim=1.14
MMN2 Y C VGND VNB nfet_01v8 m=4 w=0.65 l=0.15 mult=1 sa=0.265 sb=0.265
+ sd=0.28 topography=normal area=0.063 perim=1.14
.ENDS

.SUBCKT sky130_fd_sc_hd__nor3b_1 A B C_N VGND VNB VPB VPWR Y
MMP0 VPWR A sndPA VPB pfet_01v8_hvt m=1 w=1.0 l=0.15 mult=1 sa=0.265
+ sb=0.265 sd=0.28 topography=normal area=0.063 perim=1.14
MMP1 sndPA B sndPB VPB pfet_01v8_hvt m=1 w=1.0 l=0.15 mult=1 sa=0.265
+ sb=0.265 sd=0.28 topography=normal area=0.063 perim=1.14
MMP2 sndPB C Y VPB pfet_01v8_hvt m=1 w=1.0 l=0.15 mult=1 sa=0.265
+ sb=0.265 sd=0.28 topography=normal area=0.063 perim=1.14
MMIP2 C C_N VPWR VPB pfet_01v8_hvt m=1 w=0.42 l=0.15 mult=1 sa=0.265
+ sb=0.265 sd=0.28 topography=normal area=0.063 perim=1.14
MMN0 Y A VGND VNB nfet_01v8 m=1 w=0.65 l=0.15 mult=1 sa=0.265 sb=0.265
+ sd=0.28 topography=normal area=0.063 perim=1.14
MMN1 Y B VGND VNB nfet_01v8 m=1 w=0.65 l=0.15 mult=1 sa=0.265 sb=0.265
+ sd=0.28 topography=normal area=0.063 perim=1.14
MMN2 Y C VGND VNB nfet_01v8 m=1 w=0.65 l=0.15 mult=1 sa=0.265 sb=0.265
+ sd=0.28 topography=normal area=0.063 perim=1.14
MMIN2 C C_N VGND VNB nfet_01v8 m=1 w=0.42 l=0.15 mult=1 sa=0.265
+ sb=0.265 sd=0.28 topography=normal area=0.063 perim=1.14
.ENDS

.SUBCKT sky130_fd_sc_hd__nor3b_2 A B C_N VGND VNB VPB VPWR Y
MMP0 VPWR A sndPA VPB pfet_01v8_hvt m=2 w=1.0 l=0.15 mult=1 sa=0.265
+ sb=0.265 sd=0.28 topography=normal area=0.063 perim=1.14
MMP1 sndPA B sndPB VPB pfet_01v8_hvt m=2 w=1.0 l=0.15 mult=1 sa=0.265
+ sb=0.265 sd=0.28 topography=normal area=0.063 perim=1.14
MMP2 sndPB C Y VPB pfet_01v8_hvt m=2 w=1.0 l=0.15 mult=1 sa=0.265
+ sb=0.265 sd=0.28 topography=normal area=0.063 perim=1.14
MMIP2 C C_N VPWR VPB pfet_01v8_hvt m=1 w=0.42 l=0.15 mult=1 sa=0.265
+ sb=0.265 sd=0.28 topography=normal area=0.063 perim=1.14
MMN0 Y A VGND VNB nfet_01v8 m=2 w=0.65 l=0.15 mult=1 sa=0.265 sb=0.265
+ sd=0.28 topography=normal area=0.063 perim=1.14
MMN1 Y B VGND VNB nfet_01v8 m=2 w=0.65 l=0.15 mult=1 sa=0.265 sb=0.265
+ sd=0.28 topography=normal area=0.063 perim=1.14
MMN2 Y C VGND VNB nfet_01v8 m=2 w=0.65 l=0.15 mult=1 sa=0.265 sb=0.265
+ sd=0.28 topography=normal area=0.063 perim=1.14
MMIN2 C C_N VGND VNB nfet_01v8 m=1 w=0.42 l=0.15 mult=1 sa=0.265
+ sb=0.265 sd=0.28 topography=normal area=0.063 perim=1.14
.ENDS

.SUBCKT sky130_fd_sc_hd__nor3b_4 A B C_N VGND VNB VPB VPWR Y
MMP0 VPWR A sndPA VPB pfet_01v8_hvt m=4 w=1.0 l=0.15 mult=1 sa=0.265
+ sb=0.265 sd=0.28 topography=normal area=0.063 perim=1.14
MMP1 sndPA B sndPB VPB pfet_01v8_hvt m=4 w=1.0 l=0.15 mult=1 sa=0.265
+ sb=0.265 sd=0.28 topography=normal area=0.063 perim=1.14
MMP2 sndPB C Y VPB pfet_01v8_hvt m=4 w=1.0 l=0.15 mult=1 sa=0.265
+ sb=0.265 sd=0.28 topography=normal area=0.063 perim=1.14
MMIP2 C C_N VPWR VPB pfet_01v8_hvt m=1 w=1.0 l=0.15 mult=1 sa=0.265
+ sb=0.265 sd=0.28 topography=normal area=0.063 perim=1.14
MMN0 Y A VGND VNB nfet_01v8 m=4 w=0.65 l=0.15 mult=1 sa=0.265 sb=0.265
+ sd=0.28 topography=normal area=0.063 perim=1.14
MMN1 Y B VGND VNB nfet_01v8 m=4 w=0.65 l=0.15 mult=1 sa=0.265 sb=0.265
+ sd=0.28 topography=normal area=0.063 perim=1.14
MMN2 Y C VGND VNB nfet_01v8 m=4 w=0.65 l=0.15 mult=1 sa=0.265 sb=0.265
+ sd=0.28 topography=normal area=0.063 perim=1.14
MMIN2 C C_N VGND VNB nfet_01v8 m=1 w=0.65 l=0.15 mult=1 sa=0.265
+ sb=0.265 sd=0.28 topography=normal area=0.063 perim=1.14
.ENDS

.SUBCKT sky130_fd_sc_hd__nor4_1 A B C D VGND VNB VPB VPWR Y
MMP0 VPWR A sndPA VPB pfet_01v8_hvt m=1 w=1.0 l=0.15 mult=1 sa=0.265
+ sb=0.265 sd=0.28 topography=normal area=0.028 perim=0.76
MMP1 sndPA B sndPB VPB pfet_01v8_hvt m=1 w=1.0 l=0.15 mult=1 sa=0.265
+ sb=0.265 sd=0.28 topography=normal area=0.028 perim=0.76
MMP2 sndPB C sndPC VPB pfet_01v8_hvt m=1 w=1.0 l=0.15 mult=1 sa=0.265
+ sb=0.265 sd=0.28 topography=normal area=0.028 perim=0.76
MMP3 sndPC D Y VPB pfet_01v8_hvt m=1 w=1.0 l=0.15 mult=1 sa=0.265
+ sb=0.265 sd=0.28 topography=normal area=0.028 perim=0.76
MMN0 Y A VGND VNB nfet_01v8 m=1 w=0.65 l=0.15 mult=1 sa=0.265 sb=0.265
+ sd=0.28 topography=normal area=0.028 perim=0.76
MMN1 Y B VGND VNB nfet_01v8 m=1 w=0.65 l=0.15 mult=1 sa=0.265 sb=0.265
+ sd=0.28 topography=normal area=0.028 perim=0.76
MMN2 Y C VGND VNB nfet_01v8 m=1 w=0.65 l=0.15 mult=1 sa=0.265 sb=0.265
+ sd=0.28 topography=normal area=0.028 perim=0.76
MMN3 Y D VGND VNB nfet_01v8 m=1 w=0.65 l=0.15 mult=1 sa=0.265 sb=0.265
+ sd=0.28 topography=normal area=0.028 perim=0.76
.ENDS

.SUBCKT sky130_fd_sc_hd__nor4_2 A B C D VGND VNB VPB VPWR Y
MMP0 VPWR A sndPA VPB pfet_01v8_hvt m=2 w=1.0 l=0.15 mult=1 sa=0.265
+ sb=0.265 sd=0.28 topography=normal area=0.028 perim=0.76
MMP1 sndPA B sndPB VPB pfet_01v8_hvt m=2 w=1.0 l=0.15 mult=1 sa=0.265
+ sb=0.265 sd=0.28 topography=normal area=0.028 perim=0.76
MMP2 sndPB C sndPC VPB pfet_01v8_hvt m=2 w=1.0 l=0.15 mult=1 sa=0.265
+ sb=0.265 sd=0.28 topography=normal area=0.028 perim=0.76
MMP3 sndPC D Y VPB pfet_01v8_hvt m=2 w=1.0 l=0.15 mult=1 sa=0.265
+ sb=0.265 sd=0.28 topography=normal area=0.028 perim=0.76
MMN0 Y A VGND VNB nfet_01v8 m=2 w=0.65 l=0.15 mult=1 sa=0.265 sb=0.265
+ sd=0.28 topography=normal area=0.028 perim=0.76
MMN1 Y B VGND VNB nfet_01v8 m=2 w=0.65 l=0.15 mult=1 sa=0.265 sb=0.265
+ sd=0.28 topography=normal area=0.028 perim=0.76
MMN2 Y C VGND VNB nfet_01v8 m=2 w=0.65 l=0.15 mult=1 sa=0.265 sb=0.265
+ sd=0.28 topography=normal area=0.028 perim=0.76
MMN3 Y D VGND VNB nfet_01v8 m=2 w=0.65 l=0.15 mult=1 sa=0.265 sb=0.265
+ sd=0.28 topography=normal area=0.028 perim=0.76
.ENDS

.SUBCKT sky130_fd_sc_hd__nor4_4 A B C D VGND VNB VPB VPWR Y
MMP0 VPWR A sndPA VPB pfet_01v8_hvt m=4 w=1.0 l=0.15 mult=1 sa=0.265
+ sb=0.265 sd=0.28 topography=normal area=0.028 perim=0.76
MMP1 sndPA B sndPB VPB pfet_01v8_hvt m=4 w=1.0 l=0.15 mult=1 sa=0.265
+ sb=0.265 sd=0.28 topography=normal area=0.028 perim=0.76
MMP2 sndPB C sndPC VPB pfet_01v8_hvt m=4 w=1.0 l=0.15 mult=1 sa=0.265
+ sb=0.265 sd=0.28 topography=normal area=0.028 perim=0.76
MMP3 sndPC D Y VPB pfet_01v8_hvt m=4 w=1.0 l=0.15 mult=1 sa=0.265
+ sb=0.265 sd=0.28 topography=normal area=0.028 perim=0.76
MMN0 Y A VGND VNB nfet_01v8 m=4 w=0.65 l=0.15 mult=1 sa=0.265 sb=0.265
+ sd=0.28 topography=normal area=0.028 perim=0.76
MMN1 Y B VGND VNB nfet_01v8 m=4 w=0.65 l=0.15 mult=1 sa=0.265 sb=0.265
+ sd=0.28 topography=normal area=0.028 perim=0.76
MMN2 Y C VGND VNB nfet_01v8 m=4 w=0.65 l=0.15 mult=1 sa=0.265 sb=0.265
+ sd=0.28 topography=normal area=0.028 perim=0.76
MMN3 Y D VGND VNB nfet_01v8 m=4 w=0.65 l=0.15 mult=1 sa=0.265 sb=0.265
+ sd=0.28 topography=normal area=0.028 perim=0.76
.ENDS

.SUBCKT sky130_fd_sc_hd__nor4b_1 A B C D_N VGND VNB VPB VPWR Y
MMP0 VPWR A sndPA VPB pfet_01v8_hvt m=1 w=1.0 l=0.15 mult=1 sa=0.265
+ sb=0.265 sd=0.28 topography=normal area=0.063 perim=1.14
MMP1 sndPA B sndPB VPB pfet_01v8_hvt m=1 w=1.0 l=0.15 mult=1 sa=0.265
+ sb=0.265 sd=0.28 topography=normal area=0.063 perim=1.14
MMP2 sndPB C sndPC VPB pfet_01v8_hvt m=1 w=1.0 l=0.15 mult=1 sa=0.265
+ sb=0.265 sd=0.28 topography=normal area=0.063 perim=1.14
MMP3 sndPC D Y VPB pfet_01v8_hvt m=1 w=1.0 l=0.15 mult=1 sa=0.265
+ sb=0.265 sd=0.28 topography=normal area=0.063 perim=1.14
MMIP3 D D_N VPWR VPB pfet_01v8_hvt m=1 w=0.42 l=0.15 mult=1 sa=0.265
+ sb=0.265 sd=0.28 topography=normal area=0.063 perim=1.14
MMN0 Y A VGND VNB nfet_01v8 m=1 w=0.65 l=0.15 mult=1 sa=0.265 sb=0.265
+ sd=0.28 topography=normal area=0.063 perim=1.14
MMN1 Y B VGND VNB nfet_01v8 m=1 w=0.65 l=0.15 mult=1 sa=0.265 sb=0.265
+ sd=0.28 topography=normal area=0.063 perim=1.14
MMN2 Y C VGND VNB nfet_01v8 m=1 w=0.65 l=0.15 mult=1 sa=0.265 sb=0.265
+ sd=0.28 topography=normal area=0.063 perim=1.14
MMN3 Y D VGND VNB nfet_01v8 m=1 w=0.65 l=0.15 mult=1 sa=0.265 sb=0.265
+ sd=0.28 topography=normal area=0.063 perim=1.14
MMIN3 D D_N VGND VNB nfet_01v8 m=1 w=0.42 l=0.15 mult=1 sa=0.265
+ sb=0.265 sd=0.28 topography=normal area=0.063 perim=1.14
.ENDS

.SUBCKT sky130_fd_sc_hd__nor4b_2 A B C D_N VGND VNB VPB VPWR Y
MMP0 VPWR A sndPA VPB pfet_01v8_hvt m=2 w=1.0 l=0.15 mult=1 sa=0.265
+ sb=0.265 sd=0.28 topography=normal area=0.063 perim=1.14
MMP1 sndPA B sndPB VPB pfet_01v8_hvt m=2 w=1.0 l=0.15 mult=1 sa=0.265
+ sb=0.265 sd=0.28 topography=normal area=0.063 perim=1.14
MMP2 sndPB C sndPC VPB pfet_01v8_hvt m=2 w=1.0 l=0.15 mult=1 sa=0.265
+ sb=0.265 sd=0.28 topography=normal area=0.063 perim=1.14
MMP3 sndPC D Y VPB pfet_01v8_hvt m=2 w=1.0 l=0.15 mult=1 sa=0.265
+ sb=0.265 sd=0.28 topography=normal area=0.063 perim=1.14
MMIP3 D D_N VPWR VPB pfet_01v8_hvt m=1 w=0.42 l=0.15 mult=1 sa=0.265
+ sb=0.265 sd=0.28 topography=normal area=0.063 perim=1.14
MMN0 Y A VGND VNB nfet_01v8 m=2 w=0.65 l=0.15 mult=1 sa=0.265 sb=0.265
+ sd=0.28 topography=normal area=0.063 perim=1.14
MMN1 Y B VGND VNB nfet_01v8 m=2 w=0.65 l=0.15 mult=1 sa=0.265 sb=0.265
+ sd=0.28 topography=normal area=0.063 perim=1.14
MMN2 Y C VGND VNB nfet_01v8 m=2 w=0.65 l=0.15 mult=1 sa=0.265 sb=0.265
+ sd=0.28 topography=normal area=0.063 perim=1.14
MMN3 Y D VGND VNB nfet_01v8 m=2 w=0.65 l=0.15 mult=1 sa=0.265 sb=0.265
+ sd=0.28 topography=normal area=0.063 perim=1.14
MMIN3 D D_N VGND VNB nfet_01v8 m=1 w=0.42 l=0.15 mult=1 sa=0.265
+ sb=0.265 sd=0.28 topography=normal area=0.063 perim=1.14
.ENDS

.SUBCKT sky130_fd_sc_hd__nor4b_4 A B C D_N VGND VNB VPB VPWR Y
MMP0 VPWR A sndPA VPB pfet_01v8_hvt m=4 w=1.0 l=0.15 mult=1 sa=0.265
+ sb=0.265 sd=0.28 topography=normal area=0.063 perim=1.14
MMP1 sndPA B sndPB VPB pfet_01v8_hvt m=4 w=1.0 l=0.15 mult=1 sa=0.265
+ sb=0.265 sd=0.28 topography=normal area=0.063 perim=1.14
MMP2 sndPB C sndPC VPB pfet_01v8_hvt m=4 w=1.0 l=0.15 mult=1 sa=0.265
+ sb=0.265 sd=0.28 topography=normal area=0.063 perim=1.14
MMP3 sndPC D Y VPB pfet_01v8_hvt m=4 w=1.0 l=0.15 mult=1 sa=0.265
+ sb=0.265 sd=0.28 topography=normal area=0.063 perim=1.14
MMIP3 D D_N VPWR VPB pfet_01v8_hvt m=1 w=1.0 l=0.15 mult=1 sa=0.265
+ sb=0.265 sd=0.28 topography=normal area=0.063 perim=1.14
MMN0 Y A VGND VNB nfet_01v8 m=4 w=0.65 l=0.15 mult=1 sa=0.265 sb=0.265
+ sd=0.28 topography=normal area=0.063 perim=1.14
MMN1 Y B VGND VNB nfet_01v8 m=4 w=0.65 l=0.15 mult=1 sa=0.265 sb=0.265
+ sd=0.28 topography=normal area=0.063 perim=1.14
MMN2 Y C VGND VNB nfet_01v8 m=4 w=0.65 l=0.15 mult=1 sa=0.265 sb=0.265
+ sd=0.28 topography=normal area=0.063 perim=1.14
MMN3 Y D VGND VNB nfet_01v8 m=4 w=0.65 l=0.15 mult=1 sa=0.265 sb=0.265
+ sd=0.28 topography=normal area=0.063 perim=1.14
MMIN3 D D_N VGND VNB nfet_01v8 m=1 w=0.65 l=0.15 mult=1 sa=0.265
+ sb=0.265 sd=0.28 topography=normal area=0.063 perim=1.14
.ENDS

.SUBCKT sky130_fd_sc_hd__nor4bb_1 A B C_N D_N VGND VNB VPB VPWR Y
MMP0 VPWR A sndPA VPB pfet_01v8_hvt m=1 w=1.0 l=0.15 mult=1 sa=0.265
+ sb=0.265 sd=0.28 topography=normal area=0.063 perim=1.14
MMP1 sndPA B sndPB VPB pfet_01v8_hvt m=1 w=1.0 l=0.15 mult=1 sa=0.265
+ sb=0.265 sd=0.28 topography=normal area=0.063 perim=1.14
MMP2 sndPB C sndPC VPB pfet_01v8_hvt m=1 w=1.0 l=0.15 mult=1 sa=0.265
+ sb=0.265 sd=0.28 topography=normal area=0.063 perim=1.14
MMP3 sndPC D Y VPB pfet_01v8_hvt m=1 w=1.0 l=0.15 mult=1 sa=0.265
+ sb=0.265 sd=0.28 topography=normal area=0.063 perim=1.14
MMIP2 C C_N VPWR VPB pfet_01v8_hvt m=1 w=0.42 l=0.15 mult=1 sa=0.265
+ sb=0.265 sd=0.28 topography=normal area=0.063 perim=1.14
MMIP3 D D_N VPWR VPB pfet_01v8_hvt m=1 w=0.42 l=0.15 mult=1 sa=0.265
+ sb=0.265 sd=0.28 topography=normal area=0.063 perim=1.14
MMN0 Y A VGND VNB nfet_01v8 m=1 w=0.65 l=0.15 mult=1 sa=0.265 sb=0.265
+ sd=0.28 topography=normal area=0.063 perim=1.14
MMN1 Y B VGND VNB nfet_01v8 m=1 w=0.65 l=0.15 mult=1 sa=0.265 sb=0.265
+ sd=0.28 topography=normal area=0.063 perim=1.14
MMN2 Y C VGND VNB nfet_01v8 m=1 w=0.65 l=0.15 mult=1 sa=0.265 sb=0.265
+ sd=0.28 topography=normal area=0.063 perim=1.14
MMN3 Y D VGND VNB nfet_01v8 m=1 w=0.65 l=0.15 mult=1 sa=0.265 sb=0.265
+ sd=0.28 topography=normal area=0.063 perim=1.14
MMIN2 C C_N VGND VNB nfet_01v8 m=1 w=0.42 l=0.15 mult=1 sa=0.265
+ sb=0.265 sd=0.28 topography=normal area=0.063 perim=1.14
MMIN3 D D_N VGND VNB nfet_01v8 m=1 w=0.42 l=0.15 mult=1 sa=0.265
+ sb=0.265 sd=0.28 topography=normal area=0.063 perim=1.14
.ENDS

.SUBCKT sky130_fd_sc_hd__nor4bb_2 A B C_N D_N VGND VNB VPB VPWR Y
MMP0 VPWR A sndPA VPB pfet_01v8_hvt m=2 w=1.0 l=0.15 mult=1 sa=0.265
+ sb=0.265 sd=0.28 topography=normal area=0.063 perim=1.14
MMP1 sndPA B sndPB VPB pfet_01v8_hvt m=2 w=1.0 l=0.15 mult=1 sa=0.265
+ sb=0.265 sd=0.28 topography=normal area=0.063 perim=1.14
MMP2 sndPB C sndPC VPB pfet_01v8_hvt m=2 w=1.0 l=0.15 mult=1 sa=0.265
+ sb=0.265 sd=0.28 topography=normal area=0.063 perim=1.14
MMP3 sndPC D Y VPB pfet_01v8_hvt m=2 w=1.0 l=0.15 mult=1 sa=0.265
+ sb=0.265 sd=0.28 topography=normal area=0.063 perim=1.14
MMIP2 C C_N VPWR VPB pfet_01v8_hvt m=1 w=0.42 l=0.15 mult=1 sa=0.265
+ sb=0.265 sd=0.28 topography=normal area=0.063 perim=1.14
MMIP3 D D_N VPWR VPB pfet_01v8_hvt m=1 w=0.42 l=0.15 mult=1 sa=0.265
+ sb=0.265 sd=0.28 topography=normal area=0.063 perim=1.14
MMN0 Y A VGND VNB nfet_01v8 m=2 w=0.65 l=0.15 mult=1 sa=0.265 sb=0.265
+ sd=0.28 topography=normal area=0.063 perim=1.14
MMN1 Y B VGND VNB nfet_01v8 m=2 w=0.65 l=0.15 mult=1 sa=0.265 sb=0.265
+ sd=0.28 topography=normal area=0.063 perim=1.14
MMN2 Y C VGND VNB nfet_01v8 m=2 w=0.65 l=0.15 mult=1 sa=0.265 sb=0.265
+ sd=0.28 topography=normal area=0.063 perim=1.14
MMN3 Y D VGND VNB nfet_01v8 m=2 w=0.65 l=0.15 mult=1 sa=0.265 sb=0.265
+ sd=0.28 topography=normal area=0.063 perim=1.14
MMIN2 C C_N VGND VNB nfet_01v8 m=1 w=0.42 l=0.15 mult=1 sa=0.265
+ sb=0.265 sd=0.28 topography=normal area=0.063 perim=1.14
MMIN3 D D_N VGND VNB nfet_01v8 m=1 w=0.42 l=0.15 mult=1 sa=0.265
+ sb=0.265 sd=0.28 topography=normal area=0.063 perim=1.14
.ENDS

.SUBCKT sky130_fd_sc_hd__nor4bb_4 A B C_N D_N VGND VNB VPB VPWR Y
MMP0 VPWR A sndPA VPB pfet_01v8_hvt m=4 w=1.0 l=0.15 mult=1 sa=0.265
+ sb=0.265 sd=0.28 topography=normal area=0.063 perim=1.14
MMP1 sndPA B sndPB VPB pfet_01v8_hvt m=4 w=1.0 l=0.15 mult=1 sa=0.265
+ sb=0.265 sd=0.28 topography=normal area=0.063 perim=1.14
MMP2 sndPB C sndPC VPB pfet_01v8_hvt m=4 w=1.0 l=0.15 mult=1 sa=0.265
+ sb=0.265 sd=0.28 topography=normal area=0.063 perim=1.14
MMP3 sndPC D Y VPB pfet_01v8_hvt m=4 w=1.0 l=0.15 mult=1 sa=0.265
+ sb=0.265 sd=0.28 topography=normal area=0.063 perim=1.14
MMIP2 C C_N VPWR VPB pfet_01v8_hvt m=1 w=1.0 l=0.15 mult=1 sa=0.265
+ sb=0.265 sd=0.28 topography=normal area=0.063 perim=1.14
MMIP3 D D_N VPWR VPB pfet_01v8_hvt m=1 w=1.0 l=0.15 mult=1 sa=0.265
+ sb=0.265 sd=0.28 topography=normal area=0.063 perim=1.14
MMN0 Y A VGND VNB nfet_01v8 m=4 w=0.65 l=0.15 mult=1 sa=0.265 sb=0.265
+ sd=0.28 topography=normal area=0.063 perim=1.14
MMN1 Y B VGND VNB nfet_01v8 m=4 w=0.65 l=0.15 mult=1 sa=0.265 sb=0.265
+ sd=0.28 topography=normal area=0.063 perim=1.14
MMN2 Y C VGND VNB nfet_01v8 m=4 w=0.65 l=0.15 mult=1 sa=0.265 sb=0.265
+ sd=0.28 topography=normal area=0.063 perim=1.14
MMN3 Y D VGND VNB nfet_01v8 m=4 w=0.65 l=0.15 mult=1 sa=0.265 sb=0.265
+ sd=0.28 topography=normal area=0.063 perim=1.14
MMIN2 C C_N VGND VNB nfet_01v8 m=1 w=0.65 l=0.15 mult=1 sa=0.265
+ sb=0.265 sd=0.28 topography=normal area=0.063 perim=1.14
MMIN3 D D_N VGND VNB nfet_01v8 m=1 w=0.65 l=0.15 mult=1 sa=0.265
+ sb=0.265 sd=0.28 topography=normal area=0.063 perim=1.14
.ENDS

.SUBCKT sky130_fd_sc_hd__o2bb2a_1 A1_N A2_N B1 B2 VGND VNB VPB VPWR X
MMIN2 X y VGND VNB nfet_01v8 m=1 w=0.65 l=0.15 mult=1 sa=0.265
+ sb=0.265 sd=0.28 topography=normal area=0.063 perim=1.14
MMNnand0 VGND A1_N sndNA1N VNB nfet_01v8 m=1 w=0.42 l=0.15 mult=1
+ sa=0.265 sb=0.265 sd=0.28 topography=normal area=0.063 perim=1.14
MMNnand1 sndNA1N A2_N inand VNB nfet_01v8 m=1 w=0.42 l=0.15 mult=1
+ sa=0.265 sb=0.265 sd=0.28 topography=normal area=0.063 perim=1.14
MMNaoi10 nmid B1 VGND VNB nfet_01v8 m=1 w=0.42 l=0.15 mult=1 sa=0.265
+ sb=0.265 sd=0.28 topography=normal area=0.063 perim=1.14
MMNaoi11 nmid B2 VGND VNB nfet_01v8 m=1 w=0.42 l=0.15 mult=1 sa=0.265
+ sb=0.265 sd=0.28 topography=normal area=0.063 perim=1.14
MMNaoi20 y inand nmid VNB nfet_01v8 m=1 w=0.42 l=0.15 mult=1 sa=0.265
+ sb=0.265 sd=0.28 topography=normal area=0.063 perim=1.14
MMIP2 X y VPWR VPB pfet_01v8_hvt m=1 w=1.0 l=0.15 mult=1 sa=0.265
+ sb=0.265 sd=0.28 topography=normal area=0.063 perim=1.14
MMPnand0 inand A1_N VPWR VPB pfet_01v8_hvt m=1 w=0.42 l=0.15 mult=1
+ sa=0.265 sb=0.265 sd=0.28 topography=normal area=0.063 perim=1.14
MMPnand1 inand A2_N VPWR VPB pfet_01v8_hvt m=1 w=0.42 l=0.15 mult=1
+ sa=0.265 sb=0.265 sd=0.28 topography=normal area=0.063 perim=1.14
MMPaoi10 VPWR B1 sndPB1 VPB pfet_01v8_hvt m=1 w=0.42 l=0.15 mult=1
+ sa=0.265 sb=0.265 sd=0.28 topography=normal area=0.063 perim=1.14
MMPaoi11 sndPB1 B2 y VPB pfet_01v8_hvt m=1 w=0.42 l=0.15 mult=1
+ sa=0.265 sb=0.265 sd=0.28 topography=normal area=0.063 perim=1.14
MMPaoi20 y inand VPWR VPB pfet_01v8_hvt m=1 w=0.42 l=0.15 mult=1
+ sa=0.265 sb=0.265 sd=0.28 topography=normal area=0.063 perim=1.14
.ENDS

.SUBCKT sky130_fd_sc_hd__o2bb2a_2 A1_N A2_N B1 B2 VGND VNB VPB VPWR X
MMIN2 X y VGND VNB nfet_01v8 m=2 w=0.65 l=0.15 mult=1 sa=0.265
+ sb=0.265 sd=0.28 topography=normal area=0.063 perim=1.14
MMNnand0 VGND A1_N sndNA1N VNB nfet_01v8 m=1 w=0.42 l=0.15 mult=1
+ sa=0.265 sb=0.265 sd=0.28 topography=normal area=0.063 perim=1.14
MMNnand1 sndNA1N A2_N inand VNB nfet_01v8 m=1 w=0.42 l=0.15 mult=1
+ sa=0.265 sb=0.265 sd=0.28 topography=normal area=0.063 perim=1.14
MMNaoi10 nmid B1 VGND VNB nfet_01v8 m=1 w=0.42 l=0.15 mult=1 sa=0.265
+ sb=0.265 sd=0.28 topography=normal area=0.063 perim=1.14
MMNaoi11 nmid B2 VGND VNB nfet_01v8 m=1 w=0.42 l=0.15 mult=1 sa=0.265
+ sb=0.265 sd=0.28 topography=normal area=0.063 perim=1.14
MMNaoi20 y inand nmid VNB nfet_01v8 m=1 w=0.42 l=0.15 mult=1 sa=0.265
+ sb=0.265 sd=0.28 topography=normal area=0.063 perim=1.14
MMIP2 X y VPWR VPB pfet_01v8_hvt m=2 w=1.0 l=0.15 mult=1 sa=0.265
+ sb=0.265 sd=0.28 topography=normal area=0.063 perim=1.14
MMPnand0 inand A1_N VPWR VPB pfet_01v8_hvt m=1 w=0.64 l=0.15 mult=1
+ sa=0.265 sb=0.265 sd=0.28 topography=normal area=0.063 perim=1.14
MMPnand1 inand A2_N VPWR VPB pfet_01v8_hvt m=1 w=0.64 l=0.15 mult=1
+ sa=0.265 sb=0.265 sd=0.28 topography=normal area=0.063 perim=1.14
MMPaoi10 VPWR B1 sndPB1 VPB pfet_01v8_hvt m=1 w=0.64 l=0.15 mult=1
+ sa=0.265 sb=0.265 sd=0.28 topography=normal area=0.063 perim=1.14
MMPaoi11 sndPB1 B2 y VPB pfet_01v8_hvt m=1 w=0.64 l=0.15 mult=1
+ sa=0.265 sb=0.265 sd=0.28 topography=normal area=0.063 perim=1.14
MMPaoi20 y inand VPWR VPB pfet_01v8_hvt m=1 w=0.64 l=0.15 mult=1
+ sa=0.265 sb=0.265 sd=0.28 topography=normal area=0.063 perim=1.14
.ENDS

.SUBCKT sky130_fd_sc_hd__o2bb2a_4 A1_N A2_N B1 B2 VGND VNB VPB VPWR X
MMIN2 X y VGND VNB nfet_01v8 m=4 w=0.65 l=0.15 mult=1 sa=0.265
+ sb=0.265 sd=0.28 topography=normal area=0.063 perim=1.14
MMNnand0 VGND A1_N sndNA1N VNB nfet_01v8 m=2 w=0.65 l=0.15 mult=1
+ sa=0.265 sb=0.265 sd=0.28 topography=normal area=0.063 perim=1.14
MMNnand1 sndNA1N A2_N inand VNB nfet_01v8 m=2 w=0.65 l=0.15 mult=1
+ sa=0.265 sb=0.265 sd=0.28 topography=normal area=0.063 perim=1.14
MMNaoi10 nmid B1 VGND VNB nfet_01v8 m=2 w=0.65 l=0.15 mult=1 sa=0.265
+ sb=0.265 sd=0.28 topography=normal area=0.063 perim=1.14
MMNaoi11 nmid B2 VGND VNB nfet_01v8 m=2 w=0.65 l=0.15 mult=1 sa=0.265
+ sb=0.265 sd=0.28 topography=normal area=0.063 perim=1.14
MMNaoi20 y inand nmid VNB nfet_01v8 m=2 w=0.65 l=0.15 mult=1 sa=0.265
+ sb=0.265 sd=0.28 topography=normal area=0.063 perim=1.14
MMIP2 X y VPWR VPB pfet_01v8_hvt m=4 w=1.0 l=0.15 mult=1 sa=0.265
+ sb=0.265 sd=0.28 topography=normal area=0.063 perim=1.14
MMPnand0 inand A1_N VPWR VPB pfet_01v8_hvt m=2 w=1.0 l=0.15 mult=1
+ sa=0.265 sb=0.265 sd=0.28 topography=normal area=0.063 perim=1.14
MMPnand1 inand A2_N VPWR VPB pfet_01v8_hvt m=2 w=1.0 l=0.15 mult=1
+ sa=0.265 sb=0.265 sd=0.28 topography=normal area=0.063 perim=1.14
MMPaoi10 VPWR B1 sndPB1 VPB pfet_01v8_hvt m=2 w=1.0 l=0.15 mult=1
+ sa=0.265 sb=0.265 sd=0.28 topography=normal area=0.063 perim=1.14
MMPaoi11 sndPB1 B2 y VPB pfet_01v8_hvt m=2 w=1.0 l=0.15 mult=1
+ sa=0.265 sb=0.265 sd=0.28 topography=normal area=0.063 perim=1.14
MMPaoi20 y inand VPWR VPB pfet_01v8_hvt m=2 w=1.0 l=0.15 mult=1
+ sa=0.265 sb=0.265 sd=0.28 topography=normal area=0.063 perim=1.14
.ENDS

.SUBCKT sky130_fd_sc_hd__o2bb2ai_1 A1_N A2_N B1 B2 VGND VNB VPB VPWR Y
MMNnand0 VGND A1_N sndNA1N VNB nfet_01v8 m=1 w=0.65 l=0.15 mult=1
+ sa=0.265 sb=0.265 sd=0.28 topography=normal area=0.063 perim=1.14
MMNnand1 sndNA1N A2_N inand VNB nfet_01v8 m=1 w=0.65 l=0.15 mult=1
+ sa=0.265 sb=0.265 sd=0.28 topography=normal area=0.063 perim=1.14
MMNaoi10 nmid B1 VGND VNB nfet_01v8 m=1 w=0.65 l=0.15 mult=1 sa=0.265
+ sb=0.265 sd=0.28 topography=normal area=0.063 perim=1.14
MMNaoi11 nmid B2 VGND VNB nfet_01v8 m=1 w=0.65 l=0.15 mult=1 sa=0.265
+ sb=0.265 sd=0.28 topography=normal area=0.063 perim=1.14
MMNaoi20 Y inand nmid VNB nfet_01v8 m=1 w=0.65 l=0.15 mult=1 sa=0.265
+ sb=0.265 sd=0.28 topography=normal area=0.063 perim=1.14
MMPnand0 inand A1_N VPWR VPB pfet_01v8_hvt m=1 w=1.0 l=0.15 mult=1
+ sa=0.265 sb=0.265 sd=0.28 topography=normal area=0.063 perim=1.14
MMPnand1 inand A2_N VPWR VPB pfet_01v8_hvt m=1 w=1.0 l=0.15 mult=1
+ sa=0.265 sb=0.265 sd=0.28 topography=normal area=0.063 perim=1.14
MMPaoi10 VPWR B1 sndPB1 VPB pfet_01v8_hvt m=1 w=1.0 l=0.15 mult=1
+ sa=0.265 sb=0.265 sd=0.28 topography=normal area=0.063 perim=1.14
MMPaoi11 sndPB1 B2 Y VPB pfet_01v8_hvt m=1 w=1.0 l=0.15 mult=1
+ sa=0.265 sb=0.265 sd=0.28 topography=normal area=0.063 perim=1.14
MMPaoi20 Y inand VPWR VPB pfet_01v8_hvt m=1 w=1.0 l=0.15 mult=1
+ sa=0.265 sb=0.265 sd=0.28 topography=normal area=0.063 perim=1.14
.ENDS

.SUBCKT sky130_fd_sc_hd__o2bb2ai_2 A1_N A2_N B1 B2 VGND VNB VPB VPWR Y
MMNnand0 VGND A1_N sndNA1N VNB nfet_01v8 m=2 w=0.65 l=0.15 mult=1
+ sa=0.265 sb=0.265 sd=0.28 topography=normal area=0.063 perim=1.14
MMNnand1 sndNA1N A2_N inand VNB nfet_01v8 m=2 w=0.65 l=0.15 mult=1
+ sa=0.265 sb=0.265 sd=0.28 topography=normal area=0.063 perim=1.14
MMNaoi10 nmid B1 VGND VNB nfet_01v8 m=2 w=0.65 l=0.15 mult=1 sa=0.265
+ sb=0.265 sd=0.28 topography=normal area=0.063 perim=1.14
MMNaoi11 nmid B2 VGND VNB nfet_01v8 m=2 w=0.65 l=0.15 mult=1 sa=0.265
+ sb=0.265 sd=0.28 topography=normal area=0.063 perim=1.14
MMNaoi20 Y inand nmid VNB nfet_01v8 m=2 w=0.65 l=0.15 mult=1 sa=0.265
+ sb=0.265 sd=0.28 topography=normal area=0.063 perim=1.14
MMPnand0 inand A1_N VPWR VPB pfet_01v8_hvt m=2 w=1.0 l=0.15 mult=1
+ sa=0.265 sb=0.265 sd=0.28 topography=normal area=0.063 perim=1.14
MMPnand1 inand A2_N VPWR VPB pfet_01v8_hvt m=2 w=1.0 l=0.15 mult=1
+ sa=0.265 sb=0.265 sd=0.28 topography=normal area=0.063 perim=1.14
MMPaoi10 VPWR B1 sndPB1 VPB pfet_01v8_hvt m=2 w=1.0 l=0.15 mult=1
+ sa=0.265 sb=0.265 sd=0.28 topography=normal area=0.063 perim=1.14
MMPaoi11 sndPB1 B2 Y VPB pfet_01v8_hvt m=2 w=1.0 l=0.15 mult=1
+ sa=0.265 sb=0.265 sd=0.28 topography=normal area=0.063 perim=1.14
MMPaoi20 Y inand VPWR VPB pfet_01v8_hvt m=2 w=1.0 l=0.15 mult=1
+ sa=0.265 sb=0.265 sd=0.28 topography=normal area=0.063 perim=1.14
.ENDS

.SUBCKT sky130_fd_sc_hd__o2bb2ai_4 A1_N A2_N B1 B2 VGND VNB VPB VPWR Y
MMNnand0 VGND A1_N sndNA1N VNB nfet_01v8 m=4 w=0.65 l=0.15 mult=1
+ sa=0.265 sb=0.265 sd=0.28 topography=normal area=0.063 perim=1.14
MMNnand1 sndNA1N A2_N inand VNB nfet_01v8 m=4 w=0.65 l=0.15 mult=1
+ sa=0.265 sb=0.265 sd=0.28 topography=normal area=0.063 perim=1.14
MMNaoi10 nmid B1 VGND VNB nfet_01v8 m=4 w=0.65 l=0.15 mult=1 sa=0.265
+ sb=0.265 sd=0.28 topography=normal area=0.063 perim=1.14
MMNaoi11 nmid B2 VGND VNB nfet_01v8 m=4 w=0.65 l=0.15 mult=1 sa=0.265
+ sb=0.265 sd=0.28 topography=normal area=0.063 perim=1.14
MMNaoi20 Y inand nmid VNB nfet_01v8 m=4 w=0.65 l=0.15 mult=1 sa=0.265
+ sb=0.265 sd=0.28 topography=normal area=0.063 perim=1.14
MMPnand0 inand A1_N VPWR VPB pfet_01v8_hvt m=4 w=1.0 l=0.15 mult=1
+ sa=0.265 sb=0.265 sd=0.28 topography=normal area=0.063 perim=1.14
MMPnand1 inand A2_N VPWR VPB pfet_01v8_hvt m=4 w=1.0 l=0.15 mult=1
+ sa=0.265 sb=0.265 sd=0.28 topography=normal area=0.063 perim=1.14
MMPaoi10 VPWR B1 sndPB1 VPB pfet_01v8_hvt m=4 w=1.0 l=0.15 mult=1
+ sa=0.265 sb=0.265 sd=0.28 topography=normal area=0.063 perim=1.14
MMPaoi11 sndPB1 B2 Y VPB pfet_01v8_hvt m=4 w=1.0 l=0.15 mult=1
+ sa=0.265 sb=0.265 sd=0.28 topography=normal area=0.063 perim=1.14
MMPaoi20 Y inand VPWR VPB pfet_01v8_hvt m=4 w=1.0 l=0.15 mult=1
+ sa=0.265 sb=0.265 sd=0.28 topography=normal area=0.063 perim=1.14
.ENDS

.SUBCKT sky130_fd_sc_hd__o21a_1 A1 A2 B1 VGND VNB VPB VPWR X
MMPA0 VPWR A1 sndA1 VPB pfet_01v8_hvt m=1 w=1.0 l=0.15 mult=1 sa=0.265
+ sb=0.265 sd=0.28 topography=normal area=0.063 perim=1.14
MMPA1 sndA1 A2 y VPB pfet_01v8_hvt m=1 w=1.0 l=0.15 mult=1 sa=0.265
+ sb=0.265 sd=0.28 topography=normal area=0.063 perim=1.14
MMPB0 VPWR B1 y VPB pfet_01v8_hvt m=1 w=1.0 l=0.15 mult=1 sa=0.265
+ sb=0.265 sd=0.28 topography=normal area=0.063 perim=1.14
MMIPX X y VPWR VPB pfet_01v8_hvt m=1 w=1.0 l=0.15 mult=1 sa=0.265
+ sb=0.265 sd=0.28 topography=normal area=0.063 perim=1.14
MMNA0 pndA A1 VGND VNB nfet_01v8 m=1 w=0.65 l=0.15 mult=1 sa=0.265
+ sb=0.265 sd=0.28 topography=normal area=0.063 perim=1.14
MMNA1 pndA A2 VGND VNB nfet_01v8 m=1 w=0.65 l=0.15 mult=1 sa=0.265
+ sb=0.265 sd=0.28 topography=normal area=0.063 perim=1.14
MMNB0 y B1 pndA VNB nfet_01v8 m=1 w=0.65 l=0.15 mult=1 sa=0.265
+ sb=0.265 sd=0.28 topography=normal area=0.063 perim=1.14
MMINX X y VGND VNB nfet_01v8 m=1 w=0.65 l=0.15 mult=1 sa=0.265
+ sb=0.265 sd=0.28 topography=normal area=0.063 perim=1.14
.ENDS

.SUBCKT sky130_fd_sc_hd__o21a_2 A1 A2 B1 VGND VNB VPB VPWR X
MMPA0 VPWR A1 sndA1 VPB pfet_01v8_hvt m=1 w=1.0 l=0.15 mult=1 sa=0.265
+ sb=0.265 sd=0.28 topography=normal area=0.063 perim=1.14
MMPA1 sndA1 A2 y VPB pfet_01v8_hvt m=1 w=1.0 l=0.15 mult=1 sa=0.265
+ sb=0.265 sd=0.28 topography=normal area=0.063 perim=1.14
MMPB0 VPWR B1 y VPB pfet_01v8_hvt m=1 w=1.0 l=0.15 mult=1 sa=0.265
+ sb=0.265 sd=0.28 topography=normal area=0.063 perim=1.14
MMIPX X y VPWR VPB pfet_01v8_hvt m=2 w=1.0 l=0.15 mult=1 sa=0.265
+ sb=0.265 sd=0.28 topography=normal area=0.063 perim=1.14
MMNA0 pndA A1 VGND VNB nfet_01v8 m=1 w=0.65 l=0.15 mult=1 sa=0.265
+ sb=0.265 sd=0.28 topography=normal area=0.063 perim=1.14
MMNA1 pndA A2 VGND VNB nfet_01v8 m=1 w=0.65 l=0.15 mult=1 sa=0.265
+ sb=0.265 sd=0.28 topography=normal area=0.063 perim=1.14
MMNB0 y B1 pndA VNB nfet_01v8 m=1 w=0.65 l=0.15 mult=1 sa=0.265
+ sb=0.265 sd=0.28 topography=normal area=0.063 perim=1.14
MMINX X y VGND VNB nfet_01v8 m=2 w=0.65 l=0.15 mult=1 sa=0.265
+ sb=0.265 sd=0.28 topography=normal area=0.063 perim=1.14
.ENDS

.SUBCKT sky130_fd_sc_hd__o21a_4 A1 A2 B1 VGND VNB VPB VPWR X
MMPA0 VPWR A1 sndA1 VPB pfet_01v8_hvt w=1.0 l=0.15 mult=1 sa=0.265
+ sb=0.265 sd=0.28 topography=normal area=0.063 perim=1.14
MMPA20 VPWR A1 snd2A1 VPB pfet_01v8_hvt w=1.0 l=0.15 mult=1 sa=0.265
+ sb=0.265 sd=0.28 topography=normal area=0.063 perim=1.14
MMPA1 sndA1 A2 y VPB pfet_01v8_hvt w=1.0 l=0.15 mult=1 sa=0.265
+ sb=0.265 sd=0.28 topography=normal area=0.063 perim=1.14
MMPA21 snd2A1 A2 y VPB pfet_01v8_hvt w=1.0 l=0.15 mult=1 sa=0.265
+ sb=0.265 sd=0.28 topography=normal area=0.063 perim=1.14
MMPB0 VPWR B1 y VPB pfet_01v8_hvt m=2 w=1.0 l=0.15 mult=1 sa=0.265
+ sb=0.265 sd=0.28 topography=normal area=0.063 perim=1.14
MMIPX X y VPWR VPB pfet_01v8_hvt m=4 w=1.0 l=0.15 mult=1 sa=0.265
+ sb=0.265 sd=0.28 topography=normal area=0.063 perim=1.14
MMNA0 pndA A1 VGND VNB nfet_01v8 m=2 w=0.65 l=0.15 mult=1 sa=0.265
+ sb=0.265 sd=0.28 topography=normal area=0.063 perim=1.14
MMNA1 pndA A2 VGND VNB nfet_01v8 m=2 w=0.65 l=0.15 mult=1 sa=0.265
+ sb=0.265 sd=0.28 topography=normal area=0.063 perim=1.14
MMNB0 y B1 pndA VNB nfet_01v8 m=2 w=0.65 l=0.15 mult=1 sa=0.265
+ sb=0.265 sd=0.28 topography=normal area=0.063 perim=1.14
MMINX X y VGND VNB nfet_01v8 m=4 w=0.65 l=0.15 mult=1 sa=0.265
+ sb=0.265 sd=0.28 topography=normal area=0.063 perim=1.14
.ENDS

.SUBCKT sky130_fd_sc_hd__o21ai_0 A1 A2 B1 VGND VNB VPB VPWR Y
MMPA0 VPWR A1 sndA1 VPB pfet_01v8_hvt m=1 w=0.64 l=0.15 mult=1
+ sa=0.265 sb=0.265 sd=0.28 topography=normal area=0.063 perim=1.14
MMPA1 sndA1 A2 Y VPB pfet_01v8_hvt m=1 w=0.64 l=0.15 mult=1 sa=0.265
+ sb=0.265 sd=0.28 topography=normal area=0.063 perim=1.14
MMPB0 VPWR B1 Y VPB pfet_01v8_hvt m=1 w=0.64 l=0.15 mult=1 sa=0.265
+ sb=0.265 sd=0.28 topography=normal area=0.063 perim=1.14
MMNA0 pndA A1 VGND VNB nfet_01v8 m=1 w=0.42 l=0.15 mult=1 sa=0.265
+ sb=0.265 sd=0.28 topography=normal area=0.063 perim=1.14
MMNA1 pndA A2 VGND VNB nfet_01v8 m=1 w=0.42 l=0.15 mult=1 sa=0.265
+ sb=0.265 sd=0.28 topography=normal area=0.063 perim=1.14
MMNB0 Y B1 pndA VNB nfet_01v8 m=1 w=0.42 l=0.15 mult=1 sa=0.265
+ sb=0.265 sd=0.28 topography=normal area=0.063 perim=1.14
.ENDS

.SUBCKT sky130_fd_sc_hd__o21ai_1 A1 A2 B1 VGND VNB VPB VPWR Y
MMPA0 VPWR A1 sndA1 VPB pfet_01v8_hvt m=1 w=1.0 l=0.15 mult=1 sa=0.265
+ sb=0.265 sd=0.28 topography=normal area=0.063 perim=1.14
MMPA1 sndA1 A2 Y VPB pfet_01v8_hvt m=1 w=1.0 l=0.15 mult=1 sa=0.265
+ sb=0.265 sd=0.28 topography=normal area=0.063 perim=1.14
MMPB0 VPWR B1 Y VPB pfet_01v8_hvt m=1 w=0.7 l=0.15 mult=1 sa=0.265
+ sb=0.265 sd=0.28 topography=normal area=0.063 perim=1.14
MMNA0 pndA A1 VGND VNB nfet_01v8 m=1 w=0.65 l=0.15 mult=1 sa=0.265
+ sb=0.265 sd=0.28 topography=normal area=0.063 perim=1.14
MMNA1 pndA A2 VGND VNB nfet_01v8 m=1 w=0.65 l=0.15 mult=1 sa=0.265
+ sb=0.265 sd=0.28 topography=normal area=0.063 perim=1.14
MMNB0 Y B1 pndA VNB nfet_01v8 m=1 w=0.65 l=0.15 mult=1 sa=0.265
+ sb=0.265 sd=0.28 topography=normal area=0.063 perim=1.14
.ENDS

.SUBCKT sky130_fd_sc_hd__o21ai_2 A1 A2 B1 VGND VNB VPB VPWR Y
MMPA0 VPWR A1 sndA1 VPB pfet_01v8_hvt m=2 w=1.0 l=0.15 mult=1 sa=0.265
+ sb=0.265 sd=0.28 topography=normal area=0.063 perim=1.14
MMPA1 sndA1 A2 Y VPB pfet_01v8_hvt m=2 w=1.0 l=0.15 mult=1 sa=0.265
+ sb=0.265 sd=0.28 topography=normal area=0.063 perim=1.14
MMPB0 VPWR B1 Y VPB pfet_01v8_hvt m=2 w=1.0 l=0.15 mult=1 sa=0.265
+ sb=0.265 sd=0.28 topography=normal area=0.063 perim=1.14
MMNA0 pndA A1 VGND VNB nfet_01v8 m=2 w=0.65 l=0.15 mult=1 sa=0.265
+ sb=0.265 sd=0.28 topography=normal area=0.063 perim=1.14
MMNA1 pndA A2 VGND VNB nfet_01v8 m=2 w=0.65 l=0.15 mult=1 sa=0.265
+ sb=0.265 sd=0.28 topography=normal area=0.063 perim=1.14
MMNB0 Y B1 pndA VNB nfet_01v8 m=2 w=0.65 l=0.15 mult=1 sa=0.265
+ sb=0.265 sd=0.28 topography=normal area=0.063 perim=1.14
.ENDS

.SUBCKT sky130_fd_sc_hd__o21ai_4 A1 A2 B1 VGND VNB VPB VPWR Y
MMPA0 VPWR A1 sndA1 VPB pfet_01v8_hvt m=4 w=1.0 l=0.15 mult=1 sa=0.265
+ sb=0.265 sd=0.28 topography=normal area=0.063 perim=1.14
MMPA1 sndA1 A2 Y VPB pfet_01v8_hvt m=4 w=1.0 l=0.15 mult=1 sa=0.265
+ sb=0.265 sd=0.28 topography=normal area=0.063 perim=1.14
MMPB0 VPWR B1 Y VPB pfet_01v8_hvt m=4 w=1.0 l=0.15 mult=1 sa=0.265
+ sb=0.265 sd=0.28 topography=normal area=0.063 perim=1.14
MMNA0 pndA A1 VGND VNB nfet_01v8 m=4 w=0.65 l=0.15 mult=1 sa=0.265
+ sb=0.265 sd=0.28 topography=normal area=0.063 perim=1.14
MMNA1 pndA A2 VGND VNB nfet_01v8 m=4 w=0.65 l=0.15 mult=1 sa=0.265
+ sb=0.265 sd=0.28 topography=normal area=0.063 perim=1.14
MMNB0 Y B1 pndA VNB nfet_01v8 m=4 w=0.65 l=0.15 mult=1 sa=0.265
+ sb=0.265 sd=0.28 topography=normal area=0.063 perim=1.14
.ENDS

.SUBCKT sky130_fd_sc_hd__o21ba_1 A1 A2 B1_N VGND VNB VPB VPWR X
MMPA0 VPWR A1 sndA1 VPB pfet_01v8_hvt m=1 w=1.0 l=0.15 mult=1 sa=0.265
+ sb=0.265 sd=0.28 topography=normal area=0.063 perim=1.14
MMPA1 sndA1 A2 y VPB pfet_01v8_hvt m=1 w=1.0 l=0.15 mult=1 sa=0.265
+ sb=0.265 sd=0.28 topography=normal area=0.063 perim=1.14
MMPB0 VPWR B1 y VPB pfet_01v8_hvt m=1 w=1.0 l=0.15 mult=1 sa=0.265
+ sb=0.265 sd=0.28 topography=normal area=0.063 perim=1.14
MMIPB1N B1 B1_N VPWR VPB pfet_01v8_hvt m=1 w=0.42 l=0.15 mult=1
+ sa=0.265 sb=0.265 sd=0.28 topography=normal area=0.063 perim=1.14
MMIPX X y VPWR VPB pfet_01v8_hvt m=1 w=1.0 l=0.15 mult=1 sa=0.265
+ sb=0.265 sd=0.28 topography=normal area=0.063 perim=1.14
MMNA0 pndA A1 VGND VNB nfet_01v8 m=1 w=0.65 l=0.15 mult=1 sa=0.265
+ sb=0.265 sd=0.28 topography=normal area=0.063 perim=1.14
MMNA1 pndA A2 VGND VNB nfet_01v8 m=1 w=0.65 l=0.15 mult=1 sa=0.265
+ sb=0.265 sd=0.28 topography=normal area=0.063 perim=1.14
MMNB0 y B1 pndA VNB nfet_01v8 m=1 w=0.65 l=0.15 mult=1 sa=0.265
+ sb=0.265 sd=0.28 topography=normal area=0.063 perim=1.14
MMINB1N B1 B1_N VGND VNB nfet_01v8 m=1 w=0.42 l=0.15 mult=1 sa=0.265
+ sb=0.265 sd=0.28 topography=normal area=0.063 perim=1.14
MMINX X y VGND VNB nfet_01v8 m=1 w=0.65 l=0.15 mult=1 sa=0.265
+ sb=0.265 sd=0.28 topography=normal area=0.063 perim=1.14
.ENDS

.SUBCKT sky130_fd_sc_hd__o21ba_2 A1 A2 B1_N VGND VNB VPB VPWR X
MMPA0 VPWR A1 sndA1 VPB pfet_01v8_hvt m=1 w=1.0 l=0.15 mult=1 sa=0.265
+ sb=0.265 sd=0.28 topography=normal area=0.063 perim=1.14
MMPA1 sndA1 A2 y VPB pfet_01v8_hvt m=1 w=1.0 l=0.15 mult=1 sa=0.265
+ sb=0.265 sd=0.28 topography=normal area=0.063 perim=1.14
MMPB0 VPWR B1 y VPB pfet_01v8_hvt m=1 w=1.0 l=0.15 mult=1 sa=0.265
+ sb=0.265 sd=0.28 topography=normal area=0.063 perim=1.14
MMIPB1N B1 B1_N VPWR VPB pfet_01v8_hvt m=1 w=0.42 l=0.15 mult=1
+ sa=0.265 sb=0.265 sd=0.28 topography=normal area=0.063 perim=1.14
MMIPX X y VPWR VPB pfet_01v8_hvt m=2 w=1.0 l=0.15 mult=1 sa=0.265
+ sb=0.265 sd=0.28 topography=normal area=0.063 perim=1.14
MMNA0 pndA A1 VGND VNB nfet_01v8 m=1 w=0.65 l=0.15 mult=1 sa=0.265
+ sb=0.265 sd=0.28 topography=normal area=0.063 perim=1.14
MMNA1 pndA A2 VGND VNB nfet_01v8 m=1 w=0.65 l=0.15 mult=1 sa=0.265
+ sb=0.265 sd=0.28 topography=normal area=0.063 perim=1.14
MMNB0 y B1 pndA VNB nfet_01v8 m=1 w=0.65 l=0.15 mult=1 sa=0.265
+ sb=0.265 sd=0.28 topography=normal area=0.063 perim=1.14
MMINB1N B1 B1_N VGND VNB nfet_01v8 m=1 w=0.42 l=0.15 mult=1 sa=0.265
+ sb=0.265 sd=0.28 topography=normal area=0.063 perim=1.14
MMINX X y VGND VNB nfet_01v8 m=2 w=0.65 l=0.15 mult=1 sa=0.265
+ sb=0.265 sd=0.28 topography=normal area=0.063 perim=1.14
.ENDS

.SUBCKT sky130_fd_sc_hd__o21ba_4 A1 A2 B1_N VGND VNB VPB VPWR X
MMPA0 VPWR A1 sndA1 VPB pfet_01v8_hvt m=2 w=1.0 l=0.15 mult=1 sa=0.265
+ sb=0.265 sd=0.28 topography=normal area=0.063 perim=1.14
MMPA1 sndA1 A2 y VPB pfet_01v8_hvt m=2 w=1.0 l=0.15 mult=1 sa=0.265
+ sb=0.265 sd=0.28 topography=normal area=0.063 perim=1.14
MMPB0 VPWR B1 y VPB pfet_01v8_hvt m=2 w=1.0 l=0.15 mult=1 sa=0.265
+ sb=0.265 sd=0.28 topography=normal area=0.063 perim=1.14
MMIPB1N B1 B1_N VPWR VPB pfet_01v8_hvt m=1 w=1.0 l=0.15 mult=1
+ sa=0.265 sb=0.265 sd=0.28 topography=normal area=0.063 perim=1.14
MMIPX X y VPWR VPB pfet_01v8_hvt m=4 w=1.0 l=0.15 mult=1 sa=0.265
+ sb=0.265 sd=0.28 topography=normal area=0.063 perim=1.14
MMNA0 pndA A1 VGND VNB nfet_01v8 m=2 w=0.65 l=0.15 mult=1 sa=0.265
+ sb=0.265 sd=0.28 topography=normal area=0.063 perim=1.14
MMNA1 pndA A2 VGND VNB nfet_01v8 m=2 w=0.65 l=0.15 mult=1 sa=0.265
+ sb=0.265 sd=0.28 topography=normal area=0.063 perim=1.14
MMNB0 y B1 pndA VNB nfet_01v8 m=2 w=0.65 l=0.15 mult=1 sa=0.265
+ sb=0.265 sd=0.28 topography=normal area=0.063 perim=1.14
MMINB1N B1 B1_N VGND VNB nfet_01v8 m=1 w=0.65 l=0.15 mult=1 sa=0.265
+ sb=0.265 sd=0.28 topography=normal area=0.063 perim=1.14
MMINX X y VGND VNB nfet_01v8 m=4 w=0.65 l=0.15 mult=1 sa=0.265
+ sb=0.265 sd=0.28 topography=normal area=0.063 perim=1.14
.ENDS

.SUBCKT sky130_fd_sc_hd__o21bai_1 A1 A2 B1_N VGND VNB VPB VPWR Y
MMPA0 VPWR A1 sndA1 VPB pfet_01v8_hvt m=1 w=1.0 l=0.15 mult=1 sa=0.265
+ sb=0.265 sd=0.28 topography=normal area=0.063 perim=1.14
MMPA1 sndA1 A2 Y VPB pfet_01v8_hvt m=1 w=1.0 l=0.15 mult=1 sa=0.265
+ sb=0.265 sd=0.28 topography=normal area=0.063 perim=1.14
MMPB0 VPWR B1 Y VPB pfet_01v8_hvt m=1 w=1.0 l=0.15 mult=1 sa=0.265
+ sb=0.265 sd=0.28 topography=normal area=0.063 perim=1.14
MMIPB1N B1 B1_N VPWR VPB pfet_01v8_hvt m=1 w=0.42 l=0.15 mult=1
+ sa=0.265 sb=0.265 sd=0.28 topography=normal area=0.063 perim=1.14
MMNA0 pndA A1 VGND VNB nfet_01v8 m=1 w=0.65 l=0.15 mult=1 sa=0.265
+ sb=0.265 sd=0.28 topography=normal area=0.063 perim=1.14
MMNA1 pndA A2 VGND VNB nfet_01v8 m=1 w=0.65 l=0.15 mult=1 sa=0.265
+ sb=0.265 sd=0.28 topography=normal area=0.063 perim=1.14
MMNB0 Y B1 pndA VNB nfet_01v8 m=1 w=0.65 l=0.15 mult=1 sa=0.265
+ sb=0.265 sd=0.28 topography=normal area=0.063 perim=1.14
MMINB1N B1 B1_N VGND VNB nfet_01v8 m=1 w=0.42 l=0.15 mult=1 sa=0.265
+ sb=0.265 sd=0.28 topography=normal area=0.063 perim=1.14
.ENDS

.SUBCKT sky130_fd_sc_hd__o21bai_2 A1 A2 B1_N VGND VNB VPB VPWR Y
MMPA0 VPWR A1 sndA1 VPB pfet_01v8_hvt m=2 w=1.0 l=0.15 mult=1 sa=0.265
+ sb=0.265 sd=0.28 topography=normal area=0.063 perim=1.14
MMPA1 sndA1 A2 Y VPB pfet_01v8_hvt m=2 w=1.0 l=0.15 mult=1 sa=0.265
+ sb=0.265 sd=0.28 topography=normal area=0.063 perim=1.14
MMPB0 VPWR B1 Y VPB pfet_01v8_hvt m=2 w=1.0 l=0.15 mult=1 sa=0.265
+ sb=0.265 sd=0.28 topography=normal area=0.063 perim=1.14
MMIPB1N B1 B1_N VPWR VPB pfet_01v8_hvt m=1 w=0.42 l=0.15 mult=1
+ sa=0.265 sb=0.265 sd=0.28 topography=normal area=0.063 perim=1.14
MMNA0 pndA A1 VGND VNB nfet_01v8 m=2 w=0.65 l=0.15 mult=1 sa=0.265
+ sb=0.265 sd=0.28 topography=normal area=0.063 perim=1.14
MMNA1 pndA A2 VGND VNB nfet_01v8 m=2 w=0.65 l=0.15 mult=1 sa=0.265
+ sb=0.265 sd=0.28 topography=normal area=0.063 perim=1.14
MMNB0 Y B1 pndA VNB nfet_01v8 m=2 w=0.65 l=0.15 mult=1 sa=0.265
+ sb=0.265 sd=0.28 topography=normal area=0.063 perim=1.14
MMINB1N B1 B1_N VGND VNB nfet_01v8 m=1 w=0.42 l=0.15 mult=1 sa=0.265
+ sb=0.265 sd=0.28 topography=normal area=0.063 perim=1.14
.ENDS

.SUBCKT sky130_fd_sc_hd__o21bai_4 A1 A2 B1_N VGND VNB VPB VPWR Y
MMPA0 VPWR A1 sndA1 VPB pfet_01v8_hvt m=4 w=1.0 l=0.15 mult=1 sa=0.265
+ sb=0.265 sd=0.28 topography=normal area=0.063 perim=1.14
MMPA1 sndA1 A2 Y VPB pfet_01v8_hvt m=4 w=1.0 l=0.15 mult=1 sa=0.265
+ sb=0.265 sd=0.28 topography=normal area=0.063 perim=1.14
MMPB0 VPWR B1 Y VPB pfet_01v8_hvt m=4 w=1.0 l=0.15 mult=1 sa=0.265
+ sb=0.265 sd=0.28 topography=normal area=0.063 perim=1.14
MMIPB1N B1 B1_N VPWR VPB pfet_01v8_hvt m=1 w=1.0 l=0.15 mult=1
+ sa=0.265 sb=0.265 sd=0.28 topography=normal area=0.063 perim=1.14
MMNA0 pndA A1 VGND VNB nfet_01v8 m=4 w=0.65 l=0.15 mult=1 sa=0.265
+ sb=0.265 sd=0.28 topography=normal area=0.063 perim=1.14
MMNA1 pndA A2 VGND VNB nfet_01v8 m=4 w=0.65 l=0.15 mult=1 sa=0.265
+ sb=0.265 sd=0.28 topography=normal area=0.063 perim=1.14
MMNB0 Y B1 pndA VNB nfet_01v8 m=4 w=0.65 l=0.15 mult=1 sa=0.265
+ sb=0.265 sd=0.28 topography=normal area=0.063 perim=1.14
MMINB1N B1 B1_N VGND VNB nfet_01v8 m=1 w=0.65 l=0.15 mult=1 sa=0.265
+ sb=0.265 sd=0.28 topography=normal area=0.063 perim=1.14
.ENDS

.SUBCKT sky130_fd_sc_hd__o22a_1 A1 A2 B1 B2 VGND VNB VPB VPWR X
MMPA0 VPWR A1 sndA1 VPB pfet_01v8_hvt m=1 w=1.0 l=0.15 mult=1 sa=0.265
+ sb=0.265 sd=0.28 topography=normal area=0.063 perim=1.14
MMPA1 sndA1 A2 y VPB pfet_01v8_hvt m=1 w=1.0 l=0.15 mult=1 sa=0.265
+ sb=0.265 sd=0.28 topography=normal area=0.063 perim=1.14
MMPB0 VPWR B1 sndB1 VPB pfet_01v8_hvt m=1 w=1.0 l=0.15 mult=1 sa=0.265
+ sb=0.265 sd=0.28 topography=normal area=0.063 perim=1.14
MMPB1 sndB1 B2 y VPB pfet_01v8_hvt m=1 w=1.0 l=0.15 mult=1 sa=0.265
+ sb=0.265 sd=0.28 topography=normal area=0.063 perim=1.14
MMIPX X y VPWR VPB pfet_01v8_hvt m=1 w=1.0 l=0.15 mult=1 sa=0.265
+ sb=0.265 sd=0.28 topography=normal area=0.063 perim=1.14
MMNA0 pndA A1 VGND VNB nfet_01v8 m=1 w=0.65 l=0.15 mult=1 sa=0.265
+ sb=0.265 sd=0.28 topography=normal area=0.063 perim=1.14
MMNA1 pndA A2 VGND VNB nfet_01v8 m=1 w=0.65 l=0.15 mult=1 sa=0.265
+ sb=0.265 sd=0.28 topography=normal area=0.063 perim=1.14
MMNB0 y B1 pndA VNB nfet_01v8 m=1 w=0.65 l=0.15 mult=1 sa=0.265
+ sb=0.265 sd=0.28 topography=normal area=0.063 perim=1.14
MMNB1 y B2 pndA VNB nfet_01v8 m=1 w=0.65 l=0.15 mult=1 sa=0.265
+ sb=0.265 sd=0.28 topography=normal area=0.063 perim=1.14
MMINX X y VGND VNB nfet_01v8 m=1 w=0.65 l=0.15 mult=1 sa=0.265
+ sb=0.265 sd=0.28 topography=normal area=0.063 perim=1.14
.ENDS

.SUBCKT sky130_fd_sc_hd__o22a_2 A1 A2 B1 B2 VGND VNB VPB VPWR X
MMPA0 VPWR A1 sndA1 VPB pfet_01v8_hvt m=1 w=1.0 l=0.15 mult=1 sa=0.265
+ sb=0.265 sd=0.28 topography=normal area=0.063 perim=1.14
MMPA1 sndA1 A2 y VPB pfet_01v8_hvt m=1 w=1.0 l=0.15 mult=1 sa=0.265
+ sb=0.265 sd=0.28 topography=normal area=0.063 perim=1.14
MMPB0 VPWR B1 sndB1 VPB pfet_01v8_hvt m=1 w=1.0 l=0.15 mult=1 sa=0.265
+ sb=0.265 sd=0.28 topography=normal area=0.063 perim=1.14
MMPB1 sndB1 B2 y VPB pfet_01v8_hvt m=1 w=1.0 l=0.15 mult=1 sa=0.265
+ sb=0.265 sd=0.28 topography=normal area=0.063 perim=1.14
MMIPX X y VPWR VPB pfet_01v8_hvt m=2 w=1.0 l=0.15 mult=1 sa=0.265
+ sb=0.265 sd=0.28 topography=normal area=0.063 perim=1.14
MMNA0 pndA A1 VGND VNB nfet_01v8 m=1 w=0.65 l=0.15 mult=1 sa=0.265
+ sb=0.265 sd=0.28 topography=normal area=0.063 perim=1.14
MMNA1 pndA A2 VGND VNB nfet_01v8 m=1 w=0.65 l=0.15 mult=1 sa=0.265
+ sb=0.265 sd=0.28 topography=normal area=0.063 perim=1.14
MMNB0 y B1 pndA VNB nfet_01v8 m=1 w=0.65 l=0.15 mult=1 sa=0.265
+ sb=0.265 sd=0.28 topography=normal area=0.063 perim=1.14
MMNB1 y B2 pndA VNB nfet_01v8 m=1 w=0.65 l=0.15 mult=1 sa=0.265
+ sb=0.265 sd=0.28 topography=normal area=0.063 perim=1.14
MMINX X y VGND VNB nfet_01v8 m=2 w=0.65 l=0.15 mult=1 sa=0.265
+ sb=0.265 sd=0.28 topography=normal area=0.063 perim=1.14
.ENDS

.SUBCKT sky130_fd_sc_hd__o22a_4 A1 A2 B1 B2 VGND VNB VPB VPWR X
MMPA0 VPWR A1 sndA1 VPB pfet_01v8_hvt m=2 w=1.0 l=0.15 mult=1 sa=0.265
+ sb=0.265 sd=0.28 topography=normal area=0.063 perim=1.14
MMPA1 sndA1 A2 y VPB pfet_01v8_hvt m=2 w=1.0 l=0.15 mult=1 sa=0.265
+ sb=0.265 sd=0.28 topography=normal area=0.063 perim=1.14
MMPB0 VPWR B1 sndB1 VPB pfet_01v8_hvt m=2 w=1.0 l=0.15 mult=1 sa=0.265
+ sb=0.265 sd=0.28 topography=normal area=0.063 perim=1.14
MMPB1 sndB1 B2 y VPB pfet_01v8_hvt m=2 w=1.0 l=0.15 mult=1 sa=0.265
+ sb=0.265 sd=0.28 topography=normal area=0.063 perim=1.14
MMIPX X y VPWR VPB pfet_01v8_hvt m=4 w=1.0 l=0.15 mult=1 sa=0.265
+ sb=0.265 sd=0.28 topography=normal area=0.063 perim=1.14
MMNA0 pndA A1 VGND VNB nfet_01v8 m=2 w=0.65 l=0.15 mult=1 sa=0.265
+ sb=0.265 sd=0.28 topography=normal area=0.063 perim=1.14
MMNA1 pndA A2 VGND VNB nfet_01v8 m=2 w=0.65 l=0.15 mult=1 sa=0.265
+ sb=0.265 sd=0.28 topography=normal area=0.063 perim=1.14
MMNB0 y B1 pndA VNB nfet_01v8 m=2 w=0.65 l=0.15 mult=1 sa=0.265
+ sb=0.265 sd=0.28 topography=normal area=0.063 perim=1.14
MMNB1 y B2 pndA VNB nfet_01v8 m=2 w=0.65 l=0.15 mult=1 sa=0.265
+ sb=0.265 sd=0.28 topography=normal area=0.063 perim=1.14
MMINX X y VGND VNB nfet_01v8 m=4 w=0.65 l=0.15 mult=1 sa=0.265
+ sb=0.265 sd=0.28 topography=normal area=0.063 perim=1.14
.ENDS

.SUBCKT sky130_fd_sc_hd__o22ai_1 A1 A2 B1 B2 VGND VNB VPB VPWR Y
MMPA0 VPWR A1 sndA1 VPB pfet_01v8_hvt m=1 w=1.0 l=0.15 mult=1 sa=0.265
+ sb=0.265 sd=0.28 topography=normal area=0.063 perim=1.14
MMPA1 sndA1 A2 Y VPB pfet_01v8_hvt m=1 w=1.0 l=0.15 mult=1 sa=0.265
+ sb=0.265 sd=0.28 topography=normal area=0.063 perim=1.14
MMPB0 VPWR B1 sndB1 VPB pfet_01v8_hvt m=1 w=1.0 l=0.15 mult=1 sa=0.265
+ sb=0.265 sd=0.28 topography=normal area=0.063 perim=1.14
MMPB1 sndB1 B2 Y VPB pfet_01v8_hvt m=1 w=1.0 l=0.15 mult=1 sa=0.265
+ sb=0.265 sd=0.28 topography=normal area=0.063 perim=1.14
MMNA0 pndA A1 VGND VNB nfet_01v8 m=1 w=0.65 l=0.15 mult=1 sa=0.265
+ sb=0.265 sd=0.28 topography=normal area=0.063 perim=1.14
MMNA1 pndA A2 VGND VNB nfet_01v8 m=1 w=0.65 l=0.15 mult=1 sa=0.265
+ sb=0.265 sd=0.28 topography=normal area=0.063 perim=1.14
MMNB0 Y B1 pndA VNB nfet_01v8 m=1 w=0.65 l=0.15 mult=1 sa=0.265
+ sb=0.265 sd=0.28 topography=normal area=0.063 perim=1.14
MMNB1 Y B2 pndA VNB nfet_01v8 m=1 w=0.65 l=0.15 mult=1 sa=0.265
+ sb=0.265 sd=0.28 topography=normal area=0.063 perim=1.14
.ENDS

.SUBCKT sky130_fd_sc_hd__o22ai_2 A1 A2 B1 B2 VGND VNB VPB VPWR Y
MMPA0 VPWR A1 sndA1 VPB pfet_01v8_hvt m=2 w=1.0 l=0.15 mult=1 sa=0.265
+ sb=0.265 sd=0.28 topography=normal area=0.063 perim=1.14
MMPA1 sndA1 A2 Y VPB pfet_01v8_hvt m=2 w=1.0 l=0.15 mult=1 sa=0.265
+ sb=0.265 sd=0.28 topography=normal area=0.063 perim=1.14
MMPB0 VPWR B1 sndB1 VPB pfet_01v8_hvt m=2 w=1.0 l=0.15 mult=1 sa=0.265
+ sb=0.265 sd=0.28 topography=normal area=0.063 perim=1.14
MMPB1 sndB1 B2 Y VPB pfet_01v8_hvt m=2 w=1.0 l=0.15 mult=1 sa=0.265
+ sb=0.265 sd=0.28 topography=normal area=0.063 perim=1.14
MMNA0 pndA A1 VGND VNB nfet_01v8 m=2 w=0.65 l=0.15 mult=1 sa=0.265
+ sb=0.265 sd=0.28 topography=normal area=0.063 perim=1.14
MMNA1 pndA A2 VGND VNB nfet_01v8 m=2 w=0.65 l=0.15 mult=1 sa=0.265
+ sb=0.265 sd=0.28 topography=normal area=0.063 perim=1.14
MMNB0 Y B1 pndA VNB nfet_01v8 m=2 w=0.65 l=0.15 mult=1 sa=0.265
+ sb=0.265 sd=0.28 topography=normal area=0.063 perim=1.14
MMNB1 Y B2 pndA VNB nfet_01v8 m=2 w=0.65 l=0.15 mult=1 sa=0.265
+ sb=0.265 sd=0.28 topography=normal area=0.063 perim=1.14
.ENDS

.SUBCKT sky130_fd_sc_hd__o22ai_4 A1 A2 B1 B2 VGND VNB VPB VPWR Y
MMPA0 VPWR A1 sndA1 VPB pfet_01v8_hvt m=4 w=1.0 l=0.15 mult=1 sa=0.265
+ sb=0.265 sd=0.28 topography=normal area=0.063 perim=1.14
MMPA1 sndA1 A2 Y VPB pfet_01v8_hvt m=4 w=1.0 l=0.15 mult=1 sa=0.265
+ sb=0.265 sd=0.28 topography=normal area=0.063 perim=1.14
MMPB0 VPWR B1 sndB1 VPB pfet_01v8_hvt m=4 w=1.0 l=0.15 mult=1 sa=0.265
+ sb=0.265 sd=0.28 topography=normal area=0.063 perim=1.14
MMPB1 sndB1 B2 Y VPB pfet_01v8_hvt m=4 w=1.0 l=0.15 mult=1 sa=0.265
+ sb=0.265 sd=0.28 topography=normal area=0.063 perim=1.14
MMNA0 pndA A1 VGND VNB nfet_01v8 m=4 w=0.65 l=0.15 mult=1 sa=0.265
+ sb=0.265 sd=0.28 topography=normal area=0.063 perim=1.14
MMNA1 pndA A2 VGND VNB nfet_01v8 m=4 w=0.65 l=0.15 mult=1 sa=0.265
+ sb=0.265 sd=0.28 topography=normal area=0.063 perim=1.14
MMNB0 Y B1 pndA VNB nfet_01v8 m=4 w=0.65 l=0.15 mult=1 sa=0.265
+ sb=0.265 sd=0.28 topography=normal area=0.063 perim=1.14
MMNB1 Y B2 pndA VNB nfet_01v8 m=4 w=0.65 l=0.15 mult=1 sa=0.265
+ sb=0.265 sd=0.28 topography=normal area=0.063 perim=1.14
.ENDS

.SUBCKT sky130_fd_sc_hd__o31a_1 A1 A2 A3 B1 VGND VNB VPB VPWR X
MMPA0 VPWR A1 sndA1 VPB pfet_01v8_hvt m=1 w=1.0 l=0.15 mult=1 sa=0.265
+ sb=0.265 sd=0.28 topography=normal area=0.063 perim=1.14
MMPA1 sndA1 A2 sndA2 VPB pfet_01v8_hvt m=1 w=1.0 l=0.15 mult=1
+ sa=0.265 sb=0.265 sd=0.28 topography=normal area=0.063 perim=1.14
MMPA2 sndA2 A3 y VPB pfet_01v8_hvt m=1 w=1.0 l=0.15 mult=1 sa=0.265
+ sb=0.265 sd=0.28 topography=normal area=0.063 perim=1.14
MMPB0 VPWR B1 y VPB pfet_01v8_hvt m=1 w=1.0 l=0.15 mult=1 sa=0.265
+ sb=0.265 sd=0.28 topography=normal area=0.063 perim=1.14
MMIPX X y VPWR VPB pfet_01v8_hvt m=1 w=1.0 l=0.15 mult=1 sa=0.265
+ sb=0.265 sd=0.28 topography=normal area=0.063 perim=1.14
MMNA0 pndA A1 VGND VNB nfet_01v8 m=1 w=0.65 l=0.15 mult=1 sa=0.265
+ sb=0.265 sd=0.28 topography=normal area=0.063 perim=1.14
MMNA1 pndA A2 VGND VNB nfet_01v8 m=1 w=0.65 l=0.15 mult=1 sa=0.265
+ sb=0.265 sd=0.28 topography=normal area=0.063 perim=1.14
MMNA2 pndA A3 VGND VNB nfet_01v8 m=1 w=0.65 l=0.15 mult=1 sa=0.265
+ sb=0.265 sd=0.28 topography=normal area=0.063 perim=1.14
MMNB0 y B1 pndA VNB nfet_01v8 m=1 w=0.65 l=0.15 mult=1 sa=0.265
+ sb=0.265 sd=0.28 topography=normal area=0.063 perim=1.14
MMINX X y VGND VNB nfet_01v8 m=1 w=0.65 l=0.15 mult=1 sa=0.265
+ sb=0.265 sd=0.28 topography=normal area=0.063 perim=1.14
.ENDS

.SUBCKT sky130_fd_sc_hd__o31a_2 A1 A2 A3 B1 VGND VNB VPB VPWR X
MMPA0 VPWR A1 sndA1 VPB pfet_01v8_hvt m=1 w=1.0 l=0.15 mult=1 sa=0.265
+ sb=0.265 sd=0.28 topography=normal area=0.063 perim=1.14
MMPA1 sndA1 A2 sndA2 VPB pfet_01v8_hvt m=1 w=1.0 l=0.15 mult=1
+ sa=0.265 sb=0.265 sd=0.28 topography=normal area=0.063 perim=1.14
MMPA2 sndA2 A3 y VPB pfet_01v8_hvt m=1 w=1.0 l=0.15 mult=1 sa=0.265
+ sb=0.265 sd=0.28 topography=normal area=0.063 perim=1.14
MMPB0 VPWR B1 y VPB pfet_01v8_hvt m=1 w=1.0 l=0.15 mult=1 sa=0.265
+ sb=0.265 sd=0.28 topography=normal area=0.063 perim=1.14
MMIPX X y VPWR VPB pfet_01v8_hvt m=2 w=1.0 l=0.15 mult=1 sa=0.265
+ sb=0.265 sd=0.28 topography=normal area=0.063 perim=1.14
MMNA0 pndA A1 VGND VNB nfet_01v8 m=1 w=0.65 l=0.15 mult=1 sa=0.265
+ sb=0.265 sd=0.28 topography=normal area=0.063 perim=1.14
MMNA1 pndA A2 VGND VNB nfet_01v8 m=1 w=0.65 l=0.15 mult=1 sa=0.265
+ sb=0.265 sd=0.28 topography=normal area=0.063 perim=1.14
MMNA2 pndA A3 VGND VNB nfet_01v8 m=1 w=0.65 l=0.15 mult=1 sa=0.265
+ sb=0.265 sd=0.28 topography=normal area=0.063 perim=1.14
MMNB0 y B1 pndA VNB nfet_01v8 m=1 w=0.65 l=0.15 mult=1 sa=0.265
+ sb=0.265 sd=0.28 topography=normal area=0.063 perim=1.14
MMINX X y VGND VNB nfet_01v8 m=2 w=0.65 l=0.15 mult=1 sa=0.265
+ sb=0.265 sd=0.28 topography=normal area=0.063 perim=1.14
.ENDS

.SUBCKT sky130_fd_sc_hd__o31a_4 A1 A2 A3 B1 VGND VNB VPB VPWR X
MMPA0 VPWR A1 sndA1 VPB pfet_01v8_hvt m=2 w=1.0 l=0.15 mult=1 sa=0.265
+ sb=0.265 sd=0.28 topography=normal area=0.063 perim=1.14
MMPA1 sndA1 A2 sndA2 VPB pfet_01v8_hvt m=2 w=1.0 l=0.15 mult=1
+ sa=0.265 sb=0.265 sd=0.28 topography=normal area=0.063 perim=1.14
MMPA2 sndA2 A3 y VPB pfet_01v8_hvt m=2 w=1.0 l=0.15 mult=1 sa=0.265
+ sb=0.265 sd=0.28 topography=normal area=0.063 perim=1.14
MMPB0 VPWR B1 y VPB pfet_01v8_hvt m=2 w=1.0 l=0.15 mult=1 sa=0.265
+ sb=0.265 sd=0.28 topography=normal area=0.063 perim=1.14
MMIPX X y VPWR VPB pfet_01v8_hvt m=4 w=1.0 l=0.15 mult=1 sa=0.265
+ sb=0.265 sd=0.28 topography=normal area=0.063 perim=1.14
MMNA0 pndA A1 VGND VNB nfet_01v8 m=2 w=0.65 l=0.15 mult=1 sa=0.265
+ sb=0.265 sd=0.28 topography=normal area=0.063 perim=1.14
MMNA1 pndA A2 VGND VNB nfet_01v8 m=2 w=0.65 l=0.15 mult=1 sa=0.265
+ sb=0.265 sd=0.28 topography=normal area=0.063 perim=1.14
MMNA2 pndA A3 VGND VNB nfet_01v8 m=2 w=0.65 l=0.15 mult=1 sa=0.265
+ sb=0.265 sd=0.28 topography=normal area=0.063 perim=1.14
MMNB0 y B1 pndA VNB nfet_01v8 m=2 w=0.65 l=0.15 mult=1 sa=0.265
+ sb=0.265 sd=0.28 topography=normal area=0.063 perim=1.14
MMINX X y VGND VNB nfet_01v8 m=4 w=0.65 l=0.15 mult=1 sa=0.265
+ sb=0.265 sd=0.28 topography=normal area=0.063 perim=1.14
.ENDS

.SUBCKT sky130_fd_sc_hd__o31ai_1 A1 A2 A3 B1 VGND VNB VPB VPWR Y
MMPA0 VPWR A1 sndA1 VPB pfet_01v8_hvt m=1 w=1.0 l=0.15 mult=1 sa=0.265
+ sb=0.265 sd=0.28 topography=normal area=0.063 perim=1.14
MMPA1 sndA1 A2 sndA2 VPB pfet_01v8_hvt m=1 w=1.0 l=0.15 mult=1
+ sa=0.265 sb=0.265 sd=0.28 topography=normal area=0.063 perim=1.14
MMPA2 sndA2 A3 Y VPB pfet_01v8_hvt m=1 w=1.0 l=0.15 mult=1 sa=0.265
+ sb=0.265 sd=0.28 topography=normal area=0.063 perim=1.14
MMPB0 VPWR B1 Y VPB pfet_01v8_hvt m=1 w=1.0 l=0.15 mult=1 sa=0.265
+ sb=0.265 sd=0.28 topography=normal area=0.063 perim=1.14
MMNA0 pndA A1 VGND VNB nfet_01v8 m=1 w=0.65 l=0.15 mult=1 sa=0.265
+ sb=0.265 sd=0.28 topography=normal area=0.063 perim=1.14
MMNA1 pndA A2 VGND VNB nfet_01v8 m=1 w=0.65 l=0.15 mult=1 sa=0.265
+ sb=0.265 sd=0.28 topography=normal area=0.063 perim=1.14
MMNA2 pndA A3 VGND VNB nfet_01v8 m=1 w=0.65 l=0.15 mult=1 sa=0.265
+ sb=0.265 sd=0.28 topography=normal area=0.063 perim=1.14
MMNB0 Y B1 pndA VNB nfet_01v8 m=1 w=0.65 l=0.15 mult=1 sa=0.265
+ sb=0.265 sd=0.28 topography=normal area=0.063 perim=1.14
.ENDS

.SUBCKT sky130_fd_sc_hd__o31ai_2 A1 A2 A3 B1 VGND VNB VPB VPWR Y
MMPA0 VPWR A1 sndA1 VPB pfet_01v8_hvt m=2 w=1.0 l=0.15 mult=1 sa=0.265
+ sb=0.265 sd=0.28 topography=normal area=0.063 perim=1.14
MMPA1 sndA1 A2 sndA2 VPB pfet_01v8_hvt m=2 w=1.0 l=0.15 mult=1
+ sa=0.265 sb=0.265 sd=0.28 topography=normal area=0.063 perim=1.14
MMPA2 sndA2 A3 Y VPB pfet_01v8_hvt m=2 w=1.0 l=0.15 mult=1 sa=0.265
+ sb=0.265 sd=0.28 topography=normal area=0.063 perim=1.14
MMPB0 VPWR B1 Y VPB pfet_01v8_hvt m=2 w=1.0 l=0.15 mult=1 sa=0.265
+ sb=0.265 sd=0.28 topography=normal area=0.063 perim=1.14
MMNA0 pndA A1 VGND VNB nfet_01v8 m=2 w=0.65 l=0.15 mult=1 sa=0.265
+ sb=0.265 sd=0.28 topography=normal area=0.063 perim=1.14
MMNA1 pndA A2 VGND VNB nfet_01v8 m=2 w=0.65 l=0.15 mult=1 sa=0.265
+ sb=0.265 sd=0.28 topography=normal area=0.063 perim=1.14
MMNA2 pndA A3 VGND VNB nfet_01v8 m=2 w=0.65 l=0.15 mult=1 sa=0.265
+ sb=0.265 sd=0.28 topography=normal area=0.063 perim=1.14
MMNB0 Y B1 pndA VNB nfet_01v8 m=2 w=0.65 l=0.15 mult=1 sa=0.265
+ sb=0.265 sd=0.28 topography=normal area=0.063 perim=1.14
.ENDS

.SUBCKT sky130_fd_sc_hd__o31ai_4 A1 A2 A3 B1 VGND VNB VPB VPWR Y
MMPA0 VPWR A1 sndA1 VPB pfet_01v8_hvt m=4 w=1.0 l=0.15 mult=1 sa=0.265
+ sb=0.265 sd=0.28 topography=normal area=0.063 perim=1.14
MMPA1 sndA1 A2 sndA2 VPB pfet_01v8_hvt m=4 w=1.0 l=0.15 mult=1
+ sa=0.265 sb=0.265 sd=0.28 topography=normal area=0.063 perim=1.14
MMPA2 sndA2 A3 Y VPB pfet_01v8_hvt m=4 w=1.0 l=0.15 mult=1 sa=0.265
+ sb=0.265 sd=0.28 topography=normal area=0.063 perim=1.14
MMPB0 VPWR B1 Y VPB pfet_01v8_hvt m=4 w=1.0 l=0.15 mult=1 sa=0.265
+ sb=0.265 sd=0.28 topography=normal area=0.063 perim=1.14
MMNA0 pndA A1 VGND VNB nfet_01v8 m=4 w=0.65 l=0.15 mult=1 sa=0.265
+ sb=0.265 sd=0.28 topography=normal area=0.063 perim=1.14
MMNA1 pndA A2 VGND VNB nfet_01v8 m=4 w=0.65 l=0.15 mult=1 sa=0.265
+ sb=0.265 sd=0.28 topography=normal area=0.063 perim=1.14
MMNA2 pndA A3 VGND VNB nfet_01v8 m=4 w=0.65 l=0.15 mult=1 sa=0.265
+ sb=0.265 sd=0.28 topography=normal area=0.063 perim=1.14
MMNB0 Y B1 pndA VNB nfet_01v8 m=4 w=0.65 l=0.15 mult=1 sa=0.265
+ sb=0.265 sd=0.28 topography=normal area=0.063 perim=1.14
.ENDS

.SUBCKT sky130_fd_sc_hd__o32a_1 A1 A2 A3 B1 B2 VGND VNB VPB VPWR X
MMPA0 VPWR A1 sndA1 VPB pfet_01v8_hvt m=1 w=1.0 l=0.15 mult=1 sa=0.265
+ sb=0.265 sd=0.28 topography=normal area=0.063 perim=1.14
MMPA1 sndA1 A2 sndA2 VPB pfet_01v8_hvt m=1 w=1.0 l=0.15 mult=1
+ sa=0.265 sb=0.265 sd=0.28 topography=normal area=0.063 perim=1.14
MMPA2 sndA2 A3 y VPB pfet_01v8_hvt m=1 w=1.0 l=0.15 mult=1 sa=0.265
+ sb=0.265 sd=0.28 topography=normal area=0.063 perim=1.14
MMPB0 VPWR B1 sndB1 VPB pfet_01v8_hvt m=1 w=1.0 l=0.15 mult=1 sa=0.265
+ sb=0.265 sd=0.28 topography=normal area=0.063 perim=1.14
MMPB1 sndB1 B2 y VPB pfet_01v8_hvt m=1 w=1.0 l=0.15 mult=1 sa=0.265
+ sb=0.265 sd=0.28 topography=normal area=0.063 perim=1.14
MMIPX X y VPWR VPB pfet_01v8_hvt m=1 w=1.0 l=0.15 mult=1 sa=0.265
+ sb=0.265 sd=0.28 topography=normal area=0.063 perim=1.14
MMNA0 pndA A1 VGND VNB nfet_01v8 m=1 w=0.65 l=0.15 mult=1 sa=0.265
+ sb=0.265 sd=0.28 topography=normal area=0.063 perim=1.14
MMNA1 pndA A2 VGND VNB nfet_01v8 m=1 w=0.65 l=0.15 mult=1 sa=0.265
+ sb=0.265 sd=0.28 topography=normal area=0.063 perim=1.14
MMNA2 pndA A3 VGND VNB nfet_01v8 m=1 w=0.65 l=0.15 mult=1 sa=0.265
+ sb=0.265 sd=0.28 topography=normal area=0.063 perim=1.14
MMNB0 y B1 pndA VNB nfet_01v8 m=1 w=0.65 l=0.15 mult=1 sa=0.265
+ sb=0.265 sd=0.28 topography=normal area=0.063 perim=1.14
MMNB1 y B2 pndA VNB nfet_01v8 m=1 w=0.65 l=0.15 mult=1 sa=0.265
+ sb=0.265 sd=0.28 topography=normal area=0.063 perim=1.14
MMINX X y VGND VNB nfet_01v8 m=1 w=0.65 l=0.15 mult=1 sa=0.265
+ sb=0.265 sd=0.28 topography=normal area=0.063 perim=1.14
.ENDS

.SUBCKT sky130_fd_sc_hd__o32a_2 A1 A2 A3 B1 B2 VGND VNB VPB VPWR X
MMPA0 VPWR A1 sndA1 VPB pfet_01v8_hvt m=1 w=1.0 l=0.15 mult=1 sa=0.265
+ sb=0.265 sd=0.28 topography=normal area=0.063 perim=1.14
MMPA1 sndA1 A2 sndA2 VPB pfet_01v8_hvt m=1 w=1.0 l=0.15 mult=1
+ sa=0.265 sb=0.265 sd=0.28 topography=normal area=0.063 perim=1.14
MMPA2 sndA2 A3 y VPB pfet_01v8_hvt m=1 w=1.0 l=0.15 mult=1 sa=0.265
+ sb=0.265 sd=0.28 topography=normal area=0.063 perim=1.14
MMPB0 VPWR B1 sndB1 VPB pfet_01v8_hvt m=1 w=1.0 l=0.15 mult=1 sa=0.265
+ sb=0.265 sd=0.28 topography=normal area=0.063 perim=1.14
MMPB1 sndB1 B2 y VPB pfet_01v8_hvt m=1 w=1.0 l=0.15 mult=1 sa=0.265
+ sb=0.265 sd=0.28 topography=normal area=0.063 perim=1.14
MMIPX X y VPWR VPB pfet_01v8_hvt m=2 w=1.0 l=0.15 mult=1 sa=0.265
+ sb=0.265 sd=0.28 topography=normal area=0.063 perim=1.14
MMNA0 pndA A1 VGND VNB nfet_01v8 m=1 w=0.65 l=0.15 mult=1 sa=0.265
+ sb=0.265 sd=0.28 topography=normal area=0.063 perim=1.14
MMNA1 pndA A2 VGND VNB nfet_01v8 m=1 w=0.65 l=0.15 mult=1 sa=0.265
+ sb=0.265 sd=0.28 topography=normal area=0.063 perim=1.14
MMNA2 pndA A3 VGND VNB nfet_01v8 m=1 w=0.65 l=0.15 mult=1 sa=0.265
+ sb=0.265 sd=0.28 topography=normal area=0.063 perim=1.14
MMNB0 y B1 pndA VNB nfet_01v8 m=1 w=0.65 l=0.15 mult=1 sa=0.265
+ sb=0.265 sd=0.28 topography=normal area=0.063 perim=1.14
MMNB1 y B2 pndA VNB nfet_01v8 m=1 w=0.65 l=0.15 mult=1 sa=0.265
+ sb=0.265 sd=0.28 topography=normal area=0.063 perim=1.14
MMINX X y VGND VNB nfet_01v8 m=2 w=0.65 l=0.15 mult=1 sa=0.265
+ sb=0.265 sd=0.28 topography=normal area=0.063 perim=1.14
.ENDS

.SUBCKT sky130_fd_sc_hd__o32a_4 A1 A2 A3 B1 B2 VGND VNB VPB VPWR X
MMPA0 VPWR A1 sndA1 VPB pfet_01v8_hvt m=2 w=1.0 l=0.15 mult=1 sa=0.265
+ sb=0.265 sd=0.28 topography=normal area=0.063 perim=1.14
MMPA1 sndA1 A2 sndA2 VPB pfet_01v8_hvt m=2 w=1.0 l=0.15 mult=1
+ sa=0.265 sb=0.265 sd=0.28 topography=normal area=0.063 perim=1.14
MMPA2 sndA2 A3 y VPB pfet_01v8_hvt m=2 w=1.0 l=0.15 mult=1 sa=0.265
+ sb=0.265 sd=0.28 topography=normal area=0.063 perim=1.14
MMPB0 VPWR B1 sndB1 VPB pfet_01v8_hvt m=2 w=1.0 l=0.15 mult=1 sa=0.265
+ sb=0.265 sd=0.28 topography=normal area=0.063 perim=1.14
MMPB1 sndB1 B2 y VPB pfet_01v8_hvt m=2 w=1.0 l=0.15 mult=1 sa=0.265
+ sb=0.265 sd=0.28 topography=normal area=0.063 perim=1.14
MMIPX X y VPWR VPB pfet_01v8_hvt m=4 w=1.0 l=0.15 mult=1 sa=0.265
+ sb=0.265 sd=0.28 topography=normal area=0.063 perim=1.14
MMNA0 pndA A1 VGND VNB nfet_01v8 m=2 w=0.65 l=0.15 mult=1 sa=0.265
+ sb=0.265 sd=0.28 topography=normal area=0.063 perim=1.14
MMNA1 pndA A2 VGND VNB nfet_01v8 m=2 w=0.65 l=0.15 mult=1 sa=0.265
+ sb=0.265 sd=0.28 topography=normal area=0.063 perim=1.14
MMNA2 pndA A3 VGND VNB nfet_01v8 m=2 w=0.65 l=0.15 mult=1 sa=0.265
+ sb=0.265 sd=0.28 topography=normal area=0.063 perim=1.14
MMNB0 y B1 pndA VNB nfet_01v8 m=2 w=0.65 l=0.15 mult=1 sa=0.265
+ sb=0.265 sd=0.28 topography=normal area=0.063 perim=1.14
MMNB1 y B2 pndA VNB nfet_01v8 m=2 w=0.65 l=0.15 mult=1 sa=0.265
+ sb=0.265 sd=0.28 topography=normal area=0.063 perim=1.14
MMINX X y VGND VNB nfet_01v8 m=4 w=0.65 l=0.15 mult=1 sa=0.265
+ sb=0.265 sd=0.28 topography=normal area=0.063 perim=1.14
.ENDS

.SUBCKT sky130_fd_sc_hd__o32ai_1 A1 A2 A3 B1 B2 VGND VNB VPB VPWR Y
MMPA0 VPWR A1 sndA1 VPB pfet_01v8_hvt m=1 w=1.0 l=0.15 mult=1 sa=0.265
+ sb=0.265 sd=0.28 topography=normal area=0.063 perim=1.14
MMPA1 sndA1 A2 sndA2 VPB pfet_01v8_hvt m=1 w=1.0 l=0.15 mult=1
+ sa=0.265 sb=0.265 sd=0.28 topography=normal area=0.063 perim=1.14
MMPA2 sndA2 A3 Y VPB pfet_01v8_hvt m=1 w=1.0 l=0.15 mult=1 sa=0.265
+ sb=0.265 sd=0.28 topography=normal area=0.063 perim=1.14
MMPB0 VPWR B1 sndB1 VPB pfet_01v8_hvt m=1 w=1.0 l=0.15 mult=1 sa=0.265
+ sb=0.265 sd=0.28 topography=normal area=0.063 perim=1.14
MMPB1 sndB1 B2 Y VPB pfet_01v8_hvt m=1 w=1.0 l=0.15 mult=1 sa=0.265
+ sb=0.265 sd=0.28 topography=normal area=0.063 perim=1.14
MMNA0 pndA A1 VGND VNB nfet_01v8 m=1 w=0.65 l=0.15 mult=1 sa=0.265
+ sb=0.265 sd=0.28 topography=normal area=0.063 perim=1.14
MMNA1 pndA A2 VGND VNB nfet_01v8 m=1 w=0.65 l=0.15 mult=1 sa=0.265
+ sb=0.265 sd=0.28 topography=normal area=0.063 perim=1.14
MMNA2 pndA A3 VGND VNB nfet_01v8 m=1 w=0.65 l=0.15 mult=1 sa=0.265
+ sb=0.265 sd=0.28 topography=normal area=0.063 perim=1.14
MMNB0 Y B1 pndA VNB nfet_01v8 m=1 w=0.65 l=0.15 mult=1 sa=0.265
+ sb=0.265 sd=0.28 topography=normal area=0.063 perim=1.14
MMNB1 Y B2 pndA VNB nfet_01v8 m=1 w=0.65 l=0.15 mult=1 sa=0.265
+ sb=0.265 sd=0.28 topography=normal area=0.063 perim=1.14
.ENDS

.SUBCKT sky130_fd_sc_hd__o32ai_2 A1 A2 A3 B1 B2 VGND VNB VPB VPWR Y
MMPA0 VPWR A1 sndA1 VPB pfet_01v8_hvt m=2 w=1.0 l=0.15 mult=1 sa=0.265
+ sb=0.265 sd=0.28 topography=normal area=0.063 perim=1.14
MMPA1 sndA1 A2 sndA2 VPB pfet_01v8_hvt m=2 w=1.0 l=0.15 mult=1
+ sa=0.265 sb=0.265 sd=0.28 topography=normal area=0.063 perim=1.14
MMPA2 sndA2 A3 Y VPB pfet_01v8_hvt m=2 w=1.0 l=0.15 mult=1 sa=0.265
+ sb=0.265 sd=0.28 topography=normal area=0.063 perim=1.14
MMPB0 VPWR B1 sndB1 VPB pfet_01v8_hvt m=2 w=1.0 l=0.15 mult=1 sa=0.265
+ sb=0.265 sd=0.28 topography=normal area=0.063 perim=1.14
MMPB1 sndB1 B2 Y VPB pfet_01v8_hvt m=2 w=1.0 l=0.15 mult=1 sa=0.265
+ sb=0.265 sd=0.28 topography=normal area=0.063 perim=1.14
MMNA0 pndA A1 VGND VNB nfet_01v8 m=2 w=0.65 l=0.15 mult=1 sa=0.265
+ sb=0.265 sd=0.28 topography=normal area=0.063 perim=1.14
MMNA1 pndA A2 VGND VNB nfet_01v8 m=2 w=0.65 l=0.15 mult=1 sa=0.265
+ sb=0.265 sd=0.28 topography=normal area=0.063 perim=1.14
MMNA2 pndA A3 VGND VNB nfet_01v8 m=2 w=0.65 l=0.15 mult=1 sa=0.265
+ sb=0.265 sd=0.28 topography=normal area=0.063 perim=1.14
MMNB0 Y B1 pndA VNB nfet_01v8 m=2 w=0.65 l=0.15 mult=1 sa=0.265
+ sb=0.265 sd=0.28 topography=normal area=0.063 perim=1.14
MMNB1 Y B2 pndA VNB nfet_01v8 m=2 w=0.65 l=0.15 mult=1 sa=0.265
+ sb=0.265 sd=0.28 topography=normal area=0.063 perim=1.14
.ENDS

.SUBCKT sky130_fd_sc_hd__o32ai_4 A1 A2 A3 B1 B2 VGND VNB VPB VPWR Y
MMPA0 VPWR A1 sndA1 VPB pfet_01v8_hvt m=4 w=1.0 l=0.15 mult=1 sa=0.265
+ sb=0.265 sd=0.28 topography=normal area=0.063 perim=1.14
MMPA1 sndA1 A2 sndA2 VPB pfet_01v8_hvt m=4 w=1.0 l=0.15 mult=1
+ sa=0.265 sb=0.265 sd=0.28 topography=normal area=0.063 perim=1.14
MMPA2 sndA2 A3 Y VPB pfet_01v8_hvt m=4 w=1.0 l=0.15 mult=1 sa=0.265
+ sb=0.265 sd=0.28 topography=normal area=0.063 perim=1.14
MMPB0 VPWR B1 sndB1 VPB pfet_01v8_hvt m=4 w=1.0 l=0.15 mult=1 sa=0.265
+ sb=0.265 sd=0.28 topography=normal area=0.063 perim=1.14
MMPB1 sndB1 B2 Y VPB pfet_01v8_hvt m=4 w=1.0 l=0.15 mult=1 sa=0.265
+ sb=0.265 sd=0.28 topography=normal area=0.063 perim=1.14
MMNA0 pndA A1 VGND VNB nfet_01v8 m=4 w=0.65 l=0.15 mult=1 sa=0.265
+ sb=0.265 sd=0.28 topography=normal area=0.063 perim=1.14
MMNA1 pndA A2 VGND VNB nfet_01v8 m=4 w=0.65 l=0.15 mult=1 sa=0.265
+ sb=0.265 sd=0.28 topography=normal area=0.063 perim=1.14
MMNA2 pndA A3 VGND VNB nfet_01v8 m=4 w=0.65 l=0.15 mult=1 sa=0.265
+ sb=0.265 sd=0.28 topography=normal area=0.063 perim=1.14
MMNB0 Y B1 pndA VNB nfet_01v8 m=4 w=0.65 l=0.15 mult=1 sa=0.265
+ sb=0.265 sd=0.28 topography=normal area=0.063 perim=1.14
MMNB1 Y B2 pndA VNB nfet_01v8 m=4 w=0.65 l=0.15 mult=1 sa=0.265
+ sb=0.265 sd=0.28 topography=normal area=0.063 perim=1.14
.ENDS

.SUBCKT sky130_fd_sc_hd__o41a_1 A1 A2 A3 A4 B1 VGND VNB VPB VPWR X
MMPA0 VPWR A1 sndA1 VPB pfet_01v8_hvt m=1 w=1.0 l=0.15 mult=1 sa=0.265
+ sb=0.265 sd=0.28 topography=normal area=0.063 perim=1.14
MMPA1 sndA1 A2 sndA2 VPB pfet_01v8_hvt m=1 w=1.0 l=0.15 mult=1
+ sa=0.265 sb=0.265 sd=0.28 topography=normal area=0.063 perim=1.14
MMPA2 sndA2 A3 sndA3 VPB pfet_01v8_hvt m=1 w=1.0 l=0.15 mult=1
+ sa=0.265 sb=0.265 sd=0.28 topography=normal area=0.063 perim=1.14
MMPA3 sndA3 A4 y VPB pfet_01v8_hvt m=1 w=1.0 l=0.15 mult=1 sa=0.265
+ sb=0.265 sd=0.28 topography=normal area=0.063 perim=1.14
MMPB0 VPWR B1 y VPB pfet_01v8_hvt m=1 w=1.0 l=0.15 mult=1 sa=0.265
+ sb=0.265 sd=0.28 topography=normal area=0.063 perim=1.14
MMIPX X y VPWR VPB pfet_01v8_hvt m=1 w=1.0 l=0.15 mult=1 sa=0.265
+ sb=0.265 sd=0.28 topography=normal area=0.063 perim=1.14
MMNA0 pndA A1 VGND VNB nfet_01v8 m=1 w=0.65 l=0.15 mult=1 sa=0.265
+ sb=0.265 sd=0.28 topography=normal area=0.063 perim=1.14
MMNA1 pndA A2 VGND VNB nfet_01v8 m=1 w=0.65 l=0.15 mult=1 sa=0.265
+ sb=0.265 sd=0.28 topography=normal area=0.063 perim=1.14
MMNA2 pndA A3 VGND VNB nfet_01v8 m=1 w=0.65 l=0.15 mult=1 sa=0.265
+ sb=0.265 sd=0.28 topography=normal area=0.063 perim=1.14
MMNA3 pndA A4 VGND VNB nfet_01v8 m=1 w=0.65 l=0.15 mult=1 sa=0.265
+ sb=0.265 sd=0.28 topography=normal area=0.063 perim=1.14
MMNB0 y B1 pndA VNB nfet_01v8 m=1 w=0.65 l=0.15 mult=1 sa=0.265
+ sb=0.265 sd=0.28 topography=normal area=0.063 perim=1.14
MMINX X y VGND VNB nfet_01v8 m=1 w=0.65 l=0.15 mult=1 sa=0.265
+ sb=0.265 sd=0.28 topography=normal area=0.063 perim=1.14
.ENDS

.SUBCKT sky130_fd_sc_hd__o41a_2 A1 A2 A3 A4 B1 VGND VNB VPB VPWR X
MMPA0 VPWR A1 sndA1 VPB pfet_01v8_hvt m=1 w=1.0 l=0.15 mult=1 sa=0.265
+ sb=0.265 sd=0.28 topography=normal area=0.063 perim=1.14
MMPA1 sndA1 A2 sndA2 VPB pfet_01v8_hvt m=1 w=1.0 l=0.15 mult=1
+ sa=0.265 sb=0.265 sd=0.28 topography=normal area=0.063 perim=1.14
MMPA2 sndA2 A3 sndA3 VPB pfet_01v8_hvt m=1 w=1.0 l=0.15 mult=1
+ sa=0.265 sb=0.265 sd=0.28 topography=normal area=0.063 perim=1.14
MMPA3 sndA3 A4 y VPB pfet_01v8_hvt m=1 w=1.0 l=0.15 mult=1 sa=0.265
+ sb=0.265 sd=0.28 topography=normal area=0.063 perim=1.14
MMPB0 VPWR B1 y VPB pfet_01v8_hvt m=1 w=1.0 l=0.15 mult=1 sa=0.265
+ sb=0.265 sd=0.28 topography=normal area=0.063 perim=1.14
MMIPX X y VPWR VPB pfet_01v8_hvt m=2 w=1.0 l=0.15 mult=1 sa=0.265
+ sb=0.265 sd=0.28 topography=normal area=0.063 perim=1.14
MMNA0 pndA A1 VGND VNB nfet_01v8 m=1 w=0.65 l=0.15 mult=1 sa=0.265
+ sb=0.265 sd=0.28 topography=normal area=0.063 perim=1.14
MMNA1 pndA A2 VGND VNB nfet_01v8 m=1 w=0.65 l=0.15 mult=1 sa=0.265
+ sb=0.265 sd=0.28 topography=normal area=0.063 perim=1.14
MMNA2 pndA A3 VGND VNB nfet_01v8 m=1 w=0.65 l=0.15 mult=1 sa=0.265
+ sb=0.265 sd=0.28 topography=normal area=0.063 perim=1.14
MMNA3 pndA A4 VGND VNB nfet_01v8 m=1 w=0.65 l=0.15 mult=1 sa=0.265
+ sb=0.265 sd=0.28 topography=normal area=0.063 perim=1.14
MMNB0 y B1 pndA VNB nfet_01v8 m=1 w=0.65 l=0.15 mult=1 sa=0.265
+ sb=0.265 sd=0.28 topography=normal area=0.063 perim=1.14
MMINX X y VGND VNB nfet_01v8 m=2 w=0.65 l=0.15 mult=1 sa=0.265
+ sb=0.265 sd=0.28 topography=normal area=0.063 perim=1.14
.ENDS

.SUBCKT sky130_fd_sc_hd__o41a_4 A1 A2 A3 A4 B1 VGND VNB VPB VPWR X
MMPA0 VPWR A1 sndA1 VPB pfet_01v8_hvt m=2 w=1.0 l=0.15 mult=1 sa=0.265
+ sb=0.265 sd=0.28 topography=normal area=0.063 perim=1.14
MMPA1 sndA1 A2 sndA2 VPB pfet_01v8_hvt m=2 w=1.0 l=0.15 mult=1
+ sa=0.265 sb=0.265 sd=0.28 topography=normal area=0.063 perim=1.14
MMPA2 sndA2 A3 sndA3 VPB pfet_01v8_hvt m=2 w=1.0 l=0.15 mult=1
+ sa=0.265 sb=0.265 sd=0.28 topography=normal area=0.063 perim=1.14
MMPA3 sndA3 A4 y VPB pfet_01v8_hvt m=2 w=1.0 l=0.15 mult=1 sa=0.265
+ sb=0.265 sd=0.28 topography=normal area=0.063 perim=1.14
MMPB0 VPWR B1 y VPB pfet_01v8_hvt m=2 w=1.0 l=0.15 mult=1 sa=0.265
+ sb=0.265 sd=0.28 topography=normal area=0.063 perim=1.14
MMIPX X y VPWR VPB pfet_01v8_hvt m=4 w=1.0 l=0.15 mult=1 sa=0.265
+ sb=0.265 sd=0.28 topography=normal area=0.063 perim=1.14
MMNA0 pndA A1 VGND VNB nfet_01v8 m=2 w=0.65 l=0.15 mult=1 sa=0.265
+ sb=0.265 sd=0.28 topography=normal area=0.063 perim=1.14
MMNA1 pndA A2 VGND VNB nfet_01v8 m=2 w=0.65 l=0.15 mult=1 sa=0.265
+ sb=0.265 sd=0.28 topography=normal area=0.063 perim=1.14
MMNA2 pndA A3 VGND VNB nfet_01v8 m=2 w=0.65 l=0.15 mult=1 sa=0.265
+ sb=0.265 sd=0.28 topography=normal area=0.063 perim=1.14
MMNA3 pndA A4 VGND VNB nfet_01v8 m=2 w=0.65 l=0.15 mult=1 sa=0.265
+ sb=0.265 sd=0.28 topography=normal area=0.063 perim=1.14
MMNB0 y B1 pndA VNB nfet_01v8 m=2 w=0.65 l=0.15 mult=1 sa=0.265
+ sb=0.265 sd=0.28 topography=normal area=0.063 perim=1.14
MMINX X y VGND VNB nfet_01v8 m=4 w=0.65 l=0.15 mult=1 sa=0.265
+ sb=0.265 sd=0.28 topography=normal area=0.063 perim=1.14
.ENDS

.SUBCKT sky130_fd_sc_hd__o41ai_1 A1 A2 A3 A4 B1 VGND VNB VPB VPWR Y
MMPA0 VPWR A1 sndA1 VPB pfet_01v8_hvt m=1 w=1.0 l=0.15 mult=1 sa=0.265
+ sb=0.265 sd=0.28 topography=normal area=0.063 perim=1.14
MMPA1 sndA1 A2 sndA2 VPB pfet_01v8_hvt m=1 w=1.0 l=0.15 mult=1
+ sa=0.265 sb=0.265 sd=0.28 topography=normal area=0.063 perim=1.14
MMPA2 sndA2 A3 sndA3 VPB pfet_01v8_hvt m=1 w=1.0 l=0.15 mult=1
+ sa=0.265 sb=0.265 sd=0.28 topography=normal area=0.063 perim=1.14
MMPA3 sndA3 A4 Y VPB pfet_01v8_hvt m=1 w=1.0 l=0.15 mult=1 sa=0.265
+ sb=0.265 sd=0.28 topography=normal area=0.063 perim=1.14
MMPB0 VPWR B1 Y VPB pfet_01v8_hvt m=1 w=1.0 l=0.15 mult=1 sa=0.265
+ sb=0.265 sd=0.28 topography=normal area=0.063 perim=1.14
MMNA0 pndA A1 VGND VNB nfet_01v8 m=1 w=0.65 l=0.15 mult=1 sa=0.265
+ sb=0.265 sd=0.28 topography=normal area=0.063 perim=1.14
MMNA1 pndA A2 VGND VNB nfet_01v8 m=1 w=0.65 l=0.15 mult=1 sa=0.265
+ sb=0.265 sd=0.28 topography=normal area=0.063 perim=1.14
MMNA2 pndA A3 VGND VNB nfet_01v8 m=1 w=0.65 l=0.15 mult=1 sa=0.265
+ sb=0.265 sd=0.28 topography=normal area=0.063 perim=1.14
MMNA3 pndA A4 VGND VNB nfet_01v8 m=1 w=0.65 l=0.15 mult=1 sa=0.265
+ sb=0.265 sd=0.28 topography=normal area=0.063 perim=1.14
MMNB0 Y B1 pndA VNB nfet_01v8 m=1 w=0.65 l=0.15 mult=1 sa=0.265
+ sb=0.265 sd=0.28 topography=normal area=0.063 perim=1.14
.ENDS

.SUBCKT sky130_fd_sc_hd__o41ai_2 A1 A2 A3 A4 B1 VGND VNB VPB VPWR Y
MMPA0 VPWR A1 sndA1 VPB pfet_01v8_hvt m=2 w=1.0 l=0.15 mult=1 sa=0.265
+ sb=0.265 sd=0.28 topography=normal area=0.063 perim=1.14
MMPA1 sndA1 A2 sndA2 VPB pfet_01v8_hvt m=2 w=1.0 l=0.15 mult=1
+ sa=0.265 sb=0.265 sd=0.28 topography=normal area=0.063 perim=1.14
MMPA2 sndA2 A3 sndA3 VPB pfet_01v8_hvt m=2 w=1.0 l=0.15 mult=1
+ sa=0.265 sb=0.265 sd=0.28 topography=normal area=0.063 perim=1.14
MMPA3 sndA3 A4 Y VPB pfet_01v8_hvt m=2 w=1.0 l=0.15 mult=1 sa=0.265
+ sb=0.265 sd=0.28 topography=normal area=0.063 perim=1.14
MMPB0 VPWR B1 Y VPB pfet_01v8_hvt m=2 w=1.0 l=0.15 mult=1 sa=0.265
+ sb=0.265 sd=0.28 topography=normal area=0.063 perim=1.14
MMNA0 pndA A1 VGND VNB nfet_01v8 m=2 w=0.65 l=0.15 mult=1 sa=0.265
+ sb=0.265 sd=0.28 topography=normal area=0.063 perim=1.14
MMNA1 pndA A2 VGND VNB nfet_01v8 m=2 w=0.65 l=0.15 mult=1 sa=0.265
+ sb=0.265 sd=0.28 topography=normal area=0.063 perim=1.14
MMNA2 pndA A3 VGND VNB nfet_01v8 m=2 w=0.65 l=0.15 mult=1 sa=0.265
+ sb=0.265 sd=0.28 topography=normal area=0.063 perim=1.14
MMNA3 pndA A4 VGND VNB nfet_01v8 m=2 w=0.65 l=0.15 mult=1 sa=0.265
+ sb=0.265 sd=0.28 topography=normal area=0.063 perim=1.14
MMNB0 Y B1 pndA VNB nfet_01v8 m=2 w=0.65 l=0.15 mult=1 sa=0.265
+ sb=0.265 sd=0.28 topography=normal area=0.063 perim=1.14
.ENDS

.SUBCKT sky130_fd_sc_hd__o41ai_4 A1 A2 A3 A4 B1 VGND VNB VPB VPWR Y
MMPA0 VPWR A1 sndA1 VPB pfet_01v8_hvt m=4 w=1.0 l=0.15 mult=1 sa=0.265
+ sb=0.265 sd=0.28 topography=normal area=0.063 perim=1.14
MMPA1 sndA1 A2 sndA2 VPB pfet_01v8_hvt m=4 w=1.0 l=0.15 mult=1
+ sa=0.265 sb=0.265 sd=0.28 topography=normal area=0.063 perim=1.14
MMPA2 sndA2 A3 sndA3 VPB pfet_01v8_hvt m=4 w=1.0 l=0.15 mult=1
+ sa=0.265 sb=0.265 sd=0.28 topography=normal area=0.063 perim=1.14
MMPA3 sndA3 A4 Y VPB pfet_01v8_hvt m=4 w=1.0 l=0.15 mult=1 sa=0.265
+ sb=0.265 sd=0.28 topography=normal area=0.063 perim=1.14
MMPB0 VPWR B1 Y VPB pfet_01v8_hvt m=4 w=1.0 l=0.15 mult=1 sa=0.265
+ sb=0.265 sd=0.28 topography=normal area=0.063 perim=1.14
MMNA0 pndA A1 VGND VNB nfet_01v8 m=4 w=0.65 l=0.15 mult=1 sa=0.265
+ sb=0.265 sd=0.28 topography=normal area=0.063 perim=1.14
MMNA1 pndA A2 VGND VNB nfet_01v8 m=4 w=0.65 l=0.15 mult=1 sa=0.265
+ sb=0.265 sd=0.28 topography=normal area=0.063 perim=1.14
MMNA2 pndA A3 VGND VNB nfet_01v8 m=4 w=0.65 l=0.15 mult=1 sa=0.265
+ sb=0.265 sd=0.28 topography=normal area=0.063 perim=1.14
MMNA3 pndA A4 VGND VNB nfet_01v8 m=4 w=0.65 l=0.15 mult=1 sa=0.265
+ sb=0.265 sd=0.28 topography=normal area=0.063 perim=1.14
MMNB0 Y B1 pndA VNB nfet_01v8 m=4 w=0.65 l=0.15 mult=1 sa=0.265
+ sb=0.265 sd=0.28 topography=normal area=0.063 perim=1.14
.ENDS

.SUBCKT sky130_fd_sc_hd__o211a_1 A1 A2 B1 C1 VGND VNB VPB VPWR X
MMPA0 VPWR A1 sndA1 VPB pfet_01v8_hvt m=1 w=1.0 l=0.15 mult=1 sa=0.265
+ sb=0.265 sd=0.28 topography=normal area=0.063 perim=1.14
MMPA1 sndA1 A2 y VPB pfet_01v8_hvt m=1 w=1.0 l=0.15 mult=1 sa=0.265
+ sb=0.265 sd=0.28 topography=normal area=0.063 perim=1.14
MMPB0 VPWR B1 y VPB pfet_01v8_hvt m=1 w=1.0 l=0.15 mult=1 sa=0.265
+ sb=0.265 sd=0.28 topography=normal area=0.063 perim=1.14
MMPC0 VPWR C1 y VPB pfet_01v8_hvt m=1 w=1.0 l=0.15 mult=1 sa=0.265
+ sb=0.265 sd=0.28 topography=normal area=0.063 perim=1.14
MMIPX X y VPWR VPB pfet_01v8_hvt m=1 w=1.0 l=0.15 mult=1 sa=0.265
+ sb=0.265 sd=0.28 topography=normal area=0.063 perim=1.14
MMNA0 pndA A1 VGND VNB nfet_01v8 m=1 w=0.65 l=0.15 mult=1 sa=0.265
+ sb=0.265 sd=0.28 topography=normal area=0.063 perim=1.14
MMNA1 pndA A2 VGND VNB nfet_01v8 m=1 w=0.65 l=0.15 mult=1 sa=0.265
+ sb=0.265 sd=0.28 topography=normal area=0.063 perim=1.14
MMNB0 pndB B1 pndA VNB nfet_01v8 m=1 w=0.65 l=0.15 mult=1 sa=0.265
+ sb=0.265 sd=0.28 topography=normal area=0.063 perim=1.14
MMNC0 y C1 pndB VNB nfet_01v8 m=1 w=0.65 l=0.15 mult=1 sa=0.265
+ sb=0.265 sd=0.28 topography=normal area=0.063 perim=1.14
MMINX X y VGND VNB nfet_01v8 m=1 w=0.65 l=0.15 mult=1 sa=0.265
+ sb=0.265 sd=0.28 topography=normal area=0.063 perim=1.14
.ENDS

.SUBCKT sky130_fd_sc_hd__o211a_2 A1 A2 B1 C1 VGND VNB VPB VPWR X
MMPA0 VPWR A1 sndA1 VPB pfet_01v8_hvt m=1 w=1.0 l=0.15 mult=1 sa=0.265
+ sb=0.265 sd=0.28 topography=normal area=0.063 perim=1.14
MMPA1 sndA1 A2 y VPB pfet_01v8_hvt m=1 w=1.0 l=0.15 mult=1 sa=0.265
+ sb=0.265 sd=0.28 topography=normal area=0.063 perim=1.14
MMPB0 VPWR B1 y VPB pfet_01v8_hvt m=1 w=1.0 l=0.15 mult=1 sa=0.265
+ sb=0.265 sd=0.28 topography=normal area=0.063 perim=1.14
MMPC0 VPWR C1 y VPB pfet_01v8_hvt m=1 w=1.0 l=0.15 mult=1 sa=0.265
+ sb=0.265 sd=0.28 topography=normal area=0.063 perim=1.14
MMIPX X y VPWR VPB pfet_01v8_hvt m=2 w=1.0 l=0.15 mult=1 sa=0.265
+ sb=0.265 sd=0.28 topography=normal area=0.063 perim=1.14
MMNA0 pndA A1 VGND VNB nfet_01v8 m=1 w=0.65 l=0.15 mult=1 sa=0.265
+ sb=0.265 sd=0.28 topography=normal area=0.063 perim=1.14
MMNA1 pndA A2 VGND VNB nfet_01v8 m=1 w=0.65 l=0.15 mult=1 sa=0.265
+ sb=0.265 sd=0.28 topography=normal area=0.063 perim=1.14
MMNB0 pndB B1 pndA VNB nfet_01v8 m=1 w=0.65 l=0.15 mult=1 sa=0.265
+ sb=0.265 sd=0.28 topography=normal area=0.063 perim=1.14
MMNC0 y C1 pndB VNB nfet_01v8 m=1 w=0.65 l=0.15 mult=1 sa=0.265
+ sb=0.265 sd=0.28 topography=normal area=0.063 perim=1.14
MMINX X y VGND VNB nfet_01v8 m=2 w=0.65 l=0.15 mult=1 sa=0.265
+ sb=0.265 sd=0.28 topography=normal area=0.063 perim=1.14
.ENDS

.SUBCKT sky130_fd_sc_hd__o211a_4 A1 A2 B1 C1 VGND VNB VPB VPWR X
MMPA0 VPWR A1 sndA1 VPB pfet_01v8_hvt m=2 w=1.0 l=0.15 mult=1 sa=0.265
+ sb=0.265 sd=0.28 topography=normal area=0.063 perim=1.14
MMPA1 sndA1 A2 y VPB pfet_01v8_hvt m=2 w=1.0 l=0.15 mult=1 sa=0.265
+ sb=0.265 sd=0.28 topography=normal area=0.063 perim=1.14
MMPB0 VPWR B1 y VPB pfet_01v8_hvt m=2 w=1.0 l=0.15 mult=1 sa=0.265
+ sb=0.265 sd=0.28 topography=normal area=0.063 perim=1.14
MMPC0 VPWR C1 y VPB pfet_01v8_hvt m=2 w=1.0 l=0.15 mult=1 sa=0.265
+ sb=0.265 sd=0.28 topography=normal area=0.063 perim=1.14
MMIPX X y VPWR VPB pfet_01v8_hvt m=4 w=1.0 l=0.15 mult=1 sa=0.265
+ sb=0.265 sd=0.28 topography=normal area=0.063 perim=1.14
MMNA0 pndA A1 VGND VNB nfet_01v8 m=2 w=0.65 l=0.15 mult=1 sa=0.265
+ sb=0.265 sd=0.28 topography=normal area=0.063 perim=1.14
MMNA1 pndA A2 VGND VNB nfet_01v8 m=2 w=0.65 l=0.15 mult=1 sa=0.265
+ sb=0.265 sd=0.28 topography=normal area=0.063 perim=1.14
MMNB0 pndB B1 pndA VNB nfet_01v8 m=2 w=0.65 l=0.15 mult=1 sa=0.265
+ sb=0.265 sd=0.28 topography=normal area=0.063 perim=1.14
MMNC0 y C1 pndB VNB nfet_01v8 m=2 w=0.65 l=0.15 mult=1 sa=0.265
+ sb=0.265 sd=0.28 topography=normal area=0.063 perim=1.14
MMINX X y VGND VNB nfet_01v8 m=4 w=0.65 l=0.15 mult=1 sa=0.265
+ sb=0.265 sd=0.28 topography=normal area=0.063 perim=1.14
.ENDS

.SUBCKT sky130_fd_sc_hd__o211ai_1 A1 A2 B1 C1 VGND VNB VPB VPWR Y
MMPA0 VPWR A1 sndA1 VPB pfet_01v8_hvt m=1 w=1.0 l=0.15 mult=1 sa=0.265
+ sb=0.265 sd=0.28 topography=normal area=0.063 perim=1.14
MMPA1 sndA1 A2 Y VPB pfet_01v8_hvt m=1 w=1.0 l=0.15 mult=1 sa=0.265
+ sb=0.265 sd=0.28 topography=normal area=0.063 perim=1.14
MMPB0 VPWR B1 Y VPB pfet_01v8_hvt m=1 w=1.0 l=0.15 mult=1 sa=0.265
+ sb=0.265 sd=0.28 topography=normal area=0.063 perim=1.14
MMPC0 VPWR C1 Y VPB pfet_01v8_hvt m=1 w=1.0 l=0.15 mult=1 sa=0.265
+ sb=0.265 sd=0.28 topography=normal area=0.063 perim=1.14
MMNA0 pndA A1 VGND VNB nfet_01v8 m=1 w=0.65 l=0.15 mult=1 sa=0.265
+ sb=0.265 sd=0.28 topography=normal area=0.063 perim=1.14
MMNA1 pndA A2 VGND VNB nfet_01v8 m=1 w=0.65 l=0.15 mult=1 sa=0.265
+ sb=0.265 sd=0.28 topography=normal area=0.063 perim=1.14
MMNB0 pndB B1 pndA VNB nfet_01v8 m=1 w=0.65 l=0.15 mult=1 sa=0.265
+ sb=0.265 sd=0.28 topography=normal area=0.063 perim=1.14
MMNC0 Y C1 pndB VNB nfet_01v8 m=1 w=0.65 l=0.15 mult=1 sa=0.265
+ sb=0.265 sd=0.28 topography=normal area=0.063 perim=1.14
.ENDS

.SUBCKT sky130_fd_sc_hd__o211ai_2 A1 A2 B1 C1 VGND VNB VPB VPWR Y
MMPA0 VPWR A1 sndA1 VPB pfet_01v8_hvt m=2 w=1.0 l=0.15 mult=1 sa=0.265
+ sb=0.265 sd=0.28 topography=normal area=0.063 perim=1.14
MMPA1 sndA1 A2 Y VPB pfet_01v8_hvt m=2 w=1.0 l=0.15 mult=1 sa=0.265
+ sb=0.265 sd=0.28 topography=normal area=0.063 perim=1.14
MMPB0 VPWR B1 Y VPB pfet_01v8_hvt m=2 w=1.0 l=0.15 mult=1 sa=0.265
+ sb=0.265 sd=0.28 topography=normal area=0.063 perim=1.14
MMPC0 VPWR C1 Y VPB pfet_01v8_hvt m=2 w=1.0 l=0.15 mult=1 sa=0.265
+ sb=0.265 sd=0.28 topography=normal area=0.063 perim=1.14
MMNA0 pndA A1 VGND VNB nfet_01v8 m=2 w=0.65 l=0.15 mult=1 sa=0.265
+ sb=0.265 sd=0.28 topography=normal area=0.063 perim=1.14
MMNA1 pndA A2 VGND VNB nfet_01v8 m=2 w=0.65 l=0.15 mult=1 sa=0.265
+ sb=0.265 sd=0.28 topography=normal area=0.063 perim=1.14
MMNB0 pndB B1 pndA VNB nfet_01v8 m=2 w=0.65 l=0.15 mult=1 sa=0.265
+ sb=0.265 sd=0.28 topography=normal area=0.063 perim=1.14
MMNC0 Y C1 pndB VNB nfet_01v8 m=2 w=0.65 l=0.15 mult=1 sa=0.265
+ sb=0.265 sd=0.28 topography=normal area=0.063 perim=1.14
.ENDS

.SUBCKT sky130_fd_sc_hd__o211ai_4 A1 A2 B1 C1 VGND VNB VPB VPWR Y
MMPA0 VPWR A1 sndA1 VPB pfet_01v8_hvt m=4 w=1.0 l=0.15 mult=1 sa=0.265
+ sb=0.265 sd=0.28 topography=normal area=0.063 perim=1.14
MMPA1 sndA1 A2 Y VPB pfet_01v8_hvt m=4 w=1.0 l=0.15 mult=1 sa=0.265
+ sb=0.265 sd=0.28 topography=normal area=0.063 perim=1.14
MMPB0 VPWR B1 Y VPB pfet_01v8_hvt m=4 w=1.0 l=0.15 mult=1 sa=0.265
+ sb=0.265 sd=0.28 topography=normal area=0.063 perim=1.14
MMPC0 VPWR C1 Y VPB pfet_01v8_hvt m=4 w=1.0 l=0.15 mult=1 sa=0.265
+ sb=0.265 sd=0.28 topography=normal area=0.063 perim=1.14
MMNA0 pndA A1 VGND VNB nfet_01v8 m=4 w=0.65 l=0.15 mult=1 sa=0.265
+ sb=0.265 sd=0.28 topography=normal area=0.063 perim=1.14
MMNA1 pndA A2 VGND VNB nfet_01v8 m=4 w=0.65 l=0.15 mult=1 sa=0.265
+ sb=0.265 sd=0.28 topography=normal area=0.063 perim=1.14
MMNB0 pndB B1 pndA VNB nfet_01v8 m=4 w=0.65 l=0.15 mult=1 sa=0.265
+ sb=0.265 sd=0.28 topography=normal area=0.063 perim=1.14
MMNC0 Y C1 pndB VNB nfet_01v8 m=4 w=0.65 l=0.15 mult=1 sa=0.265
+ sb=0.265 sd=0.28 topography=normal area=0.063 perim=1.14
.ENDS

.SUBCKT sky130_fd_sc_hd__o221a_1 A1 A2 B1 B2 C1 VGND VNB VPB VPWR X
MMPA0 VPWR A1 sndA1 VPB pfet_01v8_hvt m=1 w=1.0 l=0.15 mult=1 sa=0.265
+ sb=0.265 sd=0.28 topography=normal area=0.063 perim=1.14
MMPA1 sndA1 A2 y VPB pfet_01v8_hvt m=1 w=1.0 l=0.15 mult=1 sa=0.265
+ sb=0.265 sd=0.28 topography=normal area=0.063 perim=1.14
MMPB0 VPWR B1 sndB1 VPB pfet_01v8_hvt m=1 w=1.0 l=0.15 mult=1 sa=0.265
+ sb=0.265 sd=0.28 topography=normal area=0.063 perim=1.14
MMPB1 sndB1 B2 y VPB pfet_01v8_hvt m=1 w=1.0 l=0.15 mult=1 sa=0.265
+ sb=0.265 sd=0.28 topography=normal area=0.063 perim=1.14
MMPC0 VPWR C1 y VPB pfet_01v8_hvt m=1 w=1.0 l=0.15 mult=1 sa=0.265
+ sb=0.265 sd=0.28 topography=normal area=0.063 perim=1.14
MMIPX X y VPWR VPB pfet_01v8_hvt m=1 w=1.0 l=0.15 mult=1 sa=0.265
+ sb=0.265 sd=0.28 topography=normal area=0.063 perim=1.14
MMNA0 pndA A1 VGND VNB nfet_01v8 m=1 w=0.65 l=0.15 mult=1 sa=0.265
+ sb=0.265 sd=0.28 topography=normal area=0.063 perim=1.14
MMNA1 pndA A2 VGND VNB nfet_01v8 m=1 w=0.65 l=0.15 mult=1 sa=0.265
+ sb=0.265 sd=0.28 topography=normal area=0.063 perim=1.14
MMNB0 pndB B1 pndA VNB nfet_01v8 m=1 w=0.65 l=0.15 mult=1 sa=0.265
+ sb=0.265 sd=0.28 topography=normal area=0.063 perim=1.14
MMNB1 pndB B2 pndA VNB nfet_01v8 m=1 w=0.65 l=0.15 mult=1 sa=0.265
+ sb=0.265 sd=0.28 topography=normal area=0.063 perim=1.14
MMNC0 y C1 pndB VNB nfet_01v8 m=1 w=0.65 l=0.15 mult=1 sa=0.265
+ sb=0.265 sd=0.28 topography=normal area=0.063 perim=1.14
MMINX X y VGND VNB nfet_01v8 m=1 w=0.65 l=0.15 mult=1 sa=0.265
+ sb=0.265 sd=0.28 topography=normal area=0.063 perim=1.14
.ENDS

.SUBCKT sky130_fd_sc_hd__o221a_2 A1 A2 B1 B2 C1 VGND VNB VPB VPWR X
MMPA0 VPWR A1 sndA1 VPB pfet_01v8_hvt m=1 w=1.0 l=0.15 mult=1 sa=0.265
+ sb=0.265 sd=0.28 topography=normal area=0.063 perim=1.14
MMPA1 sndA1 A2 y VPB pfet_01v8_hvt m=1 w=1.0 l=0.15 mult=1 sa=0.265
+ sb=0.265 sd=0.28 topography=normal area=0.063 perim=1.14
MMPB0 VPWR B1 sndB1 VPB pfet_01v8_hvt m=1 w=1.0 l=0.15 mult=1 sa=0.265
+ sb=0.265 sd=0.28 topography=normal area=0.063 perim=1.14
MMPB1 sndB1 B2 y VPB pfet_01v8_hvt m=1 w=1.0 l=0.15 mult=1 sa=0.265
+ sb=0.265 sd=0.28 topography=normal area=0.063 perim=1.14
MMPC0 VPWR C1 y VPB pfet_01v8_hvt m=1 w=1.0 l=0.15 mult=1 sa=0.265
+ sb=0.265 sd=0.28 topography=normal area=0.063 perim=1.14
MMIPX X y VPWR VPB pfet_01v8_hvt m=2 w=1.0 l=0.15 mult=1 sa=0.265
+ sb=0.265 sd=0.28 topography=normal area=0.063 perim=1.14
MMNA0 pndA A1 VGND VNB nfet_01v8 m=1 w=0.65 l=0.15 mult=1 sa=0.265
+ sb=0.265 sd=0.28 topography=normal area=0.063 perim=1.14
MMNA1 pndA A2 VGND VNB nfet_01v8 m=1 w=0.65 l=0.15 mult=1 sa=0.265
+ sb=0.265 sd=0.28 topography=normal area=0.063 perim=1.14
MMNB0 pndB B1 pndA VNB nfet_01v8 m=1 w=0.65 l=0.15 mult=1 sa=0.265
+ sb=0.265 sd=0.28 topography=normal area=0.063 perim=1.14
MMNB1 pndB B2 pndA VNB nfet_01v8 m=1 w=0.65 l=0.15 mult=1 sa=0.265
+ sb=0.265 sd=0.28 topography=normal area=0.063 perim=1.14
MMNC0 y C1 pndB VNB nfet_01v8 m=1 w=0.65 l=0.15 mult=1 sa=0.265
+ sb=0.265 sd=0.28 topography=normal area=0.063 perim=1.14
MMINX X y VGND VNB nfet_01v8 m=2 w=0.65 l=0.15 mult=1 sa=0.265
+ sb=0.265 sd=0.28 topography=normal area=0.063 perim=1.14
.ENDS

.SUBCKT sky130_fd_sc_hd__o221a_4 A1 A2 B1 B2 C1 VGND VNB VPB VPWR X
MMPA0 VPWR A1 sndA1 VPB pfet_01v8_hvt m=2 w=1.0 l=0.15 mult=1 sa=0.265
+ sb=0.265 sd=0.28 topography=normal area=0.063 perim=1.14
MMPA1 sndA1 A2 y VPB pfet_01v8_hvt m=2 w=1.0 l=0.15 mult=1 sa=0.265
+ sb=0.265 sd=0.28 topography=normal area=0.063 perim=1.14
MMPB0 VPWR B1 sndB1 VPB pfet_01v8_hvt m=2 w=1.0 l=0.15 mult=1 sa=0.265
+ sb=0.265 sd=0.28 topography=normal area=0.063 perim=1.14
MMPB1 sndB1 B2 y VPB pfet_01v8_hvt m=2 w=1.0 l=0.15 mult=1 sa=0.265
+ sb=0.265 sd=0.28 topography=normal area=0.063 perim=1.14
MMPC0 VPWR C1 y VPB pfet_01v8_hvt m=2 w=1.0 l=0.15 mult=1 sa=0.265
+ sb=0.265 sd=0.28 topography=normal area=0.063 perim=1.14
MMIPX X y VPWR VPB pfet_01v8_hvt m=4 w=1.0 l=0.15 mult=1 sa=0.265
+ sb=0.265 sd=0.28 topography=normal area=0.063 perim=1.14
MMNA0 pndA A1 VGND VNB nfet_01v8 m=2 w=0.65 l=0.15 mult=1 sa=0.265
+ sb=0.265 sd=0.28 topography=normal area=0.063 perim=1.14
MMNA1 pndA A2 VGND VNB nfet_01v8 m=2 w=0.65 l=0.15 mult=1 sa=0.265
+ sb=0.265 sd=0.28 topography=normal area=0.063 perim=1.14
MMNB0 pndB B1 pndA VNB nfet_01v8 m=2 w=0.65 l=0.15 mult=1 sa=0.265
+ sb=0.265 sd=0.28 topography=normal area=0.063 perim=1.14
MMNB1 pndB B2 pndA VNB nfet_01v8 m=2 w=0.65 l=0.15 mult=1 sa=0.265
+ sb=0.265 sd=0.28 topography=normal area=0.063 perim=1.14
MMNC0 y C1 pndB VNB nfet_01v8 m=2 w=0.65 l=0.15 mult=1 sa=0.265
+ sb=0.265 sd=0.28 topography=normal area=0.063 perim=1.14
MMINX X y VGND VNB nfet_01v8 m=4 w=0.65 l=0.15 mult=1 sa=0.265
+ sb=0.265 sd=0.28 topography=normal area=0.063 perim=1.14
.ENDS

.SUBCKT sky130_fd_sc_hd__o221ai_1 A1 A2 B1 B2 C1 VGND VNB VPB VPWR Y
MMPA0 VPWR A1 sndA1 VPB pfet_01v8_hvt m=1 w=1.0 l=0.15 mult=1 sa=0.265
+ sb=0.265 sd=0.28 topography=normal area=0.063 perim=1.14
MMPA1 sndA1 A2 Y VPB pfet_01v8_hvt m=1 w=1.0 l=0.15 mult=1 sa=0.265
+ sb=0.265 sd=0.28 topography=normal area=0.063 perim=1.14
MMPB0 VPWR B1 sndB1 VPB pfet_01v8_hvt m=1 w=1.0 l=0.15 mult=1 sa=0.265
+ sb=0.265 sd=0.28 topography=normal area=0.063 perim=1.14
MMPB1 sndB1 B2 Y VPB pfet_01v8_hvt m=1 w=1.0 l=0.15 mult=1 sa=0.265
+ sb=0.265 sd=0.28 topography=normal area=0.063 perim=1.14
MMPC0 VPWR C1 Y VPB pfet_01v8_hvt m=1 w=1.0 l=0.15 mult=1 sa=0.265
+ sb=0.265 sd=0.28 topography=normal area=0.063 perim=1.14
MMNA0 pndA A1 VGND VNB nfet_01v8 m=1 w=0.65 l=0.15 mult=1 sa=0.265
+ sb=0.265 sd=0.28 topography=normal area=0.063 perim=1.14
MMNA1 pndA A2 VGND VNB nfet_01v8 m=1 w=0.65 l=0.15 mult=1 sa=0.265
+ sb=0.265 sd=0.28 topography=normal area=0.063 perim=1.14
MMNB0 pndB B1 pndA VNB nfet_01v8 m=1 w=0.65 l=0.15 mult=1 sa=0.265
+ sb=0.265 sd=0.28 topography=normal area=0.063 perim=1.14
MMNB1 pndB B2 pndA VNB nfet_01v8 m=1 w=0.65 l=0.15 mult=1 sa=0.265
+ sb=0.265 sd=0.28 topography=normal area=0.063 perim=1.14
MMNC0 Y C1 pndB VNB nfet_01v8 m=1 w=0.65 l=0.15 mult=1 sa=0.265
+ sb=0.265 sd=0.28 topography=normal area=0.063 perim=1.14
.ENDS

.SUBCKT sky130_fd_sc_hd__o221ai_2 A1 A2 B1 B2 C1 VGND VNB VPB VPWR Y
MMPA0 VPWR A1 sndA1 VPB pfet_01v8_hvt m=2 w=1.0 l=0.15 mult=1 sa=0.265
+ sb=0.265 sd=0.28 topography=normal area=0.063 perim=1.14
MMPA1 sndA1 A2 Y VPB pfet_01v8_hvt m=2 w=1.0 l=0.15 mult=1 sa=0.265
+ sb=0.265 sd=0.28 topography=normal area=0.063 perim=1.14
MMPB0 VPWR B1 sndB1 VPB pfet_01v8_hvt m=2 w=1.0 l=0.15 mult=1 sa=0.265
+ sb=0.265 sd=0.28 topography=normal area=0.063 perim=1.14
MMPB1 sndB1 B2 Y VPB pfet_01v8_hvt m=2 w=1.0 l=0.15 mult=1 sa=0.265
+ sb=0.265 sd=0.28 topography=normal area=0.063 perim=1.14
MMPC0 VPWR C1 Y VPB pfet_01v8_hvt m=2 w=1.0 l=0.15 mult=1 sa=0.265
+ sb=0.265 sd=0.28 topography=normal area=0.063 perim=1.14
MMNA0 pndA A1 VGND VNB nfet_01v8 m=2 w=0.65 l=0.15 mult=1 sa=0.265
+ sb=0.265 sd=0.28 topography=normal area=0.063 perim=1.14
MMNA1 pndA A2 VGND VNB nfet_01v8 m=2 w=0.65 l=0.15 mult=1 sa=0.265
+ sb=0.265 sd=0.28 topography=normal area=0.063 perim=1.14
MMNB0 pndB B1 pndA VNB nfet_01v8 m=2 w=0.65 l=0.15 mult=1 sa=0.265
+ sb=0.265 sd=0.28 topography=normal area=0.063 perim=1.14
MMNB1 pndB B2 pndA VNB nfet_01v8 m=2 w=0.65 l=0.15 mult=1 sa=0.265
+ sb=0.265 sd=0.28 topography=normal area=0.063 perim=1.14
MMNC0 Y C1 pndB VNB nfet_01v8 m=2 w=0.65 l=0.15 mult=1 sa=0.265
+ sb=0.265 sd=0.28 topography=normal area=0.063 perim=1.14
.ENDS

.SUBCKT sky130_fd_sc_hd__o221ai_4 A1 A2 B1 B2 C1 VGND VNB VPB VPWR Y
MMPA0 VPWR A1 sndA1 VPB pfet_01v8_hvt m=4 w=1.0 l=0.15 mult=1 sa=0.265
+ sb=0.265 sd=0.28 topography=normal area=0.063 perim=1.14
MMPA1 sndA1 A2 Y VPB pfet_01v8_hvt m=4 w=1.0 l=0.15 mult=1 sa=0.265
+ sb=0.265 sd=0.28 topography=normal area=0.063 perim=1.14
MMPB0 VPWR B1 sndB1 VPB pfet_01v8_hvt m=4 w=1.0 l=0.15 mult=1 sa=0.265
+ sb=0.265 sd=0.28 topography=normal area=0.063 perim=1.14
MMPB1 sndB1 B2 Y VPB pfet_01v8_hvt m=4 w=1.0 l=0.15 mult=1 sa=0.265
+ sb=0.265 sd=0.28 topography=normal area=0.063 perim=1.14
MMPC0 VPWR C1 Y VPB pfet_01v8_hvt m=4 w=1.0 l=0.15 mult=1 sa=0.265
+ sb=0.265 sd=0.28 topography=normal area=0.063 perim=1.14
MMNA0 pndA A1 VGND VNB nfet_01v8 m=4 w=0.65 l=0.15 mult=1 sa=0.265
+ sb=0.265 sd=0.28 topography=normal area=0.063 perim=1.14
MMNA1 pndA A2 VGND VNB nfet_01v8 m=4 w=0.65 l=0.15 mult=1 sa=0.265
+ sb=0.265 sd=0.28 topography=normal area=0.063 perim=1.14
MMNB0 pndB B1 pndA VNB nfet_01v8 m=4 w=0.65 l=0.15 mult=1 sa=0.265
+ sb=0.265 sd=0.28 topography=normal area=0.063 perim=1.14
MMNB1 pndB B2 pndA VNB nfet_01v8 m=4 w=0.65 l=0.15 mult=1 sa=0.265
+ sb=0.265 sd=0.28 topography=normal area=0.063 perim=1.14
MMNC0 Y C1 pndB VNB nfet_01v8 m=4 w=0.65 l=0.15 mult=1 sa=0.265
+ sb=0.265 sd=0.28 topography=normal area=0.063 perim=1.14
.ENDS

.SUBCKT sky130_fd_sc_hd__o311a_1 A1 A2 A3 B1 C1 VGND VNB VPB VPWR X
MMPA0 VPWR A1 sndA1 VPB pfet_01v8_hvt m=1 w=1.0 l=0.15 mult=1 sa=0.265
+ sb=0.265 sd=0.28 topography=normal area=0.063 perim=1.14
MMPA1 sndA1 A2 sndA2 VPB pfet_01v8_hvt m=1 w=1.0 l=0.15 mult=1
+ sa=0.265 sb=0.265 sd=0.28 topography=normal area=0.063 perim=1.14
MMPA2 sndA2 A3 y VPB pfet_01v8_hvt m=1 w=1.0 l=0.15 mult=1 sa=0.265
+ sb=0.265 sd=0.28 topography=normal area=0.063 perim=1.14
MMPB0 VPWR B1 y VPB pfet_01v8_hvt m=1 w=1.0 l=0.15 mult=1 sa=0.265
+ sb=0.265 sd=0.28 topography=normal area=0.063 perim=1.14
MMPC0 VPWR C1 y VPB pfet_01v8_hvt m=1 w=1.0 l=0.15 mult=1 sa=0.265
+ sb=0.265 sd=0.28 topography=normal area=0.063 perim=1.14
MMIPX X y VPWR VPB pfet_01v8_hvt m=1 w=1.0 l=0.15 mult=1 sa=0.265
+ sb=0.265 sd=0.28 topography=normal area=0.063 perim=1.14
MMNA0 pndA A1 VGND VNB nfet_01v8 m=1 w=0.65 l=0.15 mult=1 sa=0.265
+ sb=0.265 sd=0.28 topography=normal area=0.063 perim=1.14
MMNA1 pndA A2 VGND VNB nfet_01v8 m=1 w=0.65 l=0.15 mult=1 sa=0.265
+ sb=0.265 sd=0.28 topography=normal area=0.063 perim=1.14
MMNA2 pndA A3 VGND VNB nfet_01v8 m=1 w=0.65 l=0.15 mult=1 sa=0.265
+ sb=0.265 sd=0.28 topography=normal area=0.063 perim=1.14
MMNB0 pndB B1 pndA VNB nfet_01v8 m=1 w=0.65 l=0.15 mult=1 sa=0.265
+ sb=0.265 sd=0.28 topography=normal area=0.063 perim=1.14
MMNC0 y C1 pndB VNB nfet_01v8 m=1 w=0.65 l=0.15 mult=1 sa=0.265
+ sb=0.265 sd=0.28 topography=normal area=0.063 perim=1.14
MMINX X y VGND VNB nfet_01v8 m=1 w=0.65 l=0.15 mult=1 sa=0.265
+ sb=0.265 sd=0.28 topography=normal area=0.063 perim=1.14
.ENDS

.SUBCKT sky130_fd_sc_hd__o311a_2 A1 A2 A3 B1 C1 VGND VNB VPB VPWR X
MMPA0 VPWR A1 sndA1 VPB pfet_01v8_hvt m=1 w=1.0 l=0.15 mult=1 sa=0.265
+ sb=0.265 sd=0.28 topography=normal area=0.063 perim=1.14
MMPA1 sndA1 A2 sndA2 VPB pfet_01v8_hvt m=1 w=1.0 l=0.15 mult=1
+ sa=0.265 sb=0.265 sd=0.28 topography=normal area=0.063 perim=1.14
MMPA2 sndA2 A3 y VPB pfet_01v8_hvt m=1 w=1.0 l=0.15 mult=1 sa=0.265
+ sb=0.265 sd=0.28 topography=normal area=0.063 perim=1.14
MMPB0 VPWR B1 y VPB pfet_01v8_hvt m=1 w=1.0 l=0.15 mult=1 sa=0.265
+ sb=0.265 sd=0.28 topography=normal area=0.063 perim=1.14
MMPC0 VPWR C1 y VPB pfet_01v8_hvt m=1 w=1.0 l=0.15 mult=1 sa=0.265
+ sb=0.265 sd=0.28 topography=normal area=0.063 perim=1.14
MMIPX X y VPWR VPB pfet_01v8_hvt m=2 w=1.0 l=0.15 mult=1 sa=0.265
+ sb=0.265 sd=0.28 topography=normal area=0.063 perim=1.14
MMNA0 pndA A1 VGND VNB nfet_01v8 m=1 w=0.65 l=0.15 mult=1 sa=0.265
+ sb=0.265 sd=0.28 topography=normal area=0.063 perim=1.14
MMNA1 pndA A2 VGND VNB nfet_01v8 m=1 w=0.65 l=0.15 mult=1 sa=0.265
+ sb=0.265 sd=0.28 topography=normal area=0.063 perim=1.14
MMNA2 pndA A3 VGND VNB nfet_01v8 m=1 w=0.65 l=0.15 mult=1 sa=0.265
+ sb=0.265 sd=0.28 topography=normal area=0.063 perim=1.14
MMNB0 pndB B1 pndA VNB nfet_01v8 m=1 w=0.65 l=0.15 mult=1 sa=0.265
+ sb=0.265 sd=0.28 topography=normal area=0.063 perim=1.14
MMNC0 y C1 pndB VNB nfet_01v8 m=1 w=0.65 l=0.15 mult=1 sa=0.265
+ sb=0.265 sd=0.28 topography=normal area=0.063 perim=1.14
MMINX X y VGND VNB nfet_01v8 m=2 w=0.65 l=0.15 mult=1 sa=0.265
+ sb=0.265 sd=0.28 topography=normal area=0.063 perim=1.14
.ENDS

.SUBCKT sky130_fd_sc_hd__o311a_4 A1 A2 A3 B1 C1 VGND VNB VPB VPWR X
MMPA0 VPWR A1 sndA1 VPB pfet_01v8_hvt m=2 w=1.0 l=0.15 mult=1 sa=0.265
+ sb=0.265 sd=0.28 topography=normal area=0.063 perim=1.14
MMPA1 sndA1 A2 sndA2 VPB pfet_01v8_hvt m=2 w=1.0 l=0.15 mult=1
+ sa=0.265 sb=0.265 sd=0.28 topography=normal area=0.063 perim=1.14
MMPA2 sndA2 A3 y VPB pfet_01v8_hvt m=2 w=1.0 l=0.15 mult=1 sa=0.265
+ sb=0.265 sd=0.28 topography=normal area=0.063 perim=1.14
MMPB0 VPWR B1 y VPB pfet_01v8_hvt m=2 w=1.0 l=0.15 mult=1 sa=0.265
+ sb=0.265 sd=0.28 topography=normal area=0.063 perim=1.14
MMPC0 VPWR C1 y VPB pfet_01v8_hvt m=2 w=1.0 l=0.15 mult=1 sa=0.265
+ sb=0.265 sd=0.28 topography=normal area=0.063 perim=1.14
MMIPX X y VPWR VPB pfet_01v8_hvt m=4 w=1.0 l=0.15 mult=1 sa=0.265
+ sb=0.265 sd=0.28 topography=normal area=0.063 perim=1.14
MMNA0 pndA A1 VGND VNB nfet_01v8 m=2 w=0.65 l=0.15 mult=1 sa=0.265
+ sb=0.265 sd=0.28 topography=normal area=0.063 perim=1.14
MMNA1 pndA A2 VGND VNB nfet_01v8 m=2 w=0.65 l=0.15 mult=1 sa=0.265
+ sb=0.265 sd=0.28 topography=normal area=0.063 perim=1.14
MMNA2 pndA A3 VGND VNB nfet_01v8 m=2 w=0.65 l=0.15 mult=1 sa=0.265
+ sb=0.265 sd=0.28 topography=normal area=0.063 perim=1.14
MMNB0 pndB B1 pndA VNB nfet_01v8 m=2 w=0.65 l=0.15 mult=1 sa=0.265
+ sb=0.265 sd=0.28 topography=normal area=0.063 perim=1.14
MMNC0 y C1 pndB VNB nfet_01v8 m=2 w=0.65 l=0.15 mult=1 sa=0.265
+ sb=0.265 sd=0.28 topography=normal area=0.063 perim=1.14
MMINX X y VGND VNB nfet_01v8 m=4 w=0.65 l=0.15 mult=1 sa=0.265
+ sb=0.265 sd=0.28 topography=normal area=0.063 perim=1.14
.ENDS

.SUBCKT sky130_fd_sc_hd__o311ai_0 A1 A2 A3 B1 C1 VGND VNB VPB VPWR Y
MMPA0 VPWR A1 sndA1 VPB pfet_01v8_hvt m=1 w=0.64 l=0.15 mult=1
+ sa=0.265 sb=0.265 sd=0.28 topography=normal area=0.063 perim=1.14
MMPA1 sndA1 A2 sndA2 VPB pfet_01v8_hvt m=1 w=0.64 l=0.15 mult=1
+ sa=0.265 sb=0.265 sd=0.28 topography=normal area=0.063 perim=1.14
MMPA2 sndA2 A3 Y VPB pfet_01v8_hvt m=1 w=0.64 l=0.15 mult=1 sa=0.265
+ sb=0.265 sd=0.28 topography=normal area=0.063 perim=1.14
MMPB0 VPWR B1 Y VPB pfet_01v8_hvt m=1 w=0.64 l=0.15 mult=1 sa=0.265
+ sb=0.265 sd=0.28 topography=normal area=0.063 perim=1.14
MMPC0 VPWR C1 Y VPB pfet_01v8_hvt m=1 w=0.64 l=0.15 mult=1 sa=0.265
+ sb=0.265 sd=0.28 topography=normal area=0.063 perim=1.14
MMNA0 pndA A1 VGND VNB nfet_01v8 m=1 w=0.42 l=0.15 mult=1 sa=0.265
+ sb=0.265 sd=0.28 topography=normal area=0.063 perim=1.14
MMNA1 pndA A2 VGND VNB nfet_01v8 m=1 w=0.42 l=0.15 mult=1 sa=0.265
+ sb=0.265 sd=0.28 topography=normal area=0.063 perim=1.14
MMNA2 pndA A3 VGND VNB nfet_01v8 m=1 w=0.42 l=0.15 mult=1 sa=0.265
+ sb=0.265 sd=0.28 topography=normal area=0.063 perim=1.14
MMNB0 pndB B1 pndA VNB nfet_01v8 m=1 w=0.42 l=0.15 mult=1 sa=0.265
+ sb=0.265 sd=0.28 topography=normal area=0.063 perim=1.14
MMNC0 Y C1 pndB VNB nfet_01v8 m=1 w=0.42 l=0.15 mult=1 sa=0.265
+ sb=0.265 sd=0.28 topography=normal area=0.063 perim=1.14
.ENDS

.SUBCKT sky130_fd_sc_hd__o311ai_1 A1 A2 A3 B1 C1 VGND VNB VPB VPWR Y
MMPA0 VPWR A1 sndA1 VPB pfet_01v8_hvt m=1 w=1.0 l=0.15 mult=1 sa=0.265
+ sb=0.265 sd=0.28 topography=normal area=0.063 perim=1.14
MMPA1 sndA1 A2 sndA2 VPB pfet_01v8_hvt m=1 w=1.0 l=0.15 mult=1
+ sa=0.265 sb=0.265 sd=0.28 topography=normal area=0.063 perim=1.14
MMPA2 sndA2 A3 Y VPB pfet_01v8_hvt m=1 w=1.0 l=0.15 mult=1 sa=0.265
+ sb=0.265 sd=0.28 topography=normal area=0.063 perim=1.14
MMPB0 VPWR B1 Y VPB pfet_01v8_hvt m=1 w=1.0 l=0.15 mult=1 sa=0.265
+ sb=0.265 sd=0.28 topography=normal area=0.063 perim=1.14
MMPC0 VPWR C1 Y VPB pfet_01v8_hvt m=1 w=1.0 l=0.15 mult=1 sa=0.265
+ sb=0.265 sd=0.28 topography=normal area=0.063 perim=1.14
MMNA0 pndA A1 VGND VNB nfet_01v8 m=1 w=0.65 l=0.15 mult=1 sa=0.265
+ sb=0.265 sd=0.28 topography=normal area=0.063 perim=1.14
MMNA1 pndA A2 VGND VNB nfet_01v8 m=1 w=0.65 l=0.15 mult=1 sa=0.265
+ sb=0.265 sd=0.28 topography=normal area=0.063 perim=1.14
MMNA2 pndA A3 VGND VNB nfet_01v8 m=1 w=0.65 l=0.15 mult=1 sa=0.265
+ sb=0.265 sd=0.28 topography=normal area=0.063 perim=1.14
MMNB0 pndB B1 pndA VNB nfet_01v8 m=1 w=0.65 l=0.15 mult=1 sa=0.265
+ sb=0.265 sd=0.28 topography=normal area=0.063 perim=1.14
MMNC0 Y C1 pndB VNB nfet_01v8 m=1 w=0.65 l=0.15 mult=1 sa=0.265
+ sb=0.265 sd=0.28 topography=normal area=0.063 perim=1.14
.ENDS

.SUBCKT sky130_fd_sc_hd__o311ai_2 A1 A2 A3 B1 C1 VGND VNB VPB VPWR Y
MMPA0 VPWR A1 sndA1 VPB pfet_01v8_hvt m=2 w=1.0 l=0.15 mult=1 sa=0.265
+ sb=0.265 sd=0.28 topography=normal area=0.063 perim=1.14
MMPA1 sndA1 A2 sndA2 VPB pfet_01v8_hvt m=2 w=1.0 l=0.15 mult=1
+ sa=0.265 sb=0.265 sd=0.28 topography=normal area=0.063 perim=1.14
MMPA2 sndA2 A3 Y VPB pfet_01v8_hvt m=2 w=1.0 l=0.15 mult=1 sa=0.265
+ sb=0.265 sd=0.28 topography=normal area=0.063 perim=1.14
MMPB0 VPWR B1 Y VPB pfet_01v8_hvt m=2 w=1.0 l=0.15 mult=1 sa=0.265
+ sb=0.265 sd=0.28 topography=normal area=0.063 perim=1.14
MMPC0 VPWR C1 Y VPB pfet_01v8_hvt m=2 w=1.0 l=0.15 mult=1 sa=0.265
+ sb=0.265 sd=0.28 topography=normal area=0.063 perim=1.14
MMNA0 pndA A1 VGND VNB nfet_01v8 m=2 w=0.65 l=0.15 mult=1 sa=0.265
+ sb=0.265 sd=0.28 topography=normal area=0.063 perim=1.14
MMNA1 pndA A2 VGND VNB nfet_01v8 m=2 w=0.65 l=0.15 mult=1 sa=0.265
+ sb=0.265 sd=0.28 topography=normal area=0.063 perim=1.14
MMNA2 pndA A3 VGND VNB nfet_01v8 m=2 w=0.65 l=0.15 mult=1 sa=0.265
+ sb=0.265 sd=0.28 topography=normal area=0.063 perim=1.14
MMNB0 pndB B1 pndA VNB nfet_01v8 m=2 w=0.65 l=0.15 mult=1 sa=0.265
+ sb=0.265 sd=0.28 topography=normal area=0.063 perim=1.14
MMNC0 Y C1 pndB VNB nfet_01v8 m=2 w=0.65 l=0.15 mult=1 sa=0.265
+ sb=0.265 sd=0.28 topography=normal area=0.063 perim=1.14
.ENDS

.SUBCKT sky130_fd_sc_hd__o311ai_4 A1 A2 A3 B1 C1 VGND VNB VPB VPWR Y
MMPA0 VPWR A1 sndA1 VPB pfet_01v8_hvt m=4 w=1.0 l=0.15 mult=1 sa=0.265
+ sb=0.265 sd=0.28 topography=normal area=0.063 perim=1.14
MMPA1 sndA1 A2 sndA2 VPB pfet_01v8_hvt m=4 w=1.0 l=0.15 mult=1
+ sa=0.265 sb=0.265 sd=0.28 topography=normal area=0.063 perim=1.14
MMPA2 sndA2 A3 Y VPB pfet_01v8_hvt m=4 w=1.0 l=0.15 mult=1 sa=0.265
+ sb=0.265 sd=0.28 topography=normal area=0.063 perim=1.14
MMPB0 VPWR B1 Y VPB pfet_01v8_hvt m=4 w=1.0 l=0.15 mult=1 sa=0.265
+ sb=0.265 sd=0.28 topography=normal area=0.063 perim=1.14
MMPC0 VPWR C1 Y VPB pfet_01v8_hvt m=4 w=1.0 l=0.15 mult=1 sa=0.265
+ sb=0.265 sd=0.28 topography=normal area=0.063 perim=1.14
MMNA0 pndA A1 VGND VNB nfet_01v8 m=4 w=0.65 l=0.15 mult=1 sa=0.265
+ sb=0.265 sd=0.28 topography=normal area=0.063 perim=1.14
MMNA1 pndA A2 VGND VNB nfet_01v8 m=4 w=0.65 l=0.15 mult=1 sa=0.265
+ sb=0.265 sd=0.28 topography=normal area=0.063 perim=1.14
MMNA2 pndA A3 VGND VNB nfet_01v8 m=4 w=0.65 l=0.15 mult=1 sa=0.265
+ sb=0.265 sd=0.28 topography=normal area=0.063 perim=1.14
MMNB0 pndB B1 pndA VNB nfet_01v8 m=4 w=0.65 l=0.15 mult=1 sa=0.265
+ sb=0.265 sd=0.28 topography=normal area=0.063 perim=1.14
MMNC0 Y C1 pndB VNB nfet_01v8 m=4 w=0.65 l=0.15 mult=1 sa=0.265
+ sb=0.265 sd=0.28 topography=normal area=0.063 perim=1.14
.ENDS

.SUBCKT sky130_fd_sc_hd__o2111a_1 A1 A2 B1 C1 D1 VGND VNB VPB VPWR X
MMPA0 VPWR A1 sndA1 VPB pfet_01v8_hvt m=1 w=1.0 l=0.15 mult=1 sa=0.265
+ sb=0.265 sd=0.28 topography=normal area=0.063 perim=1.14
MMPA1 sndA1 A2 y VPB pfet_01v8_hvt m=1 w=1.0 l=0.15 mult=1 sa=0.265
+ sb=0.265 sd=0.28 topography=normal area=0.063 perim=1.14
MMPB0 VPWR B1 y VPB pfet_01v8_hvt m=1 w=1.0 l=0.15 mult=1 sa=0.265
+ sb=0.265 sd=0.28 topography=normal area=0.063 perim=1.14
MMPC0 VPWR C1 y VPB pfet_01v8_hvt m=1 w=1.0 l=0.15 mult=1 sa=0.265
+ sb=0.265 sd=0.28 topography=normal area=0.063 perim=1.14
MMPD0 VPWR D1 y VPB pfet_01v8_hvt m=1 w=1.0 l=0.15 mult=1 sa=0.265
+ sb=0.265 sd=0.28 topography=normal area=0.063 perim=1.14
MMIPX X y VPWR VPB pfet_01v8_hvt m=1 w=1.0 l=0.15 mult=1 sa=0.265
+ sb=0.265 sd=0.28 topography=normal area=0.063 perim=1.14
MMNA0 pndA A1 VGND VNB nfet_01v8 m=1 w=0.65 l=0.15 mult=1 sa=0.265
+ sb=0.265 sd=0.28 topography=normal area=0.063 perim=1.14
MMNA1 pndA A2 VGND VNB nfet_01v8 m=1 w=0.65 l=0.15 mult=1 sa=0.265
+ sb=0.265 sd=0.28 topography=normal area=0.063 perim=1.14
MMNB0 pndB B1 pndA VNB nfet_01v8 m=1 w=0.65 l=0.15 mult=1 sa=0.265
+ sb=0.265 sd=0.28 topography=normal area=0.063 perim=1.14
MMNC0 pndC C1 pndB VNB nfet_01v8 m=1 w=0.65 l=0.15 mult=1 sa=0.265
+ sb=0.265 sd=0.28 topography=normal area=0.063 perim=1.14
MMND0 y D1 pndC VNB nfet_01v8 m=1 w=0.65 l=0.15 mult=1 sa=0.265
+ sb=0.265 sd=0.28 topography=normal area=0.063 perim=1.14
MMINX X y VGND VNB nfet_01v8 m=1 w=0.65 l=0.15 mult=1 sa=0.265
+ sb=0.265 sd=0.28 topography=normal area=0.063 perim=1.14
.ENDS

.SUBCKT sky130_fd_sc_hd__o2111a_2 A1 A2 B1 C1 D1 VGND VNB VPB VPWR X
MMPA0 VPWR A1 sndA1 VPB pfet_01v8_hvt m=1 w=1.0 l=0.15 mult=1 sa=0.265
+ sb=0.265 sd=0.28 topography=normal area=0.063 perim=1.14
MMPA1 sndA1 A2 y VPB pfet_01v8_hvt m=1 w=1.0 l=0.15 mult=1 sa=0.265
+ sb=0.265 sd=0.28 topography=normal area=0.063 perim=1.14
MMPB0 VPWR B1 y VPB pfet_01v8_hvt m=1 w=1.0 l=0.15 mult=1 sa=0.265
+ sb=0.265 sd=0.28 topography=normal area=0.063 perim=1.14
MMPC0 VPWR C1 y VPB pfet_01v8_hvt m=1 w=1.0 l=0.15 mult=1 sa=0.265
+ sb=0.265 sd=0.28 topography=normal area=0.063 perim=1.14
MMPD0 VPWR D1 y VPB pfet_01v8_hvt m=1 w=1.0 l=0.15 mult=1 sa=0.265
+ sb=0.265 sd=0.28 topography=normal area=0.063 perim=1.14
MMIPX X y VPWR VPB pfet_01v8_hvt m=2 w=1.0 l=0.15 mult=1 sa=0.265
+ sb=0.265 sd=0.28 topography=normal area=0.063 perim=1.14
MMNA0 pndA A1 VGND VNB nfet_01v8 m=1 w=0.65 l=0.15 mult=1 sa=0.265
+ sb=0.265 sd=0.28 topography=normal area=0.063 perim=1.14
MMNA1 pndA A2 VGND VNB nfet_01v8 m=1 w=0.65 l=0.15 mult=1 sa=0.265
+ sb=0.265 sd=0.28 topography=normal area=0.063 perim=1.14
MMNB0 pndB B1 pndA VNB nfet_01v8 m=1 w=0.65 l=0.15 mult=1 sa=0.265
+ sb=0.265 sd=0.28 topography=normal area=0.063 perim=1.14
MMNC0 pndC C1 pndB VNB nfet_01v8 m=1 w=0.65 l=0.15 mult=1 sa=0.265
+ sb=0.265 sd=0.28 topography=normal area=0.063 perim=1.14
MMND0 y D1 pndC VNB nfet_01v8 m=1 w=0.65 l=0.15 mult=1 sa=0.265
+ sb=0.265 sd=0.28 topography=normal area=0.063 perim=1.14
MMINX X y VGND VNB nfet_01v8 m=2 w=0.65 l=0.15 mult=1 sa=0.265
+ sb=0.265 sd=0.28 topography=normal area=0.063 perim=1.14
.ENDS

.SUBCKT sky130_fd_sc_hd__o2111a_4 A1 A2 B1 C1 D1 VGND VNB VPB VPWR X
MMPA0 VPWR A1 sndA1 VPB pfet_01v8_hvt m=2 w=1.0 l=0.15 mult=1 sa=0.265
+ sb=0.265 sd=0.28 topography=normal area=0.063 perim=1.14
MMPA1 sndA1 A2 y VPB pfet_01v8_hvt m=2 w=1.0 l=0.15 mult=1 sa=0.265
+ sb=0.265 sd=0.28 topography=normal area=0.063 perim=1.14
MMPB0 VPWR B1 y VPB pfet_01v8_hvt m=2 w=1.0 l=0.15 mult=1 sa=0.265
+ sb=0.265 sd=0.28 topography=normal area=0.063 perim=1.14
MMPC0 VPWR C1 y VPB pfet_01v8_hvt m=2 w=1.0 l=0.15 mult=1 sa=0.265
+ sb=0.265 sd=0.28 topography=normal area=0.063 perim=1.14
MMPD0 VPWR D1 y VPB pfet_01v8_hvt m=2 w=1.0 l=0.15 mult=1 sa=0.265
+ sb=0.265 sd=0.28 topography=normal area=0.063 perim=1.14
MMIPX X y VPWR VPB pfet_01v8_hvt m=4 w=1.0 l=0.15 mult=1 sa=0.265
+ sb=0.265 sd=0.28 topography=normal area=0.063 perim=1.14
MMNA0 pndA A1 VGND VNB nfet_01v8 m=2 w=0.65 l=0.15 mult=1 sa=0.265
+ sb=0.265 sd=0.28 topography=normal area=0.063 perim=1.14
MMNA1 pndA A2 VGND VNB nfet_01v8 m=2 w=0.65 l=0.15 mult=1 sa=0.265
+ sb=0.265 sd=0.28 topography=normal area=0.063 perim=1.14
MMNB0 pndB B1 pndA VNB nfet_01v8 m=2 w=0.65 l=0.15 mult=1 sa=0.265
+ sb=0.265 sd=0.28 topography=normal area=0.063 perim=1.14
MMNC0 pndC C1 pndB VNB nfet_01v8 m=2 w=0.65 l=0.15 mult=1 sa=0.265
+ sb=0.265 sd=0.28 topography=normal area=0.063 perim=1.14
MMND0 y D1 pndC VNB nfet_01v8 m=2 w=0.65 l=0.15 mult=1 sa=0.265
+ sb=0.265 sd=0.28 topography=normal area=0.063 perim=1.14
MMINX X y VGND VNB nfet_01v8 m=4 w=0.65 l=0.15 mult=1 sa=0.265
+ sb=0.265 sd=0.28 topography=normal area=0.063 perim=1.14
.ENDS

.SUBCKT sky130_fd_sc_hd__o2111ai_1 A1 A2 B1 C1 D1 VGND VNB VPB VPWR Y
MMPA0 VPWR A1 sndA1 VPB pfet_01v8_hvt m=1 w=1.0 l=0.15 mult=1 sa=0.265
+ sb=0.265 sd=0.28 topography=normal area=0.063 perim=1.14
MMPA1 sndA1 A2 Y VPB pfet_01v8_hvt m=1 w=1.0 l=0.15 mult=1 sa=0.265
+ sb=0.265 sd=0.28 topography=normal area=0.063 perim=1.14
MMPB0 VPWR B1 Y VPB pfet_01v8_hvt m=1 w=1.0 l=0.15 mult=1 sa=0.265
+ sb=0.265 sd=0.28 topography=normal area=0.063 perim=1.14
MMPC0 VPWR C1 Y VPB pfet_01v8_hvt m=1 w=1.0 l=0.15 mult=1 sa=0.265
+ sb=0.265 sd=0.28 topography=normal area=0.063 perim=1.14
MMPD0 VPWR D1 Y VPB pfet_01v8_hvt m=1 w=1.0 l=0.15 mult=1 sa=0.265
+ sb=0.265 sd=0.28 topography=normal area=0.063 perim=1.14
MMNA0 pndA A1 VGND VNB nfet_01v8 m=1 w=0.65 l=0.15 mult=1 sa=0.265
+ sb=0.265 sd=0.28 topography=normal area=0.063 perim=1.14
MMNA1 pndA A2 VGND VNB nfet_01v8 m=1 w=0.65 l=0.15 mult=1 sa=0.265
+ sb=0.265 sd=0.28 topography=normal area=0.063 perim=1.14
MMNB0 pndB B1 pndA VNB nfet_01v8 m=1 w=0.65 l=0.15 mult=1 sa=0.265
+ sb=0.265 sd=0.28 topography=normal area=0.063 perim=1.14
MMNC0 pndC C1 pndB VNB nfet_01v8 m=1 w=0.65 l=0.15 mult=1 sa=0.265
+ sb=0.265 sd=0.28 topography=normal area=0.063 perim=1.14
MMND0 Y D1 pndC VNB nfet_01v8 m=1 w=0.65 l=0.15 mult=1 sa=0.265
+ sb=0.265 sd=0.28 topography=normal area=0.063 perim=1.14
.ENDS

.SUBCKT sky130_fd_sc_hd__o2111ai_2 A1 A2 B1 C1 D1 VGND VNB VPB VPWR Y
MMPA0 VPWR A1 sndA1 VPB pfet_01v8_hvt m=2 w=1.0 l=0.15 mult=1 sa=0.265
+ sb=0.265 sd=0.28 topography=normal area=0.063 perim=1.14
MMPA1 sndA1 A2 Y VPB pfet_01v8_hvt m=2 w=1.0 l=0.15 mult=1 sa=0.265
+ sb=0.265 sd=0.28 topography=normal area=0.063 perim=1.14
MMPB0 VPWR B1 Y VPB pfet_01v8_hvt m=2 w=1.0 l=0.15 mult=1 sa=0.265
+ sb=0.265 sd=0.28 topography=normal area=0.063 perim=1.14
MMPC0 VPWR C1 Y VPB pfet_01v8_hvt m=2 w=1.0 l=0.15 mult=1 sa=0.265
+ sb=0.265 sd=0.28 topography=normal area=0.063 perim=1.14
MMPD0 VPWR D1 Y VPB pfet_01v8_hvt m=2 w=1.0 l=0.15 mult=1 sa=0.265
+ sb=0.265 sd=0.28 topography=normal area=0.063 perim=1.14
MMNA0 pndA A1 VGND VNB nfet_01v8 m=2 w=0.65 l=0.15 mult=1 sa=0.265
+ sb=0.265 sd=0.28 topography=normal area=0.063 perim=1.14
MMNA1 pndA A2 VGND VNB nfet_01v8 m=2 w=0.65 l=0.15 mult=1 sa=0.265
+ sb=0.265 sd=0.28 topography=normal area=0.063 perim=1.14
MMNB0 pndB B1 pndA VNB nfet_01v8 m=2 w=0.65 l=0.15 mult=1 sa=0.265
+ sb=0.265 sd=0.28 topography=normal area=0.063 perim=1.14
MMNC0 pndC C1 pndB VNB nfet_01v8 m=2 w=0.65 l=0.15 mult=1 sa=0.265
+ sb=0.265 sd=0.28 topography=normal area=0.063 perim=1.14
MMND0 Y D1 pndC VNB nfet_01v8 m=2 w=0.65 l=0.15 mult=1 sa=0.265
+ sb=0.265 sd=0.28 topography=normal area=0.063 perim=1.14
.ENDS

.SUBCKT sky130_fd_sc_hd__o2111ai_4 A1 A2 B1 C1 D1 VGND VNB VPB VPWR Y
MMPA0 VPWR A1 sndA1 VPB pfet_01v8_hvt m=4 w=1.0 l=0.15 mult=1 sa=0.265
+ sb=0.265 sd=0.28 topography=normal area=0.063 perim=1.14
MMPA1 sndA1 A2 Y VPB pfet_01v8_hvt m=4 w=1.0 l=0.15 mult=1 sa=0.265
+ sb=0.265 sd=0.28 topography=normal area=0.063 perim=1.14
MMPB0 VPWR B1 Y VPB pfet_01v8_hvt m=4 w=1.0 l=0.15 mult=1 sa=0.265
+ sb=0.265 sd=0.28 topography=normal area=0.063 perim=1.14
MMPC0 VPWR C1 Y VPB pfet_01v8_hvt m=4 w=1.0 l=0.15 mult=1 sa=0.265
+ sb=0.265 sd=0.28 topography=normal area=0.063 perim=1.14
MMPD0 VPWR D1 Y VPB pfet_01v8_hvt m=4 w=1.0 l=0.15 mult=1 sa=0.265
+ sb=0.265 sd=0.28 topography=normal area=0.063 perim=1.14
MMNA0 pndA A1 VGND VNB nfet_01v8 m=4 w=0.65 l=0.15 mult=1 sa=0.265
+ sb=0.265 sd=0.28 topography=normal area=0.063 perim=1.14
MMNA1 pndA A2 VGND VNB nfet_01v8 m=4 w=0.65 l=0.15 mult=1 sa=0.265
+ sb=0.265 sd=0.28 topography=normal area=0.063 perim=1.14
MMNB0 pndB B1 pndA VNB nfet_01v8 m=4 w=0.65 l=0.15 mult=1 sa=0.265
+ sb=0.265 sd=0.28 topography=normal area=0.063 perim=1.14
MMNC0 pndC C1 pndB VNB nfet_01v8 m=4 w=0.65 l=0.15 mult=1 sa=0.265
+ sb=0.265 sd=0.28 topography=normal area=0.063 perim=1.14
MMND0 Y D1 pndC VNB nfet_01v8 m=4 w=0.65 l=0.15 mult=1 sa=0.265
+ sb=0.265 sd=0.28 topography=normal area=0.063 perim=1.14
.ENDS

.SUBCKT sky130_fd_sc_hd__or2_0 A B VGND VNB VPB VPWR X
MMP0 VPWR A sndPA VPB pfet_01v8_hvt m=1 w=0.42 l=0.15 mult=1 sa=0.265
+ sb=0.265 sd=0.28 topography=normal area=0.063 perim=1.14
MMP1 sndPA B y VPB pfet_01v8_hvt m=1 w=0.42 l=0.15 mult=1 sa=0.265
+ sb=0.265 sd=0.28 topography=normal area=0.063 perim=1.14
MMIP2 X y VPWR VPB pfet_01v8_hvt m=1 w=0.64 l=0.15 mult=1 sa=0.265
+ sb=0.265 sd=0.28 topography=normal area=0.063 perim=1.14
MMN0 y A VGND VNB nfet_01v8 m=1 w=0.42 l=0.15 mult=1 sa=0.265 sb=0.265
+ sd=0.28 topography=normal area=0.063 perim=1.14
MMN1 y B VGND VNB nfet_01v8 m=1 w=0.42 l=0.15 mult=1 sa=0.265 sb=0.265
+ sd=0.28 topography=normal area=0.063 perim=1.14
MMIN2 X y VGND VNB nfet_01v8 m=1 w=0.42 l=0.15 mult=1 sa=0.265
+ sb=0.265 sd=0.28 topography=normal area=0.063 perim=1.14
.ENDS

.SUBCKT sky130_fd_sc_hd__or2_1 A B VGND VNB VPB VPWR X
MMP0 VPWR A sndPA VPB pfet_01v8_hvt m=1 w=0.42 l=0.15 mult=1 sa=0.265
+ sb=0.265 sd=0.28 topography=normal area=0.063 perim=1.14
MMP1 sndPA B y VPB pfet_01v8_hvt m=1 w=0.42 l=0.15 mult=1 sa=0.265
+ sb=0.265 sd=0.28 topography=normal area=0.063 perim=1.14
MMIP2 X y VPWR VPB pfet_01v8_hvt m=1 w=1.0 l=0.15 mult=1 sa=0.265
+ sb=0.265 sd=0.28 topography=normal area=0.063 perim=1.14
MMN0 y A VGND VNB nfet_01v8 m=1 w=0.42 l=0.15 mult=1 sa=0.265 sb=0.265
+ sd=0.28 topography=normal area=0.063 perim=1.14
MMN1 y B VGND VNB nfet_01v8 m=1 w=0.42 l=0.15 mult=1 sa=0.265 sb=0.265
+ sd=0.28 topography=normal area=0.063 perim=1.14
MMIN2 X y VGND VNB nfet_01v8 m=1 w=0.65 l=0.15 mult=1 sa=0.265
+ sb=0.265 sd=0.28 topography=normal area=0.063 perim=1.14
.ENDS

.SUBCKT sky130_fd_sc_hd__or2_2 A B VGND VNB VPB VPWR X
MMP0 VPWR A sndPA VPB pfet_01v8_hvt m=1 w=0.42 l=0.15 mult=1 sa=0.265
+ sb=0.265 sd=0.28 topography=normal area=0.063 perim=1.14
MMP1 sndPA B y VPB pfet_01v8_hvt m=1 w=0.42 l=0.15 mult=1 sa=0.265
+ sb=0.265 sd=0.28 topography=normal area=0.063 perim=1.14
MMIP2 X y VPWR VPB pfet_01v8_hvt m=2 w=1.0 l=0.15 mult=1 sa=0.265
+ sb=0.265 sd=0.28 topography=normal area=0.063 perim=1.14
MMN0 y A VGND VNB nfet_01v8 m=1 w=0.42 l=0.15 mult=1 sa=0.265 sb=0.265
+ sd=0.28 topography=normal area=0.063 perim=1.14
MMN1 y B VGND VNB nfet_01v8 m=1 w=0.42 l=0.15 mult=1 sa=0.265 sb=0.265
+ sd=0.28 topography=normal area=0.063 perim=1.14
MMIN2 X y VGND VNB nfet_01v8 m=2 w=0.65 l=0.15 mult=1 sa=0.265
+ sb=0.265 sd=0.28 topography=normal area=0.063 perim=1.14
.ENDS

.SUBCKT sky130_fd_sc_hd__or2_4 A B VGND VNB VPB VPWR X
MMP0 VPWR A sndPA VPB pfet_01v8_hvt m=1 w=1.0 l=0.15 mult=1 sa=0.265
+ sb=0.265 sd=0.28 topography=normal area=0.063 perim=1.14
MMP1 sndPA B y VPB pfet_01v8_hvt m=1 w=1.0 l=0.15 mult=1 sa=0.265
+ sb=0.265 sd=0.28 topography=normal area=0.063 perim=1.14
MMIP2 X y VPWR VPB pfet_01v8_hvt m=4 w=1.0 l=0.15 mult=1 sa=0.265
+ sb=0.265 sd=0.28 topography=normal area=0.063 perim=1.14
MMN0 y A VGND VNB nfet_01v8 m=1 w=0.65 l=0.15 mult=1 sa=0.265 sb=0.265
+ sd=0.28 topography=normal area=0.063 perim=1.14
MMN1 y B VGND VNB nfet_01v8 m=1 w=0.65 l=0.15 mult=1 sa=0.265 sb=0.265
+ sd=0.28 topography=normal area=0.063 perim=1.14
MMIN2 X y VGND VNB nfet_01v8 m=4 w=0.65 l=0.15 mult=1 sa=0.265
+ sb=0.265 sd=0.28 topography=normal area=0.063 perim=1.14
.ENDS

.SUBCKT sky130_fd_sc_hd__or2b_1 A B_N VGND VNB VPB VPWR X
MMP0 VPWR A sndPA VPB pfet_01v8_hvt m=1 w=0.42 l=0.15 mult=1 sa=0.265
+ sb=0.265 sd=0.28 topography=normal area=0.063 perim=1.14
MMP1 sndPA B y VPB pfet_01v8_hvt m=1 w=0.42 l=0.15 mult=1 sa=0.265
+ sb=0.265 sd=0.28 topography=normal area=0.063 perim=1.14
MMIP1 B B_N VPWR VPB pfet_01v8_hvt m=1 w=0.42 l=0.15 mult=1 sa=0.265
+ sb=0.265 sd=0.28 topography=normal area=0.063 perim=1.14
MMIP2 X y VPWR VPB pfet_01v8_hvt m=1 w=1.0 l=0.15 mult=1 sa=0.265
+ sb=0.265 sd=0.28 topography=normal area=0.063 perim=1.14
MMN0 y A VGND VNB nfet_01v8 m=1 w=0.42 l=0.15 mult=1 sa=0.265 sb=0.265
+ sd=0.28 topography=normal area=0.063 perim=1.14
MMN1 y B VGND VNB nfet_01v8 m=1 w=0.42 l=0.15 mult=1 sa=0.265 sb=0.265
+ sd=0.28 topography=normal area=0.063 perim=1.14
MMIN1 B B_N VGND VNB nfet_01v8 m=1 w=0.42 l=0.15 mult=1 sa=0.265
+ sb=0.265 sd=0.28 topography=normal area=0.063 perim=1.14
MMIN2 X y VGND VNB nfet_01v8 m=1 w=0.65 l=0.15 mult=1 sa=0.265
+ sb=0.265 sd=0.28 topography=normal area=0.063 perim=1.14
.ENDS

.SUBCKT sky130_fd_sc_hd__or2b_2 A B_N VGND VNB VPB VPWR X
MMP0 VPWR A sndPA VPB pfet_01v8_hvt m=1 w=0.42 l=0.15 mult=1 sa=0.265
+ sb=0.265 sd=0.28 topography=normal area=0.063 perim=1.14
MMP1 sndPA B y VPB pfet_01v8_hvt m=1 w=0.42 l=0.15 mult=1 sa=0.265
+ sb=0.265 sd=0.28 topography=normal area=0.063 perim=1.14
MMIP1 B B_N VPWR VPB pfet_01v8_hvt m=1 w=0.42 l=0.15 mult=1 sa=0.265
+ sb=0.265 sd=0.28 topography=normal area=0.063 perim=1.14
MMIP2 X y VPWR VPB pfet_01v8_hvt m=2 w=1.0 l=0.15 mult=1 sa=0.265
+ sb=0.265 sd=0.28 topography=normal area=0.063 perim=1.14
MMN0 y A VGND VNB nfet_01v8 m=1 w=0.42 l=0.15 mult=1 sa=0.265 sb=0.265
+ sd=0.28 topography=normal area=0.063 perim=1.14
MMN1 y B VGND VNB nfet_01v8 m=1 w=0.42 l=0.15 mult=1 sa=0.265 sb=0.265
+ sd=0.28 topography=normal area=0.063 perim=1.14
MMIN1 B B_N VGND VNB nfet_01v8 m=1 w=0.42 l=0.15 mult=1 sa=0.265
+ sb=0.265 sd=0.28 topography=normal area=0.063 perim=1.14
MMIN2 X y VGND VNB nfet_01v8 m=2 w=0.65 l=0.15 mult=1 sa=0.265
+ sb=0.265 sd=0.28 topography=normal area=0.063 perim=1.14
.ENDS

.SUBCKT sky130_fd_sc_hd__or2b_4 A B_N VGND VNB VPB VPWR X
MMP0 VPWR A sndPA VPB pfet_01v8_hvt m=1 w=1.0 l=0.15 mult=1 sa=0.265
+ sb=0.265 sd=0.28 topography=normal area=0.063 perim=1.14
MMP1 sndPA B y VPB pfet_01v8_hvt m=1 w=1.0 l=0.15 mult=1 sa=0.265
+ sb=0.265 sd=0.28 topography=normal area=0.063 perim=1.14
MMIP1 B B_N VPWR VPB pfet_01v8_hvt m=1 w=0.42 l=0.15 mult=1 sa=0.265
+ sb=0.265 sd=0.28 topography=normal area=0.063 perim=1.14
MMIP2 X y VPWR VPB pfet_01v8_hvt m=4 w=1.0 l=0.15 mult=1 sa=0.265
+ sb=0.265 sd=0.28 topography=normal area=0.063 perim=1.14
MMN0 y A VGND VNB nfet_01v8 m=1 w=0.65 l=0.15 mult=1 sa=0.265 sb=0.265
+ sd=0.28 topography=normal area=0.063 perim=1.14
MMN1 y B VGND VNB nfet_01v8 m=1 w=0.65 l=0.15 mult=1 sa=0.265 sb=0.265
+ sd=0.28 topography=normal area=0.063 perim=1.14
MMIN1 B B_N VGND VNB nfet_01v8 m=1 w=0.42 l=0.15 mult=1 sa=0.265
+ sb=0.265 sd=0.28 topography=normal area=0.063 perim=1.14
MMIN2 X y VGND VNB nfet_01v8 m=4 w=0.65 l=0.15 mult=1 sa=0.265
+ sb=0.265 sd=0.28 topography=normal area=0.063 perim=1.14
.ENDS

.SUBCKT sky130_fd_sc_hd__or3_1 A B C VGND VNB VPB VPWR X
MMP0 VPWR A sndPA VPB pfet_01v8_hvt m=1 w=0.42 l=0.15 mult=1 sa=0.265
+ sb=0.265 sd=0.28 topography=normal area=0.063 perim=1.14
MMP1 sndPA B sndPB VPB pfet_01v8_hvt m=1 w=0.42 l=0.15 mult=1 sa=0.265
+ sb=0.265 sd=0.28 topography=normal area=0.063 perim=1.14
MMP2 sndPB C y VPB pfet_01v8_hvt m=1 w=0.42 l=0.15 mult=1 sa=0.265
+ sb=0.265 sd=0.28 topography=normal area=0.063 perim=1.14
MMIP3 X y VPWR VPB pfet_01v8_hvt m=1 w=1.0 l=0.15 mult=1 sa=0.265
+ sb=0.265 sd=0.28 topography=normal area=0.063 perim=1.14
MMN0 y A VGND VNB nfet_01v8 m=1 w=0.42 l=0.15 mult=1 sa=0.265 sb=0.265
+ sd=0.28 topography=normal area=0.063 perim=1.14
MMN1 y B VGND VNB nfet_01v8 m=1 w=0.42 l=0.15 mult=1 sa=0.265 sb=0.265
+ sd=0.28 topography=normal area=0.063 perim=1.14
MMN2 y C VGND VNB nfet_01v8 m=1 w=0.42 l=0.15 mult=1 sa=0.265 sb=0.265
+ sd=0.28 topography=normal area=0.063 perim=1.14
MMIN3 X y VGND VNB nfet_01v8 m=1 w=0.65 l=0.15 mult=1 sa=0.265
+ sb=0.265 sd=0.28 topography=normal area=0.063 perim=1.14
.ENDS

.SUBCKT sky130_fd_sc_hd__or3_2 A B C VGND VNB VPB VPWR X
MMP0 VPWR A sndPA VPB pfet_01v8_hvt m=1 w=0.42 l=0.15 mult=1 sa=0.265
+ sb=0.265 sd=0.28 topography=normal area=0.063 perim=1.14
MMP1 sndPA B sndPB VPB pfet_01v8_hvt m=1 w=0.42 l=0.15 mult=1 sa=0.265
+ sb=0.265 sd=0.28 topography=normal area=0.063 perim=1.14
MMP2 sndPB C y VPB pfet_01v8_hvt m=1 w=0.42 l=0.15 mult=1 sa=0.265
+ sb=0.265 sd=0.28 topography=normal area=0.063 perim=1.14
MMIP3 X y VPWR VPB pfet_01v8_hvt m=2 w=1.0 l=0.15 mult=1 sa=0.265
+ sb=0.265 sd=0.28 topography=normal area=0.063 perim=1.14
MMN0 y A VGND VNB nfet_01v8 m=1 w=0.42 l=0.15 mult=1 sa=0.265 sb=0.265
+ sd=0.28 topography=normal area=0.063 perim=1.14
MMN1 y B VGND VNB nfet_01v8 m=1 w=0.42 l=0.15 mult=1 sa=0.265 sb=0.265
+ sd=0.28 topography=normal area=0.063 perim=1.14
MMN2 y C VGND VNB nfet_01v8 m=1 w=0.42 l=0.15 mult=1 sa=0.265 sb=0.265
+ sd=0.28 topography=normal area=0.063 perim=1.14
MMIN3 X y VGND VNB nfet_01v8 m=2 w=0.65 l=0.15 mult=1 sa=0.265
+ sb=0.265 sd=0.28 topography=normal area=0.063 perim=1.14
.ENDS

.SUBCKT sky130_fd_sc_hd__or3_4 A B C VGND VNB VPB VPWR X
MMP0 VPWR A sndPA VPB pfet_01v8_hvt m=1 w=1.0 l=0.15 mult=1 sa=0.265
+ sb=0.265 sd=0.28 topography=normal area=0.063 perim=1.14
MMP1 sndPA B sndPB VPB pfet_01v8_hvt m=1 w=1.0 l=0.15 mult=1 sa=0.265
+ sb=0.265 sd=0.28 topography=normal area=0.063 perim=1.14
MMP2 sndPB C y VPB pfet_01v8_hvt m=1 w=1.0 l=0.15 mult=1 sa=0.265
+ sb=0.265 sd=0.28 topography=normal area=0.063 perim=1.14
MMIP3 X y VPWR VPB pfet_01v8_hvt m=4 w=1.0 l=0.15 mult=1 sa=0.265
+ sb=0.265 sd=0.28 topography=normal area=0.063 perim=1.14
MMN0 y A VGND VNB nfet_01v8 m=1 w=0.65 l=0.15 mult=1 sa=0.265 sb=0.265
+ sd=0.28 topography=normal area=0.063 perim=1.14
MMN1 y B VGND VNB nfet_01v8 m=1 w=0.65 l=0.15 mult=1 sa=0.265 sb=0.265
+ sd=0.28 topography=normal area=0.063 perim=1.14
MMN2 y C VGND VNB nfet_01v8 m=1 w=0.65 l=0.15 mult=1 sa=0.265 sb=0.265
+ sd=0.28 topography=normal area=0.063 perim=1.14
MMIN3 X y VGND VNB nfet_01v8 m=4 w=0.65 l=0.15 mult=1 sa=0.265
+ sb=0.265 sd=0.28 topography=normal area=0.063 perim=1.14
.ENDS

.SUBCKT sky130_fd_sc_hd__or3b_1 A B C_N VGND VNB VPB VPWR X
MMP0 VPWR A sndPA VPB pfet_01v8_hvt m=1 w=0.42 l=0.15 mult=1 sa=0.265
+ sb=0.265 sd=0.28 topography=normal area=0.063 perim=1.14
MMP1 sndPA B sndPB VPB pfet_01v8_hvt m=1 w=0.42 l=0.15 mult=1 sa=0.265
+ sb=0.265 sd=0.28 topography=normal area=0.063 perim=1.14
MMP2 sndPB C y VPB pfet_01v8_hvt m=1 w=0.42 l=0.15 mult=1 sa=0.265
+ sb=0.265 sd=0.28 topography=normal area=0.063 perim=1.14
MMIP2 C C_N VPWR VPB pfet_01v8_hvt m=1 w=0.42 l=0.15 mult=1 sa=0.265
+ sb=0.265 sd=0.28 topography=normal area=0.063 perim=1.14
MMIP3 X y VPWR VPB pfet_01v8_hvt m=1 w=1.0 l=0.15 mult=1 sa=0.265
+ sb=0.265 sd=0.28 topography=normal area=0.063 perim=1.14
MMN0 y A VGND VNB nfet_01v8 m=1 w=0.42 l=0.15 mult=1 sa=0.265 sb=0.265
+ sd=0.28 topography=normal area=0.063 perim=1.14
MMN1 y B VGND VNB nfet_01v8 m=1 w=0.42 l=0.15 mult=1 sa=0.265 sb=0.265
+ sd=0.28 topography=normal area=0.063 perim=1.14
MMN2 y C VGND VNB nfet_01v8 m=1 w=0.42 l=0.15 mult=1 sa=0.265 sb=0.265
+ sd=0.28 topography=normal area=0.063 perim=1.14
MMIN2 C C_N VGND VNB nfet_01v8 m=1 w=0.42 l=0.15 mult=1 sa=0.265
+ sb=0.265 sd=0.28 topography=normal area=0.063 perim=1.14
MMIN3 X y VGND VNB nfet_01v8 m=1 w=0.65 l=0.15 mult=1 sa=0.265
+ sb=0.265 sd=0.28 topography=normal area=0.063 perim=1.14
.ENDS

.SUBCKT sky130_fd_sc_hd__or3b_2 A B C_N VGND VNB VPB VPWR X
MMP0 VPWR A sndPA VPB pfet_01v8_hvt m=1 w=0.42 l=0.15 mult=1 sa=0.265
+ sb=0.265 sd=0.28 topography=normal area=0.063 perim=1.14
MMP1 sndPA B sndPB VPB pfet_01v8_hvt m=1 w=0.42 l=0.15 mult=1 sa=0.265
+ sb=0.265 sd=0.28 topography=normal area=0.063 perim=1.14
MMP2 sndPB C y VPB pfet_01v8_hvt m=1 w=0.42 l=0.15 mult=1 sa=0.265
+ sb=0.265 sd=0.28 topography=normal area=0.063 perim=1.14
MMIP2 C C_N VPWR VPB pfet_01v8_hvt m=1 w=0.42 l=0.15 mult=1 sa=0.265
+ sb=0.265 sd=0.28 topography=normal area=0.063 perim=1.14
MMIP3 X y VPWR VPB pfet_01v8_hvt m=2 w=1.0 l=0.15 mult=1 sa=0.265
+ sb=0.265 sd=0.28 topography=normal area=0.063 perim=1.14
MMN0 y A VGND VNB nfet_01v8 m=1 w=0.42 l=0.15 mult=1 sa=0.265 sb=0.265
+ sd=0.28 topography=normal area=0.063 perim=1.14
MMN1 y B VGND VNB nfet_01v8 m=1 w=0.42 l=0.15 mult=1 sa=0.265 sb=0.265
+ sd=0.28 topography=normal area=0.063 perim=1.14
MMN2 y C VGND VNB nfet_01v8 m=1 w=0.42 l=0.15 mult=1 sa=0.265 sb=0.265
+ sd=0.28 topography=normal area=0.063 perim=1.14
MMIN2 C C_N VGND VNB nfet_01v8 m=1 w=0.42 l=0.15 mult=1 sa=0.265
+ sb=0.265 sd=0.28 topography=normal area=0.063 perim=1.14
MMIN3 X y VGND VNB nfet_01v8 m=2 w=0.65 l=0.15 mult=1 sa=0.265
+ sb=0.265 sd=0.28 topography=normal area=0.063 perim=1.14
.ENDS

.SUBCKT sky130_fd_sc_hd__or3b_4 A B C_N VGND VNB VPB VPWR X
MMP0 VPWR A sndPA VPB pfet_01v8_hvt m=1 w=1.0 l=0.15 mult=1 sa=0.265
+ sb=0.265 sd=0.28 topography=normal area=0.063 perim=1.14
MMP1 sndPA B sndPB VPB pfet_01v8_hvt m=1 w=1.0 l=0.15 mult=1 sa=0.265
+ sb=0.265 sd=0.28 topography=normal area=0.063 perim=1.14
MMP2 sndPB C y VPB pfet_01v8_hvt m=1 w=1.0 l=0.15 mult=1 sa=0.265
+ sb=0.265 sd=0.28 topography=normal area=0.063 perim=1.14
MMIP2 C C_N VPWR VPB pfet_01v8_hvt m=1 w=0.42 l=0.15 mult=1 sa=0.265
+ sb=0.265 sd=0.28 topography=normal area=0.063 perim=1.14
MMIP3 X y VPWR VPB pfet_01v8_hvt m=4 w=1.0 l=0.15 mult=1 sa=0.265
+ sb=0.265 sd=0.28 topography=normal area=0.063 perim=1.14
MMN0 y A VGND VNB nfet_01v8 m=1 w=0.65 l=0.15 mult=1 sa=0.265 sb=0.265
+ sd=0.28 topography=normal area=0.063 perim=1.14
MMN1 y B VGND VNB nfet_01v8 m=1 w=0.65 l=0.15 mult=1 sa=0.265 sb=0.265
+ sd=0.28 topography=normal area=0.063 perim=1.14
MMN2 y C VGND VNB nfet_01v8 m=1 w=0.65 l=0.15 mult=1 sa=0.265 sb=0.265
+ sd=0.28 topography=normal area=0.063 perim=1.14
MMIN2 C C_N VGND VNB nfet_01v8 m=1 w=0.42 l=0.15 mult=1 sa=0.265
+ sb=0.265 sd=0.28 topography=normal area=0.063 perim=1.14
MMIN3 X y VGND VNB nfet_01v8 m=4 w=0.65 l=0.15 mult=1 sa=0.265
+ sb=0.265 sd=0.28 topography=normal area=0.063 perim=1.14
.ENDS

.SUBCKT sky130_fd_sc_hd__or4_1 A B C D VGND VNB VPB VPWR X
MMP0 VPWR A sndPA VPB pfet_01v8_hvt m=1 w=0.42 l=0.15 mult=1 sa=0.265
+ sb=0.265 sd=0.28 topography=normal area=0.063 perim=1.14
MMP1 sndPA B sndPB VPB pfet_01v8_hvt m=1 w=0.42 l=0.15 mult=1 sa=0.265
+ sb=0.265 sd=0.28 topography=normal area=0.063 perim=1.14
MMP2 sndPB C sndPC VPB pfet_01v8_hvt m=1 w=0.42 l=0.15 mult=1 sa=0.265
+ sb=0.265 sd=0.28 topography=normal area=0.063 perim=1.14
MMP3 sndPC D y VPB pfet_01v8_hvt m=1 w=0.42 l=0.15 mult=1 sa=0.265
+ sb=0.265 sd=0.28 topography=normal area=0.063 perim=1.14
MMIP4 X y VPWR VPB pfet_01v8_hvt m=1 w=1.0 l=0.15 mult=1 sa=0.265
+ sb=0.265 sd=0.28 topography=normal area=0.063 perim=1.14
MMN0 y A VGND VNB nfet_01v8 m=1 w=0.42 l=0.15 mult=1 sa=0.265 sb=0.265
+ sd=0.28 topography=normal area=0.063 perim=1.14
MMN1 y B VGND VNB nfet_01v8 m=1 w=0.42 l=0.15 mult=1 sa=0.265 sb=0.265
+ sd=0.28 topography=normal area=0.063 perim=1.14
MMN2 y C VGND VNB nfet_01v8 m=1 w=0.42 l=0.15 mult=1 sa=0.265 sb=0.265
+ sd=0.28 topography=normal area=0.063 perim=1.14
MMN3 y D VGND VNB nfet_01v8 m=1 w=0.42 l=0.15 mult=1 sa=0.265 sb=0.265
+ sd=0.28 topography=normal area=0.063 perim=1.14
MMIN4 X y VGND VNB nfet_01v8 m=1 w=0.65 l=0.15 mult=1 sa=0.265
+ sb=0.265 sd=0.28 topography=normal area=0.063 perim=1.14
.ENDS

.SUBCKT sky130_fd_sc_hd__or4_2 A B C D VGND VNB VPB VPWR X
MMP0 VPWR A sndPA VPB pfet_01v8_hvt m=1 w=0.42 l=0.15 mult=1 sa=0.265
+ sb=0.265 sd=0.28 topography=normal area=0.063 perim=1.14
MMP1 sndPA B sndPB VPB pfet_01v8_hvt m=1 w=0.42 l=0.15 mult=1 sa=0.265
+ sb=0.265 sd=0.28 topography=normal area=0.063 perim=1.14
MMP2 sndPB C sndPC VPB pfet_01v8_hvt m=1 w=0.42 l=0.15 mult=1 sa=0.265
+ sb=0.265 sd=0.28 topography=normal area=0.063 perim=1.14
MMP3 sndPC D y VPB pfet_01v8_hvt m=1 w=0.42 l=0.15 mult=1 sa=0.265
+ sb=0.265 sd=0.28 topography=normal area=0.063 perim=1.14
MMIP4 X y VPWR VPB pfet_01v8_hvt m=2 w=1.0 l=0.15 mult=1 sa=0.265
+ sb=0.265 sd=0.28 topography=normal area=0.063 perim=1.14
MMN0 y A VGND VNB nfet_01v8 m=1 w=0.42 l=0.15 mult=1 sa=0.265 sb=0.265
+ sd=0.28 topography=normal area=0.063 perim=1.14
MMN1 y B VGND VNB nfet_01v8 m=1 w=0.42 l=0.15 mult=1 sa=0.265 sb=0.265
+ sd=0.28 topography=normal area=0.063 perim=1.14
MMN2 y C VGND VNB nfet_01v8 m=1 w=0.42 l=0.15 mult=1 sa=0.265 sb=0.265
+ sd=0.28 topography=normal area=0.063 perim=1.14
MMN3 y D VGND VNB nfet_01v8 m=1 w=0.42 l=0.15 mult=1 sa=0.265 sb=0.265
+ sd=0.28 topography=normal area=0.063 perim=1.14
MMIN4 X y VGND VNB nfet_01v8 m=2 w=0.65 l=0.15 mult=1 sa=0.265
+ sb=0.265 sd=0.28 topography=normal area=0.063 perim=1.14
.ENDS

.SUBCKT sky130_fd_sc_hd__or4_4 A B C D VGND VNB VPB VPWR X
MMP0 VPWR A sndPA VPB pfet_01v8_hvt m=1 w=1.0 l=0.15 mult=1 sa=0.265
+ sb=0.265 sd=0.28 topography=normal area=0.063 perim=1.14
MMP1 sndPA B sndPB VPB pfet_01v8_hvt m=1 w=1.0 l=0.15 mult=1 sa=0.265
+ sb=0.265 sd=0.28 topography=normal area=0.063 perim=1.14
MMP2 sndPB C sndPC VPB pfet_01v8_hvt m=1 w=1.0 l=0.15 mult=1 sa=0.265
+ sb=0.265 sd=0.28 topography=normal area=0.063 perim=1.14
MMP3 sndPC D y VPB pfet_01v8_hvt m=1 w=1.0 l=0.15 mult=1 sa=0.265
+ sb=0.265 sd=0.28 topography=normal area=0.063 perim=1.14
MMIP4 X y VPWR VPB pfet_01v8_hvt m=4 w=1.0 l=0.15 mult=1 sa=0.265
+ sb=0.265 sd=0.28 topography=normal area=0.063 perim=1.14
MMN0 y A VGND VNB nfet_01v8 m=1 w=0.65 l=0.15 mult=1 sa=0.265 sb=0.265
+ sd=0.28 topography=normal area=0.063 perim=1.14
MMN1 y B VGND VNB nfet_01v8 m=1 w=0.65 l=0.15 mult=1 sa=0.265 sb=0.265
+ sd=0.28 topography=normal area=0.063 perim=1.14
MMN2 y C VGND VNB nfet_01v8 m=1 w=0.65 l=0.15 mult=1 sa=0.265 sb=0.265
+ sd=0.28 topography=normal area=0.063 perim=1.14
MMN3 y D VGND VNB nfet_01v8 m=1 w=0.65 l=0.15 mult=1 sa=0.265 sb=0.265
+ sd=0.28 topography=normal area=0.063 perim=1.14
MMIN4 X y VGND VNB nfet_01v8 m=4 w=0.65 l=0.15 mult=1 sa=0.265
+ sb=0.265 sd=0.28 topography=normal area=0.063 perim=1.14
.ENDS

.SUBCKT sky130_fd_sc_hd__or4b_1 A B C D_N VGND VNB VPB VPWR X
MMP0 VPWR A sndPA VPB pfet_01v8_hvt m=1 w=0.42 l=0.15 mult=1 sa=0.265
+ sb=0.265 sd=0.28 topography=normal area=0.063 perim=1.14
MMP1 sndPA B sndPB VPB pfet_01v8_hvt m=1 w=0.42 l=0.15 mult=1 sa=0.265
+ sb=0.265 sd=0.28 topography=normal area=0.063 perim=1.14
MMP2 sndPB C sndPC VPB pfet_01v8_hvt m=1 w=0.42 l=0.15 mult=1 sa=0.265
+ sb=0.265 sd=0.28 topography=normal area=0.063 perim=1.14
MMP3 sndPC D y VPB pfet_01v8_hvt m=1 w=0.42 l=0.15 mult=1 sa=0.265
+ sb=0.265 sd=0.28 topography=normal area=0.063 perim=1.14
MMIP3 D D_N VPWR VPB pfet_01v8_hvt m=1 w=0.42 l=0.15 mult=1 sa=0.265
+ sb=0.265 sd=0.28 topography=normal area=0.063 perim=1.14
MMIP4 X y VPWR VPB pfet_01v8_hvt m=1 w=1.0 l=0.15 mult=1 sa=0.265
+ sb=0.265 sd=0.28 topography=normal area=0.063 perim=1.14
MMN0 y A VGND VNB nfet_01v8 m=1 w=0.42 l=0.15 mult=1 sa=0.265 sb=0.265
+ sd=0.28 topography=normal area=0.063 perim=1.14
MMN1 y B VGND VNB nfet_01v8 m=1 w=0.42 l=0.15 mult=1 sa=0.265 sb=0.265
+ sd=0.28 topography=normal area=0.063 perim=1.14
MMN2 y C VGND VNB nfet_01v8 m=1 w=0.42 l=0.15 mult=1 sa=0.265 sb=0.265
+ sd=0.28 topography=normal area=0.063 perim=1.14
MMN3 y D VGND VNB nfet_01v8 m=1 w=0.42 l=0.15 mult=1 sa=0.265 sb=0.265
+ sd=0.28 topography=normal area=0.063 perim=1.14
MMIN3 D D_N VGND VNB nfet_01v8 m=1 w=0.42 l=0.15 mult=1 sa=0.265
+ sb=0.265 sd=0.28 topography=normal area=0.063 perim=1.14
MMIN4 X y VGND VNB nfet_01v8 m=1 w=0.65 l=0.15 mult=1 sa=0.265
+ sb=0.265 sd=0.28 topography=normal area=0.063 perim=1.14
.ENDS

.SUBCKT sky130_fd_sc_hd__or4b_2 A B C D_N VGND VNB VPB VPWR X
MMP0 VPWR A sndPA VPB pfet_01v8_hvt m=1 w=0.42 l=0.15 mult=1 sa=0.265
+ sb=0.265 sd=0.28 topography=normal area=0.063 perim=1.14
MMP1 sndPA B sndPB VPB pfet_01v8_hvt m=1 w=0.42 l=0.15 mult=1 sa=0.265
+ sb=0.265 sd=0.28 topography=normal area=0.063 perim=1.14
MMP2 sndPB C sndPC VPB pfet_01v8_hvt m=1 w=0.42 l=0.15 mult=1 sa=0.265
+ sb=0.265 sd=0.28 topography=normal area=0.063 perim=1.14
MMP3 sndPC D y VPB pfet_01v8_hvt m=1 w=0.42 l=0.15 mult=1 sa=0.265
+ sb=0.265 sd=0.28 topography=normal area=0.063 perim=1.14
MMIP3 D D_N VPWR VPB pfet_01v8_hvt m=1 w=0.42 l=0.15 mult=1 sa=0.265
+ sb=0.265 sd=0.28 topography=normal area=0.063 perim=1.14
MMIP4 X y VPWR VPB pfet_01v8_hvt m=2 w=1.0 l=0.15 mult=1 sa=0.265
+ sb=0.265 sd=0.28 topography=normal area=0.063 perim=1.14
MMN0 y A VGND VNB nfet_01v8 m=1 w=0.42 l=0.15 mult=1 sa=0.265 sb=0.265
+ sd=0.28 topography=normal area=0.063 perim=1.14
MMN1 y B VGND VNB nfet_01v8 m=1 w=0.42 l=0.15 mult=1 sa=0.265 sb=0.265
+ sd=0.28 topography=normal area=0.063 perim=1.14
MMN2 y C VGND VNB nfet_01v8 m=1 w=0.42 l=0.15 mult=1 sa=0.265 sb=0.265
+ sd=0.28 topography=normal area=0.063 perim=1.14
MMN3 y D VGND VNB nfet_01v8 m=1 w=0.42 l=0.15 mult=1 sa=0.265 sb=0.265
+ sd=0.28 topography=normal area=0.063 perim=1.14
MMIN3 D D_N VGND VNB nfet_01v8 m=1 w=0.42 l=0.15 mult=1 sa=0.265
+ sb=0.265 sd=0.28 topography=normal area=0.063 perim=1.14
MMIN4 X y VGND VNB nfet_01v8 m=2 w=0.65 l=0.15 mult=1 sa=0.265
+ sb=0.265 sd=0.28 topography=normal area=0.063 perim=1.14
.ENDS

.SUBCKT sky130_fd_sc_hd__or4b_4 A B C D_N VGND VNB VPB VPWR X
MMP0 VPWR A sndPA VPB pfet_01v8_hvt m=1 w=1.0 l=0.15 mult=1 sa=0.265
+ sb=0.265 sd=0.28 topography=normal area=0.063 perim=1.14
MMP1 sndPA B sndPB VPB pfet_01v8_hvt m=1 w=1.0 l=0.15 mult=1 sa=0.265
+ sb=0.265 sd=0.28 topography=normal area=0.063 perim=1.14
MMP2 sndPB C sndPC VPB pfet_01v8_hvt m=1 w=1.0 l=0.15 mult=1 sa=0.265
+ sb=0.265 sd=0.28 topography=normal area=0.063 perim=1.14
MMP3 sndPC D y VPB pfet_01v8_hvt m=1 w=1.0 l=0.15 mult=1 sa=0.265
+ sb=0.265 sd=0.28 topography=normal area=0.063 perim=1.14
MMIP3 D D_N VPWR VPB pfet_01v8_hvt m=1 w=0.42 l=0.15 mult=1 sa=0.265
+ sb=0.265 sd=0.28 topography=normal area=0.063 perim=1.14
MMIP4 X y VPWR VPB pfet_01v8_hvt m=4 w=1.0 l=0.15 mult=1 sa=0.265
+ sb=0.265 sd=0.28 topography=normal area=0.063 perim=1.14
MMN0 y A VGND VNB nfet_01v8 m=1 w=0.65 l=0.15 mult=1 sa=0.265 sb=0.265
+ sd=0.28 topography=normal area=0.063 perim=1.14
MMN1 y B VGND VNB nfet_01v8 m=1 w=0.65 l=0.15 mult=1 sa=0.265 sb=0.265
+ sd=0.28 topography=normal area=0.063 perim=1.14
MMN2 y C VGND VNB nfet_01v8 m=1 w=0.65 l=0.15 mult=1 sa=0.265 sb=0.265
+ sd=0.28 topography=normal area=0.063 perim=1.14
MMN3 y D VGND VNB nfet_01v8 m=1 w=0.65 l=0.15 mult=1 sa=0.265 sb=0.265
+ sd=0.28 topography=normal area=0.063 perim=1.14
MMIN3 D D_N VGND VNB nfet_01v8 m=1 w=0.42 l=0.15 mult=1 sa=0.265
+ sb=0.265 sd=0.28 topography=normal area=0.063 perim=1.14
MMIN4 X y VGND VNB nfet_01v8 m=4 w=0.65 l=0.15 mult=1 sa=0.265
+ sb=0.265 sd=0.28 topography=normal area=0.063 perim=1.14
.ENDS

.SUBCKT sky130_fd_sc_hd__or4bb_1 A B C_N D_N VGND VNB VPB VPWR X
MMP0 VPWR A sndPA VPB pfet_01v8_hvt m=1 w=0.42 l=0.15 mult=1 sa=0.265
+ sb=0.265 sd=0.28 topography=normal area=0.063 perim=1.14
MMP1 sndPA B sndPB VPB pfet_01v8_hvt m=1 w=0.42 l=0.15 mult=1 sa=0.265
+ sb=0.265 sd=0.28 topography=normal area=0.063 perim=1.14
MMP2 sndPB C sndPC VPB pfet_01v8_hvt m=1 w=0.42 l=0.15 mult=1 sa=0.265
+ sb=0.265 sd=0.28 topography=normal area=0.063 perim=1.14
MMP3 sndPC D y VPB pfet_01v8_hvt m=1 w=0.42 l=0.15 mult=1 sa=0.265
+ sb=0.265 sd=0.28 topography=normal area=0.063 perim=1.14
MMIP2 C C_N VPWR VPB pfet_01v8_hvt m=1 w=0.42 l=0.15 mult=1 sa=0.265
+ sb=0.265 sd=0.28 topography=normal area=0.063 perim=1.14
MMIP3 D D_N VPWR VPB pfet_01v8_hvt m=1 w=0.42 l=0.15 mult=1 sa=0.265
+ sb=0.265 sd=0.28 topography=normal area=0.063 perim=1.14
MMIP4 X y VPWR VPB pfet_01v8_hvt m=1 w=1.0 l=0.15 mult=1 sa=0.265
+ sb=0.265 sd=0.28 topography=normal area=0.063 perim=1.14
MMN0 y A VGND VNB nfet_01v8 m=1 w=0.42 l=0.15 mult=1 sa=0.265 sb=0.265
+ sd=0.28 topography=normal area=0.063 perim=1.14
MMN1 y B VGND VNB nfet_01v8 m=1 w=0.42 l=0.15 mult=1 sa=0.265 sb=0.265
+ sd=0.28 topography=normal area=0.063 perim=1.14
MMN2 y C VGND VNB nfet_01v8 m=1 w=0.42 l=0.15 mult=1 sa=0.265 sb=0.265
+ sd=0.28 topography=normal area=0.063 perim=1.14
MMN3 y D VGND VNB nfet_01v8 m=1 w=0.42 l=0.15 mult=1 sa=0.265 sb=0.265
+ sd=0.28 topography=normal area=0.063 perim=1.14
MMIN2 C C_N VGND VNB nfet_01v8 m=1 w=0.42 l=0.15 mult=1 sa=0.265
+ sb=0.265 sd=0.28 topography=normal area=0.063 perim=1.14
MMIN3 D D_N VGND VNB nfet_01v8 m=1 w=0.42 l=0.15 mult=1 sa=0.265
+ sb=0.265 sd=0.28 topography=normal area=0.063 perim=1.14
MMIN4 X y VGND VNB nfet_01v8 m=1 w=0.65 l=0.15 mult=1 sa=0.265
+ sb=0.265 sd=0.28 topography=normal area=0.063 perim=1.14
.ENDS

.SUBCKT sky130_fd_sc_hd__or4bb_2 A B C_N D_N VGND VNB VPB VPWR X
MMP0 VPWR A sndPA VPB pfet_01v8_hvt m=1 w=0.42 l=0.15 mult=1 sa=0.265
+ sb=0.265 sd=0.28 topography=normal area=0.063 perim=1.14
MMP1 sndPA B sndPB VPB pfet_01v8_hvt m=1 w=0.42 l=0.15 mult=1 sa=0.265
+ sb=0.265 sd=0.28 topography=normal area=0.063 perim=1.14
MMP2 sndPB C sndPC VPB pfet_01v8_hvt m=1 w=0.42 l=0.15 mult=1 sa=0.265
+ sb=0.265 sd=0.28 topography=normal area=0.063 perim=1.14
MMP3 sndPC D y VPB pfet_01v8_hvt m=1 w=0.42 l=0.15 mult=1 sa=0.265
+ sb=0.265 sd=0.28 topography=normal area=0.063 perim=1.14
MMIP2 C C_N VPWR VPB pfet_01v8_hvt m=1 w=0.42 l=0.15 mult=1 sa=0.265
+ sb=0.265 sd=0.28 topography=normal area=0.063 perim=1.14
MMIP3 D D_N VPWR VPB pfet_01v8_hvt m=1 w=0.42 l=0.15 mult=1 sa=0.265
+ sb=0.265 sd=0.28 topography=normal area=0.063 perim=1.14
MMIP4 X y VPWR VPB pfet_01v8_hvt m=2 w=1.0 l=0.15 mult=1 sa=0.265
+ sb=0.265 sd=0.28 topography=normal area=0.063 perim=1.14
MMN0 y A VGND VNB nfet_01v8 m=1 w=0.42 l=0.15 mult=1 sa=0.265 sb=0.265
+ sd=0.28 topography=normal area=0.063 perim=1.14
MMN1 y B VGND VNB nfet_01v8 m=1 w=0.42 l=0.15 mult=1 sa=0.265 sb=0.265
+ sd=0.28 topography=normal area=0.063 perim=1.14
MMN2 y C VGND VNB nfet_01v8 m=1 w=0.42 l=0.15 mult=1 sa=0.265 sb=0.265
+ sd=0.28 topography=normal area=0.063 perim=1.14
MMN3 y D VGND VNB nfet_01v8 m=1 w=0.42 l=0.15 mult=1 sa=0.265 sb=0.265
+ sd=0.28 topography=normal area=0.063 perim=1.14
MMIN2 C C_N VGND VNB nfet_01v8 m=1 w=0.42 l=0.15 mult=1 sa=0.265
+ sb=0.265 sd=0.28 topography=normal area=0.063 perim=1.14
MMIN3 D D_N VGND VNB nfet_01v8 m=1 w=0.42 l=0.15 mult=1 sa=0.265
+ sb=0.265 sd=0.28 topography=normal area=0.063 perim=1.14
MMIN4 X y VGND VNB nfet_01v8 m=2 w=0.65 l=0.15 mult=1 sa=0.265
+ sb=0.265 sd=0.28 topography=normal area=0.063 perim=1.14
.ENDS

.SUBCKT sky130_fd_sc_hd__or4bb_4 A B C_N D_N VGND VNB VPB VPWR X
MMP0 VPWR A sndPA VPB pfet_01v8_hvt m=1 w=1.0 l=0.15 mult=1 sa=0.265
+ sb=0.265 sd=0.28 topography=normal area=0.063 perim=1.14
MMP1 sndPA B sndPB VPB pfet_01v8_hvt m=1 w=1.0 l=0.15 mult=1 sa=0.265
+ sb=0.265 sd=0.28 topography=normal area=0.063 perim=1.14
MMP2 sndPB C sndPC VPB pfet_01v8_hvt m=1 w=1.0 l=0.15 mult=1 sa=0.265
+ sb=0.265 sd=0.28 topography=normal area=0.063 perim=1.14
MMP3 sndPC D y VPB pfet_01v8_hvt m=1 w=1.0 l=0.15 mult=1 sa=0.265
+ sb=0.265 sd=0.28 topography=normal area=0.063 perim=1.14
MMIP2 C C_N VPWR VPB pfet_01v8_hvt m=1 w=0.42 l=0.15 mult=1 sa=0.265
+ sb=0.265 sd=0.28 topography=normal area=0.063 perim=1.14
MMIP3 D D_N VPWR VPB pfet_01v8_hvt m=1 w=0.42 l=0.15 mult=1 sa=0.265
+ sb=0.265 sd=0.28 topography=normal area=0.063 perim=1.14
MMIP4 X y VPWR VPB pfet_01v8_hvt m=4 w=1.0 l=0.15 mult=1 sa=0.265
+ sb=0.265 sd=0.28 topography=normal area=0.063 perim=1.14
MMN0 y A VGND VNB nfet_01v8 m=1 w=0.65 l=0.15 mult=1 sa=0.265 sb=0.265
+ sd=0.28 topography=normal area=0.063 perim=1.14
MMN1 y B VGND VNB nfet_01v8 m=1 w=0.65 l=0.15 mult=1 sa=0.265 sb=0.265
+ sd=0.28 topography=normal area=0.063 perim=1.14
MMN2 y C VGND VNB nfet_01v8 m=1 w=0.65 l=0.15 mult=1 sa=0.265 sb=0.265
+ sd=0.28 topography=normal area=0.063 perim=1.14
MMN3 y D VGND VNB nfet_01v8 m=1 w=0.65 l=0.15 mult=1 sa=0.265 sb=0.265
+ sd=0.28 topography=normal area=0.063 perim=1.14
MMIN2 C C_N VGND VNB nfet_01v8 m=1 w=0.42 l=0.15 mult=1 sa=0.265
+ sb=0.265 sd=0.28 topography=normal area=0.063 perim=1.14
MMIN3 D D_N VGND VNB nfet_01v8 m=1 w=0.42 l=0.15 mult=1 sa=0.265
+ sb=0.265 sd=0.28 topography=normal area=0.063 perim=1.14
MMIN4 X y VGND VNB nfet_01v8 m=4 w=0.65 l=0.15 mult=1 sa=0.265
+ sb=0.265 sd=0.28 topography=normal area=0.063 perim=1.14
.ENDS

.SUBCKT sky130_fd_sc_hd__probe_p_8 A VGND VNB VPB VPWR X
MMIP1 Ab A VPWR VPB pfet_01v8_hvt m=3 w=1.0 l=0.15 mult=1 sa=0.265
+ sb=0.265 sd=0.28 topography=normal area=0.063 perim=1.14
MMIP2 net29 Ab VPWR VPB pfet_01v8_hvt m=8 w=1.0 l=0.15 mult=1 sa=0.265
+ sb=0.265 sd=0.28 topography=normal area=0.063 perim=1.14
MMIN1 Ab A VGND VNB nfet_01v8 m=3 w=0.65 l=0.15 mult=1 sa=0.265
+ sb=0.265 sd=0.28 topography=normal area=0.063 perim=1.14
MMIN2 net29 Ab VGND VNB nfet_01v8 m=8 w=0.65 l=0.15 mult=1 sa=0.265
+ sb=0.265 sd=0.28 topography=normal area=0.063 perim=1.14
rI112 net29 X sky130_fd_pr__res_generic_m5
.ENDS

.SUBCKT sky130_fd_sc_hd__probec_p_8 A VGND VNB VPB VPWR X
MMIP1 Ab A VPWR VPB pfet_01v8_hvt m=3 w=1.0 l=0.15 mult=1 sa=0.265
+ sb=0.265 sd=0.28 topography=normal area=0.063 perim=1.14
MMIP2 net33 Ab VPWR VPB pfet_01v8_hvt m=8 w=1.0 l=0.15 mult=1 sa=0.265
+ sb=0.265 sd=0.28 topography=normal area=0.063 perim=1.14
MMIN1 Ab A VGND VNB nfet_01v8 m=3 w=0.65 l=0.15 mult=1 sa=0.265
+ sb=0.265 sd=0.28 topography=normal area=0.063 perim=1.14
MMIN2 net33 Ab VGND VNB nfet_01v8 m=8 w=0.65 l=0.15 mult=1 sa=0.265
+ sb=0.265 sd=0.28 topography=normal area=0.063 perim=1.14
rI112 net33 X short
rI120 VGND met5vgnd short
rI119 VPWR met5vpwr short
.ENDS

.SUBCKT sky130_fd_sc_hd__sdfbbn_1 CLK_N D RESET_B SCD SCE SET_B VGND VNB VPB VPWR Q Q_N
MI98 net105 D n0 VNB nfet_01v8 m=1 w=0.42 l=0.15 mult=1 sa=0.265
+ sb=0.265 sd=0.28 topography=normal area=0.525 perim=3.1
MI103 n1 SCD VGND VNB nfet_01v8 m=1 w=0.42 l=0.15 mult=1 sa=0.265
+ sb=0.265 sd=0.28 topography=normal area=0.525 perim=3.1
MI104 n0 sceb VGND VNB nfet_01v8 m=1 w=0.42 l=0.15 mult=1 sa=0.265
+ sb=0.265 sd=0.28 topography=normal area=0.525 perim=3.1
MI120 net105 SCE n1 VNB nfet_01v8 m=1 w=0.42 l=0.15 mult=1 sa=0.265
+ sb=0.265 sd=0.28 topography=normal area=0.525 perim=3.1
MI46 clkneg clkpos VGND VNB nfet_01v8 m=1 w=0.42 l=0.15 mult=1
+ sa=0.265 sb=0.265 sd=0.28 topography=normal area=0.063 perim=1.14
MI642 RESET RESET_B VGND VNB nfet_01v8 m=1 w=0.42 l=0.15 mult=1
+ sa=0.265 sb=0.265 sd=0.28 topography=normal area=0.063 perim=1.14
MI676 M1 M0 net176 VNB nfet_01v8 m=1 w=0.64 l=0.15 mult=1 sa=0.265
+ sb=0.265 sd=0.28 topography=normal area=0.063 perim=1.14
MI675 net176 SET_B VGND VNB nfet_01v8 m=1 w=0.42 l=0.15 mult=1
+ sa=0.265 sb=0.265 sd=0.28 topography=normal area=0.063 perim=1.14
MI653 Q net213 VGND VNB nfet_01v8 m=1 w=0.65 l=0.15 mult=1 sa=0.265
+ sb=0.265 sd=0.28 topography=normal area=0.063 perim=1.14
MI677 M1 RESET net176 VNB nfet_01v8 m=1 w=0.64 l=0.15 mult=1 sa=0.265
+ sb=0.265 sd=0.28 topography=normal area=0.063 perim=1.14
MI648 M0 clkpos net153 VNB nfet_01v8 m=1 w=0.36 l=0.15 mult=1 sa=0.265
+ sb=0.265 sd=0.28 topography=normal area=0.063 perim=1.14
MI44 clkpos CLK_N VGND VNB nfet_01v8 m=1 w=0.42 l=0.15 mult=1 sa=0.265
+ sb=0.265 sd=0.28 topography=normal area=0.063 perim=1.14
MI649 net153 M1 VGND VNB nfet_01v8 m=1 w=0.42 l=0.15 mult=1 sa=0.265
+ sb=0.265 sd=0.28 topography=normal area=0.063 perim=1.14
MI655 S0 clkneg net145 VNB nfet_01v8 m=1 w=0.36 l=0.15 mult=1 sa=0.265
+ sb=0.265 sd=0.28 topography=normal area=0.063 perim=1.14
MI654 net145 net117 VGND VNB nfet_01v8 m=1 w=0.42 l=0.15 mult=1
+ sa=0.265 sb=0.265 sd=0.28 topography=normal area=0.063 perim=1.14
MI651 Q_N net117 VGND VNB nfet_01v8 m=1 w=0.65 l=0.15 mult=1 sa=0.265
+ sb=0.265 sd=0.28 topography=normal area=0.063 perim=1.14
MI652 net213 net117 VGND VNB nfet_01v8 m=1 w=0.42 l=0.15 mult=1
+ sa=0.265 sb=0.265 sd=0.28 topography=normal area=0.063 perim=1.14
MI42 net105 clkneg M0 VNB nfet_01v8 m=1 w=0.36 l=0.15 mult=1 sa=0.265
+ sb=0.265 sd=0.28 topography=normal area=0.063 perim=1.14
MI668 S0 clkpos net125 VNB nfet_01v8 m=1 w=0.36 l=0.15 mult=1 sa=0.265
+ sb=0.265 sd=0.28 topography=normal area=0.063 perim=1.14
MI667 net125 M1 VGND VNB nfet_01v8 m=1 w=0.64 l=0.15 mult=1 sa=0.265
+ sb=0.265 sd=0.28 topography=normal area=0.063 perim=1.14
MI630 net117 RESET net116 VNB nfet_01v8 m=1 w=0.64 l=0.15 mult=1
+ sa=0.265 sb=0.265 sd=0.28 topography=normal area=0.063 perim=1.14
MI3 net117 S0 net116 VNB nfet_01v8 m=1 w=0.64 l=0.15 mult=1 sa=0.265
+ sb=0.265 sd=0.28 topography=normal area=0.063 perim=1.14
MI7 net116 SET_B VGND VNB nfet_01v8 m=1 w=0.42 l=0.15 mult=1 sa=0.265
+ sb=0.265 sd=0.28 topography=normal area=0.063 perim=1.14
MI639 sceb SCE VGND VNB nfet_01v8 m=1 w=0.42 l=0.15 mult=1 sa=0.265
+ sb=0.265 sd=0.28 topography=normal area=0.063 perim=1.14
MI107 p0 SCE VPWR VPB pfet_01v8_hvt m=1 w=0.42 l=0.15 mult=1 sa=0.265
+ sb=0.265 sd=0.28 topography=normal area=0.063 perim=1.14
MI94 net105 D p0 VPB pfet_01v8_hvt m=1 w=0.42 l=0.15 mult=1 sa=0.265
+ sb=0.265 sd=0.28 topography=normal area=0.063 perim=1.14
MI101 net105 sceb p1 VPB pfet_01v8_hvt m=1 w=0.64 l=0.15 mult=1
+ sa=0.265 sb=0.265 sd=0.28 topography=normal area=0.063 perim=1.14
MI108 p1 SCD VPWR VPB pfet_01v8_hvt m=1 w=0.64 l=0.15 mult=1 sa=0.265
+ sb=0.265 sd=0.28 topography=normal area=0.063 perim=1.14
MI679 M1 SET_B VPWR VPB pfet_01v8_hvt m=1 w=0.42 l=0.15 mult=1
+ sa=0.265 sb=0.265 sd=0.28 topography=normal area=0.063 perim=1.14
MI669 S0 clkneg net265 VPB pfet_01v8_hvt m=1 w=0.42 l=0.15 mult=1
+ sa=0.265 sb=0.265 sd=0.28 topography=normal area=0.063 perim=1.14
MI660 Q net213 VPWR VPB pfet_01v8_hvt m=1 w=1.0 l=0.15 mult=1 sa=0.265
+ sb=0.265 sd=0.28 topography=normal area=0.063 perim=1.14
MI9 net117 S0 net268 VPB pfet_01v8_hvt m=1 w=0.84 l=0.15 mult=1
+ sa=0.265 sb=0.265 sd=0.28 topography=normal area=0.063 perim=1.14
MI670 net265 M1 VPWR VPB pfet_01v8_hvt m=1 w=0.84 l=0.15 mult=1
+ sa=0.265 sb=0.265 sd=0.28 topography=normal area=0.063 perim=1.14
MI678 net216 RESET VPWR VPB pfet_01v8_hvt m=1 w=0.84 l=0.15 mult=1
+ sa=0.265 sb=0.265 sd=0.28 topography=normal area=0.063 perim=1.14
MI662 net257 net117 VPWR VPB pfet_01v8_hvt m=1 w=0.42 l=0.15 mult=1
+ sa=0.265 sb=0.265 sd=0.28 topography=normal area=0.063 perim=1.14
MI664 S0 clkpos net257 VPB pfet_01v8_hvt m=1 w=0.42 l=0.15 mult=1
+ sa=0.265 sb=0.265 sd=0.28 topography=normal area=0.063 perim=1.14
MI10 net117 SET_B VPWR VPB pfet_01v8_hvt m=1 w=0.42 l=0.15 mult=1
+ sa=0.265 sb=0.265 sd=0.28 topography=normal area=0.063 perim=1.14
MI11 net268 RESET VPWR VPB pfet_01v8_hvt m=1 w=0.84 l=0.15 mult=1
+ sa=0.265 sb=0.265 sd=0.28 topography=normal area=0.063 perim=1.14
MI650 net241 M1 VPWR VPB pfet_01v8_hvt m=1 w=0.42 l=0.15 mult=1
+ sa=0.265 sb=0.265 sd=0.28 topography=normal area=0.063 perim=1.14
MI43 net105 clkpos M0 VPB pfet_01v8_hvt m=1 w=0.42 l=0.15 mult=1
+ sa=0.265 sb=0.265 sd=0.28 topography=normal area=0.063 perim=1.14
MI656 M0 clkneg net241 VPB pfet_01v8_hvt m=1 w=0.42 l=0.15 mult=1
+ sa=0.265 sb=0.265 sd=0.28 topography=normal area=0.063 perim=1.14
MI643 RESET RESET_B VPWR VPB pfet_01v8_hvt m=1 w=0.64 l=0.15 mult=1
+ sa=0.265 sb=0.265 sd=0.28 topography=normal area=0.063 perim=1.14
MI47 clkneg clkpos VPWR VPB pfet_01v8_hvt m=1 w=0.64 l=0.15 mult=1
+ sa=0.265 sb=0.265 sd=0.28 topography=normal area=0.063 perim=1.14
MI45 clkpos CLK_N VPWR VPB pfet_01v8_hvt m=1 w=0.64 l=0.15 mult=1
+ sa=0.265 sb=0.265 sd=0.28 topography=normal area=0.063 perim=1.14
MI680 M1 M0 net216 VPB pfet_01v8_hvt m=1 w=0.84 l=0.15 mult=1 sa=0.265
+ sb=0.265 sd=0.28 topography=normal area=0.063 perim=1.14
MI663 net213 net117 VPWR VPB pfet_01v8_hvt m=1 w=0.64 l=0.15 mult=1
+ sa=0.265 sb=0.265 sd=0.28 topography=normal area=0.063 perim=1.14
MI661 Q_N net117 VPWR VPB pfet_01v8_hvt m=1 w=1.0 l=0.15 mult=1
+ sa=0.265 sb=0.265 sd=0.28 topography=normal area=0.063 perim=1.14
MI640 sceb SCE VPWR VPB pfet_01v8_hvt m=1 w=0.42 l=0.15 mult=1
+ sa=0.265 sb=0.265 sd=0.28 topography=normal area=0.063 perim=1.14
.ENDS

.SUBCKT sky130_fd_sc_hd__sdfbbn_2 CLK_N D RESET_B SCD SCE SET_B VGND VNB VPB VPWR Q Q_N
MI98 net105 D n0 VNB nfet_01v8 m=1 w=0.42 l=0.15 mult=1 sa=0.265
+ sb=0.265 sd=0.28 topography=normal area=0.525 perim=3.1
MI103 n1 SCD VGND VNB nfet_01v8 m=1 w=0.42 l=0.15 mult=1 sa=0.265
+ sb=0.265 sd=0.28 topography=normal area=0.525 perim=3.1
MI104 n0 sceb VGND VNB nfet_01v8 m=1 w=0.42 l=0.15 mult=1 sa=0.265
+ sb=0.265 sd=0.28 topography=normal area=0.525 perim=3.1
MI120 net105 SCE n1 VNB nfet_01v8 m=1 w=0.42 l=0.15 mult=1 sa=0.265
+ sb=0.265 sd=0.28 topography=normal area=0.525 perim=3.1
MI46 clkneg clkpos VGND VNB nfet_01v8 m=1 w=0.42 l=0.15 mult=1
+ sa=0.265 sb=0.265 sd=0.28 topography=normal area=0.063 perim=1.14
MI642 RESET RESET_B VGND VNB nfet_01v8 m=1 w=0.42 l=0.15 mult=1
+ sa=0.265 sb=0.265 sd=0.28 topography=normal area=0.063 perim=1.14
MI676 M1 M0 net176 VNB nfet_01v8 m=1 w=0.64 l=0.15 mult=1 sa=0.265
+ sb=0.265 sd=0.28 topography=normal area=0.063 perim=1.14
MI675 net176 SET_B VGND VNB nfet_01v8 m=1 w=0.42 l=0.15 mult=1
+ sa=0.265 sb=0.265 sd=0.28 topography=normal area=0.063 perim=1.14
MI653 Q net213 VGND VNB nfet_01v8 m=2 w=0.65 l=0.15 mult=1 sa=0.265
+ sb=0.265 sd=0.28 topography=normal area=0.063 perim=1.14
MI677 M1 RESET net176 VNB nfet_01v8 m=1 w=0.64 l=0.15 mult=1 sa=0.265
+ sb=0.265 sd=0.28 topography=normal area=0.063 perim=1.14
MI648 M0 clkpos net160 VNB nfet_01v8 m=1 w=0.36 l=0.15 mult=1 sa=0.265
+ sb=0.265 sd=0.28 topography=normal area=0.063 perim=1.14
MI44 clkpos CLK_N VGND VNB nfet_01v8 m=1 w=0.42 l=0.15 mult=1 sa=0.265
+ sb=0.265 sd=0.28 topography=normal area=0.063 perim=1.14
MI649 net160 M1 VGND VNB nfet_01v8 m=1 w=0.42 l=0.15 mult=1 sa=0.265
+ sb=0.265 sd=0.28 topography=normal area=0.063 perim=1.14
MI655 S0 clkneg net145 VNB nfet_01v8 m=1 w=0.36 l=0.15 mult=1 sa=0.265
+ sb=0.265 sd=0.28 topography=normal area=0.063 perim=1.14
MI654 net145 net117 VGND VNB nfet_01v8 m=1 w=0.42 l=0.15 mult=1
+ sa=0.265 sb=0.265 sd=0.28 topography=normal area=0.063 perim=1.14
MI651 Q_N net117 VGND VNB nfet_01v8 m=2 w=0.65 l=0.15 mult=1 sa=0.265
+ sb=0.265 sd=0.28 topography=normal area=0.063 perim=1.14
MI652 net213 net117 VGND VNB nfet_01v8 m=1 w=0.42 l=0.15 mult=1
+ sa=0.265 sb=0.265 sd=0.28 topography=normal area=0.063 perim=1.14
MI42 net105 clkneg M0 VNB nfet_01v8 m=1 w=0.36 l=0.15 mult=1 sa=0.265
+ sb=0.265 sd=0.28 topography=normal area=0.063 perim=1.14
MI668 S0 clkpos net128 VNB nfet_01v8 m=1 w=0.36 l=0.15 mult=1 sa=0.265
+ sb=0.265 sd=0.28 topography=normal area=0.063 perim=1.14
MI667 net128 M1 VGND VNB nfet_01v8 m=1 w=0.64 l=0.15 mult=1 sa=0.265
+ sb=0.265 sd=0.28 topography=normal area=0.063 perim=1.14
MI630 net117 RESET net116 VNB nfet_01v8 m=1 w=0.64 l=0.15 mult=1
+ sa=0.265 sb=0.265 sd=0.28 topography=normal area=0.063 perim=1.14
MI3 net117 S0 net116 VNB nfet_01v8 m=1 w=0.64 l=0.15 mult=1 sa=0.265
+ sb=0.265 sd=0.28 topography=normal area=0.063 perim=1.14
MI7 net116 SET_B VGND VNB nfet_01v8 m=1 w=0.42 l=0.15 mult=1 sa=0.265
+ sb=0.265 sd=0.28 topography=normal area=0.063 perim=1.14
MI639 sceb SCE VGND VNB nfet_01v8 m=1 w=0.42 l=0.15 mult=1 sa=0.265
+ sb=0.265 sd=0.28 topography=normal area=0.063 perim=1.14
MI107 p0 SCE VPWR VPB pfet_01v8_hvt m=1 w=0.42 l=0.15 mult=1 sa=0.265
+ sb=0.265 sd=0.28 topography=normal area=0.063 perim=1.14
MI94 net105 D p0 VPB pfet_01v8_hvt m=1 w=0.42 l=0.15 mult=1 sa=0.265
+ sb=0.265 sd=0.28 topography=normal area=0.063 perim=1.14
MI101 net105 sceb p1 VPB pfet_01v8_hvt m=1 w=0.64 l=0.15 mult=1
+ sa=0.265 sb=0.265 sd=0.28 topography=normal area=0.063 perim=1.14
MI108 p1 SCD VPWR VPB pfet_01v8_hvt m=1 w=0.64 l=0.15 mult=1 sa=0.265
+ sb=0.265 sd=0.28 topography=normal area=0.063 perim=1.14
MI679 M1 SET_B VPWR VPB pfet_01v8_hvt m=1 w=0.42 l=0.15 mult=1
+ sa=0.265 sb=0.265 sd=0.28 topography=normal area=0.063 perim=1.14
MI669 S0 clkneg net265 VPB pfet_01v8_hvt m=1 w=0.42 l=0.15 mult=1
+ sa=0.265 sb=0.265 sd=0.28 topography=normal area=0.063 perim=1.14
MI660 Q net213 VPWR VPB pfet_01v8_hvt m=2 w=1.0 l=0.15 mult=1 sa=0.265
+ sb=0.265 sd=0.28 topography=normal area=0.063 perim=1.14
MI9 net117 S0 net268 VPB pfet_01v8_hvt m=1 w=0.84 l=0.15 mult=1
+ sa=0.265 sb=0.265 sd=0.28 topography=normal area=0.063 perim=1.14
MI670 net265 M1 VPWR VPB pfet_01v8_hvt m=1 w=0.84 l=0.15 mult=1
+ sa=0.265 sb=0.265 sd=0.28 topography=normal area=0.063 perim=1.14
MI678 net216 RESET VPWR VPB pfet_01v8_hvt m=1 w=0.84 l=0.15 mult=1
+ sa=0.265 sb=0.265 sd=0.28 topography=normal area=0.063 perim=1.14
MI662 net257 net117 VPWR VPB pfet_01v8_hvt m=1 w=0.42 l=0.15 mult=1
+ sa=0.265 sb=0.265 sd=0.28 topography=normal area=0.063 perim=1.14
MI664 S0 clkpos net257 VPB pfet_01v8_hvt m=1 w=0.42 l=0.15 mult=1
+ sa=0.265 sb=0.265 sd=0.28 topography=normal area=0.063 perim=1.14
MI10 net117 SET_B VPWR VPB pfet_01v8_hvt m=1 w=0.42 l=0.15 mult=1
+ sa=0.265 sb=0.265 sd=0.28 topography=normal area=0.063 perim=1.14
MI11 net268 RESET VPWR VPB pfet_01v8_hvt m=1 w=0.84 l=0.15 mult=1
+ sa=0.265 sb=0.265 sd=0.28 topography=normal area=0.063 perim=1.14
MI650 net241 M1 VPWR VPB pfet_01v8_hvt m=1 w=0.42 l=0.15 mult=1
+ sa=0.265 sb=0.265 sd=0.28 topography=normal area=0.063 perim=1.14
MI43 net105 clkpos M0 VPB pfet_01v8_hvt m=1 w=0.42 l=0.15 mult=1
+ sa=0.265 sb=0.265 sd=0.28 topography=normal area=0.063 perim=1.14
MI656 M0 clkneg net241 VPB pfet_01v8_hvt m=1 w=0.42 l=0.15 mult=1
+ sa=0.265 sb=0.265 sd=0.28 topography=normal area=0.063 perim=1.14
MI643 RESET RESET_B VPWR VPB pfet_01v8_hvt m=1 w=0.64 l=0.15 mult=1
+ sa=0.265 sb=0.265 sd=0.28 topography=normal area=0.063 perim=1.14
MI47 clkneg clkpos VPWR VPB pfet_01v8_hvt m=1 w=0.64 l=0.15 mult=1
+ sa=0.265 sb=0.265 sd=0.28 topography=normal area=0.063 perim=1.14
MI45 clkpos CLK_N VPWR VPB pfet_01v8_hvt m=1 w=0.64 l=0.15 mult=1
+ sa=0.265 sb=0.265 sd=0.28 topography=normal area=0.063 perim=1.14
MI680 M1 M0 net216 VPB pfet_01v8_hvt m=1 w=0.84 l=0.15 mult=1 sa=0.265
+ sb=0.265 sd=0.28 topography=normal area=0.063 perim=1.14
MI663 net213 net117 VPWR VPB pfet_01v8_hvt m=1 w=0.64 l=0.15 mult=1
+ sa=0.265 sb=0.265 sd=0.28 topography=normal area=0.063 perim=1.14
MI661 Q_N net117 VPWR VPB pfet_01v8_hvt m=2 w=1.0 l=0.15 mult=1
+ sa=0.265 sb=0.265 sd=0.28 topography=normal area=0.063 perim=1.14
MI640 sceb SCE VPWR VPB pfet_01v8_hvt m=1 w=0.42 l=0.15 mult=1
+ sa=0.265 sb=0.265 sd=0.28 topography=normal area=0.063 perim=1.14
.ENDS

.SUBCKT sky130_fd_sc_hd__sdfbbp_1 CLK D RESET_B SCD SCE SET_B VGND VNB VPB VPWR Q Q_N
MI98 net105 D n0 VNB nfet_01v8 m=1 w=0.42 l=0.15 mult=1 sa=0.265
+ sb=0.265 sd=0.28 topography=normal area=0.525 perim=3.1
MI103 n1 SCD VGND VNB nfet_01v8 m=1 w=0.42 l=0.15 mult=1 sa=0.265
+ sb=0.265 sd=0.28 topography=normal area=0.525 perim=3.1
MI104 n0 sceb VGND VNB nfet_01v8 m=1 w=0.42 l=0.15 mult=1 sa=0.265
+ sb=0.265 sd=0.28 topography=normal area=0.525 perim=3.1
MI120 net105 SCE n1 VNB nfet_01v8 m=1 w=0.42 l=0.15 mult=1 sa=0.265
+ sb=0.265 sd=0.28 topography=normal area=0.525 perim=3.1
MI46 clkpos clkneg VGND VNB nfet_01v8 m=1 w=0.42 l=0.15 mult=1
+ sa=0.265 sb=0.265 sd=0.28 topography=normal area=0.063 perim=1.14
MI642 RESET RESET_B VGND VNB nfet_01v8 m=1 w=0.42 l=0.15 mult=1
+ sa=0.265 sb=0.265 sd=0.28 topography=normal area=0.063 perim=1.14
MI676 M1 M0 net176 VNB nfet_01v8 m=1 w=0.64 l=0.15 mult=1 sa=0.265
+ sb=0.265 sd=0.28 topography=normal area=0.063 perim=1.14
MI675 net176 SET_B VGND VNB nfet_01v8 m=1 w=0.42 l=0.15 mult=1
+ sa=0.265 sb=0.265 sd=0.28 topography=normal area=0.063 perim=1.14
MI653 Q net213 VGND VNB nfet_01v8 m=1 w=0.65 l=0.15 mult=1 sa=0.265
+ sb=0.265 sd=0.28 topography=normal area=0.063 perim=1.14
MI677 M1 RESET net176 VNB nfet_01v8 m=1 w=0.64 l=0.15 mult=1 sa=0.265
+ sb=0.265 sd=0.28 topography=normal area=0.063 perim=1.14
MI648 M0 clkpos net160 VNB nfet_01v8 m=1 w=0.36 l=0.15 mult=1 sa=0.265
+ sb=0.265 sd=0.28 topography=normal area=0.063 perim=1.14
MI44 clkneg CLK VGND VNB nfet_01v8 m=1 w=0.42 l=0.15 mult=1 sa=0.265
+ sb=0.265 sd=0.28 topography=normal area=0.063 perim=1.14
MI649 net160 M1 VGND VNB nfet_01v8 m=1 w=0.42 l=0.15 mult=1 sa=0.265
+ sb=0.265 sd=0.28 topography=normal area=0.063 perim=1.14
MI655 S0 clkneg net145 VNB nfet_01v8 m=1 w=0.36 l=0.15 mult=1 sa=0.265
+ sb=0.265 sd=0.28 topography=normal area=0.063 perim=1.14
MI654 net145 net117 VGND VNB nfet_01v8 m=1 w=0.42 l=0.15 mult=1
+ sa=0.265 sb=0.265 sd=0.28 topography=normal area=0.063 perim=1.14
MI651 Q_N net117 VGND VNB nfet_01v8 m=1 w=0.65 l=0.15 mult=1 sa=0.265
+ sb=0.265 sd=0.28 topography=normal area=0.063 perim=1.14
MI652 net213 net117 VGND VNB nfet_01v8 m=1 w=0.42 l=0.15 mult=1
+ sa=0.265 sb=0.265 sd=0.28 topography=normal area=0.063 perim=1.14
MI42 net105 clkneg M0 VNB nfet_01v8 m=1 w=0.36 l=0.15 mult=1 sa=0.265
+ sb=0.265 sd=0.28 topography=normal area=0.063 perim=1.14
MI668 S0 clkpos net125 VNB nfet_01v8 m=1 w=0.36 l=0.15 mult=1 sa=0.265
+ sb=0.265 sd=0.28 topography=normal area=0.063 perim=1.14
MI667 net125 M1 VGND VNB nfet_01v8 m=1 w=0.64 l=0.15 mult=1 sa=0.265
+ sb=0.265 sd=0.28 topography=normal area=0.063 perim=1.14
MI630 net117 RESET net116 VNB nfet_01v8 m=1 w=0.64 l=0.15 mult=1
+ sa=0.265 sb=0.265 sd=0.28 topography=normal area=0.063 perim=1.14
MI3 net117 S0 net116 VNB nfet_01v8 m=1 w=0.64 l=0.15 mult=1 sa=0.265
+ sb=0.265 sd=0.28 topography=normal area=0.063 perim=1.14
MI7 net116 SET_B VGND VNB nfet_01v8 m=1 w=0.42 l=0.15 mult=1 sa=0.265
+ sb=0.265 sd=0.28 topography=normal area=0.063 perim=1.14
MI639 sceb SCE VGND VNB nfet_01v8 m=1 w=0.42 l=0.15 mult=1 sa=0.265
+ sb=0.265 sd=0.28 topography=normal area=0.063 perim=1.14
MI107 p0 SCE VPWR VPB pfet_01v8_hvt m=1 w=0.42 l=0.15 mult=1 sa=0.265
+ sb=0.265 sd=0.28 topography=normal area=0.063 perim=1.14
MI94 net105 D p0 VPB pfet_01v8_hvt m=1 w=0.42 l=0.15 mult=1 sa=0.265
+ sb=0.265 sd=0.28 topography=normal area=0.063 perim=1.14
MI101 net105 sceb p1 VPB pfet_01v8_hvt m=1 w=0.64 l=0.15 mult=1
+ sa=0.265 sb=0.265 sd=0.28 topography=normal area=0.063 perim=1.14
MI108 p1 SCD VPWR VPB pfet_01v8_hvt m=1 w=0.64 l=0.15 mult=1 sa=0.265
+ sb=0.265 sd=0.28 topography=normal area=0.063 perim=1.14
MI679 M1 SET_B VPWR VPB pfet_01v8_hvt m=1 w=0.42 l=0.15 mult=1
+ sa=0.265 sb=0.265 sd=0.28 topography=normal area=0.063 perim=1.14
MI669 S0 clkneg net265 VPB pfet_01v8_hvt m=1 w=0.42 l=0.15 mult=1
+ sa=0.265 sb=0.265 sd=0.28 topography=normal area=0.063 perim=1.14
MI660 Q net213 VPWR VPB pfet_01v8_hvt m=1 w=1.0 l=0.15 mult=1 sa=0.265
+ sb=0.265 sd=0.28 topography=normal area=0.063 perim=1.14
MI9 net117 S0 net268 VPB pfet_01v8_hvt m=1 w=0.84 l=0.15 mult=1
+ sa=0.265 sb=0.265 sd=0.28 topography=normal area=0.063 perim=1.14
MI670 net265 M1 VPWR VPB pfet_01v8_hvt m=1 w=0.84 l=0.15 mult=1
+ sa=0.265 sb=0.265 sd=0.28 topography=normal area=0.063 perim=1.14
MI678 net216 RESET VPWR VPB pfet_01v8_hvt m=1 w=0.84 l=0.15 mult=1
+ sa=0.265 sb=0.265 sd=0.28 topography=normal area=0.063 perim=1.14
MI662 net257 net117 VPWR VPB pfet_01v8_hvt m=1 w=0.42 l=0.15 mult=1
+ sa=0.265 sb=0.265 sd=0.28 topography=normal area=0.063 perim=1.14
MI664 S0 clkpos net257 VPB pfet_01v8_hvt m=1 w=0.42 l=0.15 mult=1
+ sa=0.265 sb=0.265 sd=0.28 topography=normal area=0.063 perim=1.14
MI10 net117 SET_B VPWR VPB pfet_01v8_hvt m=1 w=0.42 l=0.15 mult=1
+ sa=0.265 sb=0.265 sd=0.28 topography=normal area=0.063 perim=1.14
MI11 net268 RESET VPWR VPB pfet_01v8_hvt m=1 w=0.84 l=0.15 mult=1
+ sa=0.265 sb=0.265 sd=0.28 topography=normal area=0.063 perim=1.14
MI650 net241 M1 VPWR VPB pfet_01v8_hvt m=1 w=0.42 l=0.15 mult=1
+ sa=0.265 sb=0.265 sd=0.28 topography=normal area=0.063 perim=1.14
MI43 net105 clkpos M0 VPB pfet_01v8_hvt m=1 w=0.42 l=0.15 mult=1
+ sa=0.265 sb=0.265 sd=0.28 topography=normal area=0.063 perim=1.14
MI656 M0 clkneg net241 VPB pfet_01v8_hvt m=1 w=0.42 l=0.15 mult=1
+ sa=0.265 sb=0.265 sd=0.28 topography=normal area=0.063 perim=1.14
MI643 RESET RESET_B VPWR VPB pfet_01v8_hvt m=1 w=0.64 l=0.15 mult=1
+ sa=0.265 sb=0.265 sd=0.28 topography=normal area=0.063 perim=1.14
MI47 clkpos clkneg VPWR VPB pfet_01v8_hvt m=1 w=0.64 l=0.15 mult=1
+ sa=0.265 sb=0.265 sd=0.28 topography=normal area=0.063 perim=1.14
MI45 clkneg CLK VPWR VPB pfet_01v8_hvt m=1 w=0.64 l=0.15 mult=1
+ sa=0.265 sb=0.265 sd=0.28 topography=normal area=0.063 perim=1.14
MI680 M1 M0 net216 VPB pfet_01v8_hvt m=1 w=0.84 l=0.15 mult=1 sa=0.265
+ sb=0.265 sd=0.28 topography=normal area=0.063 perim=1.14
MI663 net213 net117 VPWR VPB pfet_01v8_hvt m=1 w=0.64 l=0.15 mult=1
+ sa=0.265 sb=0.265 sd=0.28 topography=normal area=0.063 perim=1.14
MI661 Q_N net117 VPWR VPB pfet_01v8_hvt m=1 w=1.0 l=0.15 mult=1
+ sa=0.265 sb=0.265 sd=0.28 topography=normal area=0.063 perim=1.14
MI640 sceb SCE VPWR VPB pfet_01v8_hvt m=1 w=0.42 l=0.15 mult=1
+ sa=0.265 sb=0.265 sd=0.28 topography=normal area=0.063 perim=1.14
.ENDS

.SUBCKT sky130_fd_sc_hd__sdfrbp_1 CLK D RESET_B SCD SCE VGND VNB VPB VPWR Q Q_N
MI642 clkneg CLK VGND VNB nfet_01v8 m=1 w=0.65 l=0.15 mult=1 sa=0.265
+ sb=0.265 sd=0.28 topography=normal area=0.063 perim=1.14
MI636 clkpos clkneg VGND VNB nfet_01v8 m=1 w=0.65 l=0.15 mult=1
+ sa=0.265 sb=0.265 sd=0.28 topography=normal area=0.063 perim=1.14
MI42 db clkneg M0 VNB nfet_01v8 m=1 w=0.36 l=0.15 mult=1 sa=0.265
+ sb=0.265 sd=0.28 topography=normal area=0.063 perim=1.14
MI656 net92 S0 net134 VNB nfet_01v8 m=1 w=0.42 l=0.15 mult=1 sa=0.265
+ sb=0.265 sd=0.28 topography=normal area=0.063 perim=1.14
MI657 net134 RESET_B VGND VNB nfet_01v8 m=1 w=0.42 l=0.15 mult=1
+ sa=0.265 sb=0.265 sd=0.28 topography=normal area=0.063 perim=1.14
MI33 net127 RESET_B VGND VNB nfet_01v8 m=1 w=0.42 l=0.15 mult=1
+ sa=0.265 sb=0.265 sd=0.28 topography=normal area=0.063 perim=1.14
MI634 sceb SCE VGND VNB nfet_01v8 m=1 w=0.42 l=0.15 mult=1 sa=0.265
+ sb=0.265 sd=0.28 topography=normal area=0.063 perim=1.14
MI4 M0 clkpos net115 VNB nfet_01v8 m=1 w=0.36 l=0.15 mult=1 sa=0.265
+ sb=0.265 sd=0.28 topography=normal area=0.063 perim=1.14
MI34 net115 M1 net127 VNB nfet_01v8 m=1 w=0.42 l=0.15 mult=1 sa=0.265
+ sb=0.265 sd=0.28 topography=normal area=0.063 perim=1.14
MI655 S0 clkneg net103 VNB nfet_01v8 m=1 w=0.36 l=0.15 mult=1 sa=0.265
+ sb=0.265 sd=0.28 topography=normal area=0.063 perim=1.14
MI652 Q net92 VGND VNB nfet_01v8 m=1 w=0.65 l=0.15 mult=1 sa=0.265
+ sb=0.265 sd=0.28 topography=normal area=0.063 perim=1.14
MI654 net103 net92 VGND VNB nfet_01v8 m=1 w=0.42 l=0.15 mult=1
+ sa=0.265 sb=0.265 sd=0.28 topography=normal area=0.063 perim=1.14
MI647 M1 M0 VGND VNB nfet_01v8 m=1 w=0.64 l=0.15 mult=1 sa=0.265
+ sb=0.265 sd=0.28 topography=normal area=0.063 perim=1.14
MI649 M1 clkpos S0 VNB nfet_01v8 m=1 w=0.36 l=0.15 mult=1 sa=0.265
+ sb=0.265 sd=0.28 topography=normal area=0.063 perim=1.14
MI672 net171 net92 VGND VNB nfet_01v8 m=1 w=0.52 l=0.15 mult=1
+ sa=0.265 sb=0.265 sd=0.28 topography=normal area=0.063 perim=1.14
MI670 Q_N net171 VGND VNB nfet_01v8 m=1 w=0.52 l=0.15 mult=1 sa=0.265
+ sb=0.265 sd=0.28 topography=normal area=0.063 perim=1.14
MI98 db D n0 VNB nfet_01v8 m=1 w=0.42 l=0.15 mult=1 sa=0.265 sb=0.265
+ sd=0.28 topography=normal area=0.525 perim=3.1
MI103 n1 SCD VGND VNB nfet_01v8 m=1 w=0.42 l=0.18 mult=1 sa=0.265
+ sb=0.265 sd=0.28 topography=normal area=0.525 perim=3.1
MI120 db SCE n1 VNB nfet_01v8 m=1 w=0.42 l=0.5 mult=1 sa=0.265
+ sb=0.265 sd=0.28 topography=normal area=0.525 perim=3.1
MI104 n0 sceb VGND VNB nfet_01v8 m=1 w=0.42 l=0.15 mult=1 sa=0.265
+ sb=0.265 sd=0.28 topography=normal area=0.525 perim=3.1
MI643 clkneg CLK VPWR VPB pfet_01v8_hvt m=1 w=1.0 l=0.15 mult=1
+ sa=0.265 sb=0.265 sd=0.28 topography=normal area=0.063 perim=1.14
MI635 clkpos clkneg VPWR VPB pfet_01v8_hvt m=1 w=1.0 l=0.15 mult=1
+ sa=0.265 sb=0.265 sd=0.28 topography=normal area=0.063 perim=1.14
MI43 db clkpos M0 VPB pfet_01v8_hvt m=1 w=0.42 l=0.15 mult=1 sa=0.265
+ sb=0.265 sd=0.28 topography=normal area=0.063 perim=1.14
MI662 net215 net92 VPWR VPB pfet_01v8_hvt m=1 w=0.42 l=0.15 mult=1
+ sa=0.265 sb=0.265 sd=0.28 topography=normal area=0.063 perim=1.14
MI659 net92 RESET_B VPWR VPB pfet_01v8_hvt m=1 w=0.42 l=0.15 mult=1
+ sa=0.265 sb=0.265 sd=0.28 topography=normal area=0.063 perim=1.14
MI664 S0 clkpos net215 VPB pfet_01v8_hvt m=1 w=0.42 l=0.15 mult=1
+ sa=0.265 sb=0.265 sd=0.28 topography=normal area=0.063 perim=1.14
MI658 net92 S0 VPWR VPB pfet_01v8_hvt m=1 w=0.42 l=0.15 mult=1
+ sa=0.265 sb=0.265 sd=0.28 topography=normal area=0.063 perim=1.14
MI30 net194 M1 VPWR VPB pfet_01v8_hvt m=1 w=0.42 l=0.15 mult=1
+ sa=0.265 sb=0.265 sd=0.28 topography=normal area=0.063 perim=1.14
MI31 M0 clkneg net194 VPB pfet_01v8_hvt m=1 w=0.42 l=0.15 mult=1
+ sa=0.265 sb=0.265 sd=0.28 topography=normal area=0.063 perim=1.14
MI32 net194 RESET_B VPWR VPB pfet_01v8_hvt m=1 w=0.42 l=0.15 mult=1
+ sa=0.265 sb=0.265 sd=0.28 topography=normal area=0.063 perim=1.14
MI663 Q net92 VPWR VPB pfet_01v8_hvt m=1 w=1.0 l=0.15 mult=1 sa=0.265
+ sb=0.265 sd=0.28 topography=normal area=0.063 perim=1.14
MI648 M1 M0 VPWR VPB pfet_01v8_hvt m=1 w=0.84 l=0.15 mult=1 sa=0.265
+ sb=0.265 sd=0.28 topography=normal area=0.063 perim=1.14
MI650 M1 clkneg S0 VPB pfet_01v8_hvt m=1 w=0.42 l=0.15 mult=1 sa=0.265
+ sb=0.265 sd=0.28 topography=normal area=0.063 perim=1.14
MI633 sceb SCE VPWR VPB pfet_01v8_hvt m=1 w=0.54 l=0.15 mult=1
+ sa=0.265 sb=0.265 sd=0.28 topography=normal area=0.063 perim=1.14
MI673 net171 net92 VPWR VPB pfet_01v8_hvt m=1 w=0.79 l=0.15 mult=1
+ sa=0.265 sb=0.265 sd=0.28 topography=normal area=0.063 perim=1.14
MI671 Q_N net171 VPWR VPB pfet_01v8_hvt m=1 w=0.79 l=0.15 mult=1
+ sa=0.265 sb=0.265 sd=0.28 topography=normal area=0.063 perim=1.14
MI101 db sceb p1 VPB pfet_01v8_hvt m=1 w=0.54 l=0.15 mult=1 sa=0.265
+ sb=0.265 sd=0.28 topography=normal area=0.063 perim=1.14
MI107 p0 SCE VPWR VPB pfet_01v8_hvt m=1 w=0.54 l=0.15 mult=1 sa=0.265
+ sb=0.265 sd=0.28 topography=normal area=0.063 perim=1.14
MI94 db D p0 VPB pfet_01v8_hvt m=1 w=0.54 l=0.15 mult=1 sa=0.265
+ sb=0.265 sd=0.28 topography=normal area=0.063 perim=1.14
MI108 p1 SCD VPWR VPB pfet_01v8_hvt m=1 w=0.54 l=0.15 mult=1 sa=0.265
+ sb=0.265 sd=0.28 topography=normal area=0.063 perim=1.14
.ENDS

.SUBCKT sky130_fd_sc_hd__sdfrbp_2 CLK D RESET_B SCD SCE VGND VNB VPB VPWR Q Q_N
MI642 clkneg CLK VGND VNB nfet_01v8 m=1 w=0.65 l=0.15 mult=1 sa=0.265
+ sb=0.265 sd=0.28 topography=normal area=0.063 perim=1.14
MI636 clkpos clkneg VGND VNB nfet_01v8 m=1 w=0.65 l=0.15 mult=1
+ sa=0.265 sb=0.265 sd=0.28 topography=normal area=0.063 perim=1.14
MI42 db clkneg M0 VNB nfet_01v8 m=1 w=0.36 l=0.15 mult=1 sa=0.265
+ sb=0.265 sd=0.28 topography=normal area=0.063 perim=1.14
MI656 net92 S0 net134 VNB nfet_01v8 m=1 w=0.42 l=0.15 mult=1 sa=0.265
+ sb=0.265 sd=0.28 topography=normal area=0.063 perim=1.14
MI657 net134 RESET_B VGND VNB nfet_01v8 m=1 w=0.42 l=0.15 mult=1
+ sa=0.265 sb=0.265 sd=0.28 topography=normal area=0.063 perim=1.14
MI33 net127 RESET_B VGND VNB nfet_01v8 m=1 w=0.42 l=0.15 mult=1
+ sa=0.265 sb=0.265 sd=0.28 topography=normal area=0.063 perim=1.14
MI634 sceb SCE VGND VNB nfet_01v8 m=1 w=0.42 l=0.15 mult=1 sa=0.265
+ sb=0.265 sd=0.28 topography=normal area=0.063 perim=1.14
MI4 M0 clkpos net115 VNB nfet_01v8 m=1 w=0.36 l=0.15 mult=1 sa=0.265
+ sb=0.265 sd=0.28 topography=normal area=0.063 perim=1.14
MI34 net115 M1 net127 VNB nfet_01v8 m=1 w=0.42 l=0.15 mult=1 sa=0.265
+ sb=0.265 sd=0.28 topography=normal area=0.063 perim=1.14
MI655 S0 clkneg net110 VNB nfet_01v8 m=1 w=0.36 l=0.15 mult=1 sa=0.265
+ sb=0.265 sd=0.28 topography=normal area=0.063 perim=1.14
MI652 Q net92 VGND VNB nfet_01v8 m=2 w=0.65 l=0.15 mult=1 sa=0.265
+ sb=0.265 sd=0.28 topography=normal area=0.063 perim=1.14
MI654 net110 net92 VGND VNB nfet_01v8 m=1 w=0.42 l=0.15 mult=1
+ sa=0.265 sb=0.265 sd=0.28 topography=normal area=0.063 perim=1.14
MI647 M1 M0 VGND VNB nfet_01v8 m=1 w=0.64 l=0.15 mult=1 sa=0.265
+ sb=0.265 sd=0.28 topography=normal area=0.063 perim=1.14
MI649 M1 clkpos S0 VNB nfet_01v8 m=1 w=0.36 l=0.15 mult=1 sa=0.265
+ sb=0.265 sd=0.28 topography=normal area=0.063 perim=1.14
MI672 net171 net92 VGND VNB nfet_01v8 m=1 w=0.42 l=0.15 mult=1
+ sa=0.265 sb=0.265 sd=0.28 topography=normal area=0.063 perim=1.14
MI670 Q_N net171 VGND VNB nfet_01v8 m=2 w=0.65 l=0.15 mult=1 sa=0.265
+ sb=0.265 sd=0.28 topography=normal area=0.063 perim=1.14
MI98 db D n0 VNB nfet_01v8 m=1 w=0.42 l=0.15 mult=1 sa=0.265 sb=0.265
+ sd=0.28 topography=normal area=0.525 perim=3.1
MI103 n1 SCD VGND VNB nfet_01v8 m=1 w=0.42 l=0.18 mult=1 sa=0.265
+ sb=0.265 sd=0.28 topography=normal area=0.525 perim=3.1
MI120 db SCE n1 VNB nfet_01v8 m=1 w=0.42 l=0.5 mult=1 sa=0.265
+ sb=0.265 sd=0.28 topography=normal area=0.525 perim=3.1
MI104 n0 sceb VGND VNB nfet_01v8 m=1 w=0.42 l=0.15 mult=1 sa=0.265
+ sb=0.265 sd=0.28 topography=normal area=0.525 perim=3.1
MI643 clkneg CLK VPWR VPB pfet_01v8_hvt m=1 w=1.0 l=0.15 mult=1
+ sa=0.265 sb=0.265 sd=0.28 topography=normal area=0.063 perim=1.14
MI635 clkpos clkneg VPWR VPB pfet_01v8_hvt m=1 w=1.0 l=0.15 mult=1
+ sa=0.265 sb=0.265 sd=0.28 topography=normal area=0.063 perim=1.14
MI43 db clkpos M0 VPB pfet_01v8_hvt m=1 w=0.42 l=0.15 mult=1 sa=0.265
+ sb=0.265 sd=0.28 topography=normal area=0.063 perim=1.14
MI662 net215 net92 VPWR VPB pfet_01v8_hvt m=1 w=0.42 l=0.15 mult=1
+ sa=0.265 sb=0.265 sd=0.28 topography=normal area=0.063 perim=1.14
MI659 net92 RESET_B VPWR VPB pfet_01v8_hvt m=1 w=0.42 l=0.15 mult=1
+ sa=0.265 sb=0.265 sd=0.28 topography=normal area=0.063 perim=1.14
MI664 S0 clkpos net215 VPB pfet_01v8_hvt m=1 w=0.42 l=0.15 mult=1
+ sa=0.265 sb=0.265 sd=0.28 topography=normal area=0.063 perim=1.14
MI658 net92 S0 VPWR VPB pfet_01v8_hvt m=1 w=0.42 l=0.15 mult=1
+ sa=0.265 sb=0.265 sd=0.28 topography=normal area=0.063 perim=1.14
MI30 net194 M1 VPWR VPB pfet_01v8_hvt m=1 w=0.42 l=0.15 mult=1
+ sa=0.265 sb=0.265 sd=0.28 topography=normal area=0.063 perim=1.14
MI31 M0 clkneg net194 VPB pfet_01v8_hvt m=1 w=0.42 l=0.15 mult=1
+ sa=0.265 sb=0.265 sd=0.28 topography=normal area=0.063 perim=1.14
MI32 net194 RESET_B VPWR VPB pfet_01v8_hvt m=1 w=0.42 l=0.15 mult=1
+ sa=0.265 sb=0.265 sd=0.28 topography=normal area=0.063 perim=1.14
MI663 Q net92 VPWR VPB pfet_01v8_hvt m=2 w=1.0 l=0.15 mult=1 sa=0.265
+ sb=0.265 sd=0.28 topography=normal area=0.063 perim=1.14
MI648 M1 M0 VPWR VPB pfet_01v8_hvt m=1 w=0.84 l=0.15 mult=1 sa=0.265
+ sb=0.265 sd=0.28 topography=normal area=0.063 perim=1.14
MI650 M1 clkneg S0 VPB pfet_01v8_hvt m=1 w=0.42 l=0.15 mult=1 sa=0.265
+ sb=0.265 sd=0.28 topography=normal area=0.063 perim=1.14
MI633 sceb SCE VPWR VPB pfet_01v8_hvt m=1 w=0.54 l=0.15 mult=1
+ sa=0.265 sb=0.265 sd=0.28 topography=normal area=0.063 perim=1.14
MI673 net171 net92 VPWR VPB pfet_01v8_hvt m=1 w=0.64 l=0.15 mult=1
+ sa=0.265 sb=0.265 sd=0.28 topography=normal area=0.063 perim=1.14
MI671 Q_N net171 VPWR VPB pfet_01v8_hvt m=2 w=1.0 l=0.15 mult=1
+ sa=0.265 sb=0.265 sd=0.28 topography=normal area=0.063 perim=1.14
MI101 db sceb p1 VPB pfet_01v8_hvt m=1 w=0.54 l=0.15 mult=1 sa=0.265
+ sb=0.265 sd=0.28 topography=normal area=0.063 perim=1.14
MI107 p0 SCE VPWR VPB pfet_01v8_hvt m=1 w=0.54 l=0.15 mult=1 sa=0.265
+ sb=0.265 sd=0.28 topography=normal area=0.063 perim=1.14
MI94 db D p0 VPB pfet_01v8_hvt m=1 w=0.54 l=0.15 mult=1 sa=0.265
+ sb=0.265 sd=0.28 topography=normal area=0.063 perim=1.14
MI108 p1 SCD VPWR VPB pfet_01v8_hvt m=1 w=0.54 l=0.15 mult=1 sa=0.265
+ sb=0.265 sd=0.28 topography=normal area=0.063 perim=1.14
.ENDS

.SUBCKT sky130_fd_sc_hd__sdfrtn_1 CLK_N D RESET_B SCD SCE VGND VNB VPB VPWR Q
MI642 clkpos CLK_N VGND VNB nfet_01v8 m=1 w=0.65 l=0.15 mult=1
+ sa=0.265 sb=0.265 sd=0.28 topography=normal area=0.063 perim=1.14
MI636 clkneg clkpos VGND VNB nfet_01v8 m=1 w=0.65 l=0.15 mult=1
+ sa=0.265 sb=0.265 sd=0.28 topography=normal area=0.063 perim=1.14
MI42 db clkneg M0 VNB nfet_01v8 m=1 w=0.36 l=0.15 mult=1 sa=0.265
+ sb=0.265 sd=0.28 topography=normal area=0.063 perim=1.14
MI656 net87 net153 net117 VNB nfet_01v8 m=1 w=0.42 l=0.15 mult=1
+ sa=0.265 sb=0.265 sd=0.28 topography=normal area=0.063 perim=1.14
MI657 net117 RESET_B VGND VNB nfet_01v8 m=1 w=0.42 l=0.15 mult=1
+ sa=0.265 sb=0.265 sd=0.28 topography=normal area=0.063 perim=1.14
MI33 net110 RESET_B VGND VNB nfet_01v8 m=1 w=0.42 l=0.15 mult=1
+ sa=0.265 sb=0.265 sd=0.28 topography=normal area=0.063 perim=1.14
MI634 sceb SCE VGND VNB nfet_01v8 m=1 w=0.42 l=0.15 mult=1 sa=0.265
+ sb=0.265 sd=0.28 topography=normal area=0.063 perim=1.14
MI4 M0 clkpos net98 VNB nfet_01v8 m=1 w=0.36 l=0.15 mult=1 sa=0.265
+ sb=0.265 sd=0.28 topography=normal area=0.063 perim=1.14
MI34 net98 M1 net110 VNB nfet_01v8 m=1 w=0.42 l=0.15 mult=1 sa=0.265
+ sb=0.265 sd=0.28 topography=normal area=0.063 perim=1.14
MI655 net153 clkneg net93 VNB nfet_01v8 m=1 w=0.36 l=0.15 mult=1
+ sa=0.265 sb=0.265 sd=0.28 topography=normal area=0.063 perim=1.14
MI653 Q net87 VGND VNB nfet_01v8 m=1 w=0.65 l=0.15 mult=1 sa=0.265
+ sb=0.265 sd=0.28 topography=normal area=0.063 perim=1.14
MI654 net93 net87 VGND VNB nfet_01v8 m=1 w=0.42 l=0.15 mult=1 sa=0.265
+ sb=0.265 sd=0.28 topography=normal area=0.063 perim=1.14
MI647 M1 M0 VGND VNB nfet_01v8 m=1 w=0.64 l=0.15 mult=1 sa=0.265
+ sb=0.265 sd=0.28 topography=normal area=0.063 perim=1.14
MI649 M1 clkpos net153 VNB nfet_01v8 m=1 w=0.36 l=0.15 mult=1 sa=0.265
+ sb=0.265 sd=0.28 topography=normal area=0.063 perim=1.14
MI98 db D n0 VNB nfet_01v8 m=1 w=0.42 l=0.15 mult=1 sa=0.265 sb=0.265
+ sd=0.28 topography=normal area=0.525 perim=3.1
MI103 n1 SCD VGND VNB nfet_01v8 m=1 w=0.42 l=0.18 mult=1 sa=0.265
+ sb=0.265 sd=0.28 topography=normal area=0.525 perim=3.1
MI120 db SCE n1 VNB nfet_01v8 m=1 w=0.42 l=0.5 mult=1 sa=0.265
+ sb=0.265 sd=0.28 topography=normal area=0.525 perim=3.1
MI104 n0 sceb VGND VNB nfet_01v8 m=1 w=0.42 l=0.15 mult=1 sa=0.265
+ sb=0.265 sd=0.28 topography=normal area=0.525 perim=3.1
MI643 clkpos CLK_N VPWR VPB pfet_01v8_hvt m=1 w=1.0 l=0.15 mult=1
+ sa=0.265 sb=0.265 sd=0.28 topography=normal area=0.063 perim=1.14
MI635 clkneg clkpos VPWR VPB pfet_01v8_hvt m=1 w=1.0 l=0.15 mult=1
+ sa=0.265 sb=0.265 sd=0.28 topography=normal area=0.063 perim=1.14
MI43 db clkpos M0 VPB pfet_01v8_hvt m=1 w=0.42 l=0.15 mult=1 sa=0.265
+ sb=0.265 sd=0.28 topography=normal area=0.063 perim=1.14
MI662 net190 net87 VPWR VPB pfet_01v8_hvt m=1 w=0.42 l=0.15 mult=1
+ sa=0.265 sb=0.265 sd=0.28 topography=normal area=0.063 perim=1.14
MI659 net87 RESET_B VPWR VPB pfet_01v8_hvt m=1 w=0.42 l=0.15 mult=1
+ sa=0.265 sb=0.265 sd=0.28 topography=normal area=0.063 perim=1.14
MI664 net153 clkpos net190 VPB pfet_01v8_hvt m=1 w=0.42 l=0.15 mult=1
+ sa=0.265 sb=0.265 sd=0.28 topography=normal area=0.063 perim=1.14
MI658 net87 net153 VPWR VPB pfet_01v8_hvt m=1 w=0.42 l=0.15 mult=1
+ sa=0.265 sb=0.265 sd=0.28 topography=normal area=0.063 perim=1.14
MI30 net169 M1 VPWR VPB pfet_01v8_hvt m=1 w=0.42 l=0.15 mult=1
+ sa=0.265 sb=0.265 sd=0.28 topography=normal area=0.063 perim=1.14
MI31 M0 clkneg net169 VPB pfet_01v8_hvt m=1 w=0.42 l=0.15 mult=1
+ sa=0.265 sb=0.265 sd=0.28 topography=normal area=0.063 perim=1.14
MI32 net169 RESET_B VPWR VPB pfet_01v8_hvt m=1 w=0.42 l=0.15 mult=1
+ sa=0.265 sb=0.265 sd=0.28 topography=normal area=0.063 perim=1.14
MI660 Q net87 VPWR VPB pfet_01v8_hvt m=1 w=1.0 l=0.15 mult=1 sa=0.265
+ sb=0.265 sd=0.28 topography=normal area=0.063 perim=1.14
MI648 M1 M0 VPWR VPB pfet_01v8_hvt m=1 w=0.84 l=0.15 mult=1 sa=0.265
+ sb=0.265 sd=0.28 topography=normal area=0.063 perim=1.14
MI650 M1 clkneg net153 VPB pfet_01v8_hvt m=1 w=0.42 l=0.15 mult=1
+ sa=0.265 sb=0.265 sd=0.28 topography=normal area=0.063 perim=1.14
MI633 sceb SCE VPWR VPB pfet_01v8_hvt m=1 w=0.54 l=0.15 mult=1
+ sa=0.265 sb=0.265 sd=0.28 topography=normal area=0.063 perim=1.14
MI101 db sceb p1 VPB pfet_01v8_hvt m=1 w=0.54 l=0.15 mult=1 sa=0.265
+ sb=0.265 sd=0.28 topography=normal area=0.063 perim=1.14
MI107 p0 SCE VPWR VPB pfet_01v8_hvt m=1 w=0.54 l=0.15 mult=1 sa=0.265
+ sb=0.265 sd=0.28 topography=normal area=0.063 perim=1.14
MI94 db D p0 VPB pfet_01v8_hvt m=1 w=0.54 l=0.15 mult=1 sa=0.265
+ sb=0.265 sd=0.28 topography=normal area=0.063 perim=1.14
MI108 p1 SCD VPWR VPB pfet_01v8_hvt m=1 w=0.54 l=0.15 mult=1 sa=0.265
+ sb=0.265 sd=0.28 topography=normal area=0.063 perim=1.14
.ENDS

.SUBCKT sky130_fd_sc_hd__sdfrtp_1 CLK D RESET_B SCD SCE VGND VNB VPB VPWR Q
MI642 clkneg CLK VGND VNB nfet_01v8 m=1 w=0.65 l=0.15 mult=1 sa=0.265
+ sb=0.265 sd=0.28 topography=normal area=0.063 perim=1.14
MI636 clkpos clkneg VGND VNB nfet_01v8 m=1 w=0.65 l=0.15 mult=1
+ sa=0.265 sb=0.265 sd=0.28 topography=normal area=0.063 perim=1.14
MI42 db clkneg M0 VNB nfet_01v8 m=1 w=0.36 l=0.15 mult=1 sa=0.265
+ sb=0.265 sd=0.28 topography=normal area=0.063 perim=1.14
MI656 net84 S0 net114 VNB nfet_01v8 m=1 w=0.42 l=0.15 mult=1 sa=0.265
+ sb=0.265 sd=0.28 topography=normal area=0.063 perim=1.14
MI657 net114 RESET_B VGND VNB nfet_01v8 m=1 w=0.42 l=0.15 mult=1
+ sa=0.265 sb=0.265 sd=0.28 topography=normal area=0.063 perim=1.14
MI33 net107 RESET_B VGND VNB nfet_01v8 m=1 w=0.42 l=0.15 mult=1
+ sa=0.265 sb=0.265 sd=0.28 topography=normal area=0.063 perim=1.14
MI634 sceb SCE VGND VNB nfet_01v8 m=1 w=0.42 l=0.15 mult=1 sa=0.265
+ sb=0.265 sd=0.28 topography=normal area=0.063 perim=1.14
MI4 M0 clkpos net95 VNB nfet_01v8 m=1 w=0.36 l=0.15 mult=1 sa=0.265
+ sb=0.265 sd=0.28 topography=normal area=0.063 perim=1.14
MI34 net95 M1 net107 VNB nfet_01v8 m=1 w=0.42 l=0.15 mult=1 sa=0.265
+ sb=0.265 sd=0.28 topography=normal area=0.063 perim=1.14
MI655 S0 clkneg net83 VNB nfet_01v8 m=1 w=0.36 l=0.15 mult=1 sa=0.265
+ sb=0.265 sd=0.28 topography=normal area=0.063 perim=1.14
MI652 Q net84 VGND VNB nfet_01v8 m=1 w=0.65 l=0.15 mult=1 sa=0.265
+ sb=0.265 sd=0.28 topography=normal area=0.063 perim=1.14
MI654 net83 net84 VGND VNB nfet_01v8 m=1 w=0.42 l=0.15 mult=1 sa=0.265
+ sb=0.265 sd=0.28 topography=normal area=0.063 perim=1.14
MI647 M1 M0 VGND VNB nfet_01v8 m=1 w=0.64 l=0.15 mult=1 sa=0.265
+ sb=0.265 sd=0.28 topography=normal area=0.063 perim=1.14
MI649 M1 clkpos S0 VNB nfet_01v8 m=1 w=0.36 l=0.15 mult=1 sa=0.265
+ sb=0.265 sd=0.28 topography=normal area=0.063 perim=1.14
MI98 db D n0 VNB nfet_01v8 m=1 w=0.42 l=0.15 mult=1 sa=0.265 sb=0.265
+ sd=0.28 topography=normal area=0.525 perim=3.1
MI103 n1 SCD VGND VNB nfet_01v8 m=1 w=0.42 l=0.18 mult=1 sa=0.265
+ sb=0.265 sd=0.28 topography=normal area=0.525 perim=3.1
MI120 db SCE n1 VNB nfet_01v8 m=1 w=0.42 l=0.5 mult=1 sa=0.265
+ sb=0.265 sd=0.28 topography=normal area=0.525 perim=3.1
MI104 n0 sceb VGND VNB nfet_01v8 m=1 w=0.42 l=0.15 mult=1 sa=0.265
+ sb=0.265 sd=0.28 topography=normal area=0.525 perim=3.1
MI643 clkneg CLK VPWR VPB pfet_01v8_hvt m=1 w=1.0 l=0.15 mult=1
+ sa=0.265 sb=0.265 sd=0.28 topography=normal area=0.063 perim=1.14
MI635 clkpos clkneg VPWR VPB pfet_01v8_hvt m=1 w=1.0 l=0.15 mult=1
+ sa=0.265 sb=0.265 sd=0.28 topography=normal area=0.063 perim=1.14
MI43 db clkpos M0 VPB pfet_01v8_hvt m=1 w=0.42 l=0.15 mult=1 sa=0.265
+ sb=0.265 sd=0.28 topography=normal area=0.063 perim=1.14
MI662 net187 net84 VPWR VPB pfet_01v8_hvt m=1 w=0.42 l=0.15 mult=1
+ sa=0.265 sb=0.265 sd=0.28 topography=normal area=0.063 perim=1.14
MI659 net84 RESET_B VPWR VPB pfet_01v8_hvt m=1 w=0.42 l=0.15 mult=1
+ sa=0.265 sb=0.265 sd=0.28 topography=normal area=0.063 perim=1.14
MI664 S0 clkpos net187 VPB pfet_01v8_hvt m=1 w=0.42 l=0.15 mult=1
+ sa=0.265 sb=0.265 sd=0.28 topography=normal area=0.063 perim=1.14
MI658 net84 S0 VPWR VPB pfet_01v8_hvt m=1 w=0.42 l=0.15 mult=1
+ sa=0.265 sb=0.265 sd=0.28 topography=normal area=0.063 perim=1.14
MI30 net166 M1 VPWR VPB pfet_01v8_hvt m=1 w=0.42 l=0.15 mult=1
+ sa=0.265 sb=0.265 sd=0.28 topography=normal area=0.063 perim=1.14
MI31 M0 clkneg net166 VPB pfet_01v8_hvt m=1 w=0.42 l=0.15 mult=1
+ sa=0.265 sb=0.265 sd=0.28 topography=normal area=0.063 perim=1.14
MI32 net166 RESET_B VPWR VPB pfet_01v8_hvt m=1 w=0.42 l=0.15 mult=1
+ sa=0.265 sb=0.265 sd=0.28 topography=normal area=0.063 perim=1.14
MI663 Q net84 VPWR VPB pfet_01v8_hvt m=1 w=1.0 l=0.15 mult=1 sa=0.265
+ sb=0.265 sd=0.28 topography=normal area=0.063 perim=1.14
MI648 M1 M0 VPWR VPB pfet_01v8_hvt m=1 w=0.84 l=0.15 mult=1 sa=0.265
+ sb=0.265 sd=0.28 topography=normal area=0.063 perim=1.14
MI650 M1 clkneg S0 VPB pfet_01v8_hvt m=1 w=0.42 l=0.15 mult=1 sa=0.265
+ sb=0.265 sd=0.28 topography=normal area=0.063 perim=1.14
MI633 sceb SCE VPWR VPB pfet_01v8_hvt m=1 w=0.54 l=0.15 mult=1
+ sa=0.265 sb=0.265 sd=0.28 topography=normal area=0.063 perim=1.14
MI101 db sceb p1 VPB pfet_01v8_hvt m=1 w=0.54 l=0.15 mult=1 sa=0.265
+ sb=0.265 sd=0.28 topography=normal area=0.063 perim=1.14
MI107 p0 SCE VPWR VPB pfet_01v8_hvt m=1 w=0.54 l=0.15 mult=1 sa=0.265
+ sb=0.265 sd=0.28 topography=normal area=0.063 perim=1.14
MI94 db D p0 VPB pfet_01v8_hvt m=1 w=0.54 l=0.15 mult=1 sa=0.265
+ sb=0.265 sd=0.28 topography=normal area=0.063 perim=1.14
MI108 p1 SCD VPWR VPB pfet_01v8_hvt m=1 w=0.54 l=0.15 mult=1 sa=0.265
+ sb=0.265 sd=0.28 topography=normal area=0.063 perim=1.14
.ENDS

.SUBCKT sky130_fd_sc_hd__sdfrtp_2 CLK D RESET_B SCD SCE VGND VNB VPB VPWR Q
MI642 clkneg CLK VGND VNB nfet_01v8 m=1 w=0.65 l=0.15 mult=1 sa=0.265
+ sb=0.265 sd=0.28 topography=normal area=0.063 perim=1.14
MI636 clkpos clkneg VGND VNB nfet_01v8 m=1 w=0.65 l=0.15 mult=1
+ sa=0.265 sb=0.265 sd=0.28 topography=normal area=0.063 perim=1.14
MI42 db clkneg M0 VNB nfet_01v8 m=1 w=0.36 l=0.15 mult=1 sa=0.265
+ sb=0.265 sd=0.28 topography=normal area=0.063 perim=1.14
MI656 net84 S0 net114 VNB nfet_01v8 m=1 w=0.42 l=0.15 mult=1 sa=0.265
+ sb=0.265 sd=0.28 topography=normal area=0.063 perim=1.14
MI657 net114 RESET_B VGND VNB nfet_01v8 m=1 w=0.42 l=0.15 mult=1
+ sa=0.265 sb=0.265 sd=0.28 topography=normal area=0.063 perim=1.14
MI33 net107 RESET_B VGND VNB nfet_01v8 m=1 w=0.42 l=0.15 mult=1
+ sa=0.265 sb=0.265 sd=0.28 topography=normal area=0.063 perim=1.14
MI634 sceb SCE VGND VNB nfet_01v8 m=1 w=0.42 l=0.15 mult=1 sa=0.265
+ sb=0.265 sd=0.28 topography=normal area=0.063 perim=1.14
MI4 M0 clkpos net95 VNB nfet_01v8 m=1 w=0.36 l=0.15 mult=1 sa=0.265
+ sb=0.265 sd=0.28 topography=normal area=0.063 perim=1.14
MI34 net95 M1 net107 VNB nfet_01v8 m=1 w=0.42 l=0.15 mult=1 sa=0.265
+ sb=0.265 sd=0.28 topography=normal area=0.063 perim=1.14
MI655 S0 clkneg net90 VNB nfet_01v8 m=1 w=0.36 l=0.15 mult=1 sa=0.265
+ sb=0.265 sd=0.28 topography=normal area=0.063 perim=1.14
MI652 Q net84 VGND VNB nfet_01v8 m=2 w=0.65 l=0.15 mult=1 sa=0.265
+ sb=0.265 sd=0.28 topography=normal area=0.063 perim=1.14
MI654 net90 net84 VGND VNB nfet_01v8 m=1 w=0.42 l=0.15 mult=1 sa=0.265
+ sb=0.265 sd=0.28 topography=normal area=0.063 perim=1.14
MI647 M1 M0 VGND VNB nfet_01v8 m=1 w=0.64 l=0.15 mult=1 sa=0.265
+ sb=0.265 sd=0.28 topography=normal area=0.063 perim=1.14
MI649 M1 clkpos S0 VNB nfet_01v8 m=1 w=0.36 l=0.15 mult=1 sa=0.265
+ sb=0.265 sd=0.28 topography=normal area=0.063 perim=1.14
MI98 db D n0 VNB nfet_01v8 m=1 w=0.42 l=0.15 mult=1 sa=0.265 sb=0.265
+ sd=0.28 topography=normal area=0.525 perim=3.1
MI103 n1 SCD VGND VNB nfet_01v8 m=1 w=0.42 l=0.18 mult=1 sa=0.265
+ sb=0.265 sd=0.28 topography=normal area=0.525 perim=3.1
MI120 db SCE n1 VNB nfet_01v8 m=1 w=0.42 l=0.5 mult=1 sa=0.265
+ sb=0.265 sd=0.28 topography=normal area=0.525 perim=3.1
MI104 n0 sceb VGND VNB nfet_01v8 m=1 w=0.42 l=0.15 mult=1 sa=0.265
+ sb=0.265 sd=0.28 topography=normal area=0.525 perim=3.1
MI643 clkneg CLK VPWR VPB pfet_01v8_hvt m=1 w=1.0 l=0.15 mult=1
+ sa=0.265 sb=0.265 sd=0.28 topography=normal area=0.063 perim=1.14
MI635 clkpos clkneg VPWR VPB pfet_01v8_hvt m=1 w=1.0 l=0.15 mult=1
+ sa=0.265 sb=0.265 sd=0.28 topography=normal area=0.063 perim=1.14
MI43 db clkpos M0 VPB pfet_01v8_hvt m=1 w=0.42 l=0.15 mult=1 sa=0.265
+ sb=0.265 sd=0.28 topography=normal area=0.063 perim=1.14
MI662 net187 net84 VPWR VPB pfet_01v8_hvt m=1 w=0.42 l=0.15 mult=1
+ sa=0.265 sb=0.265 sd=0.28 topography=normal area=0.063 perim=1.14
MI659 net84 RESET_B VPWR VPB pfet_01v8_hvt m=1 w=0.42 l=0.15 mult=1
+ sa=0.265 sb=0.265 sd=0.28 topography=normal area=0.063 perim=1.14
MI664 S0 clkpos net187 VPB pfet_01v8_hvt m=1 w=0.42 l=0.15 mult=1
+ sa=0.265 sb=0.265 sd=0.28 topography=normal area=0.063 perim=1.14
MI658 net84 S0 VPWR VPB pfet_01v8_hvt m=1 w=0.42 l=0.15 mult=1
+ sa=0.265 sb=0.265 sd=0.28 topography=normal area=0.063 perim=1.14
MI30 net166 M1 VPWR VPB pfet_01v8_hvt m=1 w=0.42 l=0.15 mult=1
+ sa=0.265 sb=0.265 sd=0.28 topography=normal area=0.063 perim=1.14
MI31 M0 clkneg net166 VPB pfet_01v8_hvt m=1 w=0.42 l=0.15 mult=1
+ sa=0.265 sb=0.265 sd=0.28 topography=normal area=0.063 perim=1.14
MI32 net166 RESET_B VPWR VPB pfet_01v8_hvt m=1 w=0.42 l=0.15 mult=1
+ sa=0.265 sb=0.265 sd=0.28 topography=normal area=0.063 perim=1.14
MI663 Q net84 VPWR VPB pfet_01v8_hvt m=2 w=1.0 l=0.15 mult=1 sa=0.265
+ sb=0.265 sd=0.28 topography=normal area=0.063 perim=1.14
MI648 M1 M0 VPWR VPB pfet_01v8_hvt m=1 w=0.84 l=0.15 mult=1 sa=0.265
+ sb=0.265 sd=0.28 topography=normal area=0.063 perim=1.14
MI650 M1 clkneg S0 VPB pfet_01v8_hvt m=1 w=0.42 l=0.15 mult=1 sa=0.265
+ sb=0.265 sd=0.28 topography=normal area=0.063 perim=1.14
MI633 sceb SCE VPWR VPB pfet_01v8_hvt m=1 w=0.54 l=0.15 mult=1
+ sa=0.265 sb=0.265 sd=0.28 topography=normal area=0.063 perim=1.14
MI101 db sceb p1 VPB pfet_01v8_hvt m=1 w=0.54 l=0.15 mult=1 sa=0.265
+ sb=0.265 sd=0.28 topography=normal area=0.063 perim=1.14
MI107 p0 SCE VPWR VPB pfet_01v8_hvt m=1 w=0.54 l=0.15 mult=1 sa=0.265
+ sb=0.265 sd=0.28 topography=normal area=0.063 perim=1.14
MI94 db D p0 VPB pfet_01v8_hvt m=1 w=0.54 l=0.15 mult=1 sa=0.265
+ sb=0.265 sd=0.28 topography=normal area=0.063 perim=1.14
MI108 p1 SCD VPWR VPB pfet_01v8_hvt m=1 w=0.54 l=0.15 mult=1 sa=0.265
+ sb=0.265 sd=0.28 topography=normal area=0.063 perim=1.14
.ENDS

.SUBCKT sky130_fd_sc_hd__sdfrtp_4 CLK D RESET_B SCD SCE VGND VNB VPB VPWR Q
MI642 clkneg CLK VGND VNB nfet_01v8 m=1 w=0.65 l=0.15 mult=1 sa=0.265
+ sb=0.265 sd=0.28 topography=normal area=0.063 perim=1.14
MI636 clkpos clkneg VGND VNB nfet_01v8 m=1 w=0.65 l=0.15 mult=1
+ sa=0.265 sb=0.265 sd=0.28 topography=normal area=0.063 perim=1.14
MI42 db clkneg M0 VNB nfet_01v8 m=1 w=0.36 l=0.15 mult=1 sa=0.265
+ sb=0.265 sd=0.28 topography=normal area=0.063 perim=1.14
MI656 net84 S0 net114 VNB nfet_01v8 m=1 w=0.42 l=0.15 mult=1 sa=0.265
+ sb=0.265 sd=0.28 topography=normal area=0.063 perim=1.14
MI657 net114 RESET_B VGND VNB nfet_01v8 m=1 w=0.42 l=0.15 mult=1
+ sa=0.265 sb=0.265 sd=0.28 topography=normal area=0.063 perim=1.14
MI33 net107 RESET_B VGND VNB nfet_01v8 m=1 w=0.42 l=0.15 mult=1
+ sa=0.265 sb=0.265 sd=0.28 topography=normal area=0.063 perim=1.14
MI634 sceb SCE VGND VNB nfet_01v8 m=1 w=0.42 l=0.15 mult=1 sa=0.265
+ sb=0.265 sd=0.28 topography=normal area=0.063 perim=1.14
MI4 M0 clkpos net95 VNB nfet_01v8 m=1 w=0.36 l=0.15 mult=1 sa=0.265
+ sb=0.265 sd=0.28 topography=normal area=0.063 perim=1.14
MI34 net95 M1 net107 VNB nfet_01v8 m=1 w=0.42 l=0.15 mult=1 sa=0.265
+ sb=0.265 sd=0.28 topography=normal area=0.063 perim=1.14
MI655 S0 clkneg net90 VNB nfet_01v8 m=1 w=0.36 l=0.15 mult=1 sa=0.265
+ sb=0.265 sd=0.28 topography=normal area=0.063 perim=1.14
MI652 Q net84 VGND VNB nfet_01v8 m=4 w=0.65 l=0.15 mult=1 sa=0.265
+ sb=0.265 sd=0.28 topography=normal area=0.063 perim=1.14
MI654 net90 net84 VGND VNB nfet_01v8 m=1 w=0.42 l=0.15 mult=1 sa=0.265
+ sb=0.265 sd=0.28 topography=normal area=0.063 perim=1.14
MI647 M1 M0 VGND VNB nfet_01v8 m=1 w=0.64 l=0.15 mult=1 sa=0.265
+ sb=0.265 sd=0.28 topography=normal area=0.063 perim=1.14
MI649 M1 clkpos S0 VNB nfet_01v8 m=1 w=0.36 l=0.15 mult=1 sa=0.265
+ sb=0.265 sd=0.28 topography=normal area=0.063 perim=1.14
MI98 db D n0 VNB nfet_01v8 m=1 w=0.42 l=0.15 mult=1 sa=0.265 sb=0.265
+ sd=0.28 topography=normal area=0.525 perim=3.1
MI103 n1 SCD VGND VNB nfet_01v8 m=1 w=0.42 l=0.18 mult=1 sa=0.265
+ sb=0.265 sd=0.28 topography=normal area=0.525 perim=3.1
MI120 db SCE n1 VNB nfet_01v8 m=1 w=0.42 l=0.5 mult=1 sa=0.265
+ sb=0.265 sd=0.28 topography=normal area=0.525 perim=3.1
MI104 n0 sceb VGND VNB nfet_01v8 m=1 w=0.42 l=0.15 mult=1 sa=0.265
+ sb=0.265 sd=0.28 topography=normal area=0.525 perim=3.1
MI643 clkneg CLK VPWR VPB pfet_01v8_hvt m=1 w=1.0 l=0.15 mult=1
+ sa=0.265 sb=0.265 sd=0.28 topography=normal area=0.063 perim=1.14
MI635 clkpos clkneg VPWR VPB pfet_01v8_hvt m=1 w=1.0 l=0.15 mult=1
+ sa=0.265 sb=0.265 sd=0.28 topography=normal area=0.063 perim=1.14
MI43 db clkpos M0 VPB pfet_01v8_hvt m=1 w=0.42 l=0.15 mult=1 sa=0.265
+ sb=0.265 sd=0.28 topography=normal area=0.063 perim=1.14
MI662 net187 net84 VPWR VPB pfet_01v8_hvt m=1 w=0.42 l=0.15 mult=1
+ sa=0.265 sb=0.265 sd=0.28 topography=normal area=0.063 perim=1.14
MI659 net84 RESET_B VPWR VPB pfet_01v8_hvt m=1 w=0.42 l=0.15 mult=1
+ sa=0.265 sb=0.265 sd=0.28 topography=normal area=0.063 perim=1.14
MI664 S0 clkpos net187 VPB pfet_01v8_hvt m=1 w=0.42 l=0.15 mult=1
+ sa=0.265 sb=0.265 sd=0.28 topography=normal area=0.063 perim=1.14
MI658 net84 S0 VPWR VPB pfet_01v8_hvt m=1 w=0.42 l=0.15 mult=1
+ sa=0.265 sb=0.265 sd=0.28 topography=normal area=0.063 perim=1.14
MI30 net166 M1 VPWR VPB pfet_01v8_hvt m=1 w=0.42 l=0.15 mult=1
+ sa=0.265 sb=0.265 sd=0.28 topography=normal area=0.063 perim=1.14
MI31 M0 clkneg net166 VPB pfet_01v8_hvt m=1 w=0.42 l=0.15 mult=1
+ sa=0.265 sb=0.265 sd=0.28 topography=normal area=0.063 perim=1.14
MI32 net166 RESET_B VPWR VPB pfet_01v8_hvt m=1 w=0.42 l=0.15 mult=1
+ sa=0.265 sb=0.265 sd=0.28 topography=normal area=0.063 perim=1.14
MI663 Q net84 VPWR VPB pfet_01v8_hvt m=4 w=1.0 l=0.15 mult=1 sa=0.265
+ sb=0.265 sd=0.28 topography=normal area=0.063 perim=1.14
MI648 M1 M0 VPWR VPB pfet_01v8_hvt m=1 w=0.84 l=0.15 mult=1 sa=0.265
+ sb=0.265 sd=0.28 topography=normal area=0.063 perim=1.14
MI650 M1 clkneg S0 VPB pfet_01v8_hvt m=1 w=0.42 l=0.15 mult=1 sa=0.265
+ sb=0.265 sd=0.28 topography=normal area=0.063 perim=1.14
MI633 sceb SCE VPWR VPB pfet_01v8_hvt m=1 w=0.54 l=0.15 mult=1
+ sa=0.265 sb=0.265 sd=0.28 topography=normal area=0.063 perim=1.14
MI101 db sceb p1 VPB pfet_01v8_hvt m=1 w=0.54 l=0.15 mult=1 sa=0.265
+ sb=0.265 sd=0.28 topography=normal area=0.063 perim=1.14
MI107 p0 SCE VPWR VPB pfet_01v8_hvt m=1 w=0.54 l=0.15 mult=1 sa=0.265
+ sb=0.265 sd=0.28 topography=normal area=0.063 perim=1.14
MI94 db D p0 VPB pfet_01v8_hvt m=1 w=0.54 l=0.15 mult=1 sa=0.265
+ sb=0.265 sd=0.28 topography=normal area=0.063 perim=1.14
MI108 p1 SCD VPWR VPB pfet_01v8_hvt m=1 w=0.54 l=0.15 mult=1 sa=0.265
+ sb=0.265 sd=0.28 topography=normal area=0.063 perim=1.14
.ENDS

.SUBCKT sky130_fd_sc_hd__sdfsbp_1 CLK D SCD SCE SET_B VGND VNB VPB VPWR Q Q_N
MI107 p0 SCE VPWR VPB pfet_01v8_hvt m=1 w=0.64 l=0.15 mult=1 sa=0.265
+ sb=0.265 sd=0.28 topography=normal area=0.063 perim=1.14
MI94 db D p0 VPB pfet_01v8_hvt m=1 w=0.64 l=0.15 mult=1 sa=0.265
+ sb=0.265 sd=0.28 topography=normal area=0.063 perim=1.14
MI101 db sceb p1 VPB pfet_01v8_hvt m=1 w=0.64 l=0.15 mult=1 sa=0.265
+ sb=0.265 sd=0.28 topography=normal area=0.063 perim=1.14
MI108 p1 SCD VPWR VPB pfet_01v8_hvt m=1 w=0.64 l=0.15 mult=1 sa=0.265
+ sb=0.265 sd=0.28 topography=normal area=0.063 perim=1.14
MI662 net159 M1 VPWR VPB pfet_01v8_hvt m=1 w=0.42 l=0.15 mult=1
+ sa=0.265 sb=0.265 sd=0.28 topography=normal area=0.063 perim=1.14
MI664 M0 clkneg net159 VPB pfet_01v8_hvt m=1 w=0.42 l=0.15 mult=1
+ sa=0.265 sb=0.265 sd=0.28 topography=normal area=0.063 perim=1.14
MI6 net138 S1 VPWR VPB pfet_01v8_hvt m=1 w=0.42 l=0.15 mult=1 sa=0.265
+ sb=0.265 sd=0.28 topography=normal area=0.063 perim=1.14
MI43 db clkpos M0 VPB pfet_01v8_hvt m=1 w=0.42 l=0.15 mult=1 sa=0.265
+ sb=0.265 sd=0.28 topography=normal area=0.063 perim=1.14
MI45 clkneg CLK VPWR VPB pfet_01v8_hvt m=1 w=0.64 l=0.15 mult=1
+ sa=0.265 sb=0.265 sd=0.28 topography=normal area=0.063 perim=1.14
MI669 S0 clkpos net138 VPB pfet_01v8_hvt m=1 w=0.42 l=0.15 mult=1
+ sa=0.265 sb=0.265 sd=0.28 topography=normal area=0.063 perim=1.14
MI658 M1 M0 VPWR VPB pfet_01v8_hvt m=1 w=0.42 l=0.15 mult=1 sa=0.265
+ sb=0.265 sd=0.28 topography=normal area=0.063 perim=1.14
MI661 Q_N S0 VPWR VPB pfet_01v8_hvt m=1 w=1.0 l=0.15 mult=1 sa=0.265
+ sb=0.265 sd=0.28 topography=normal area=0.063 perim=1.14
MI659 M1 SET_B VPWR VPB pfet_01v8_hvt m=1 w=0.42 l=0.15 mult=1
+ sa=0.265 sb=0.265 sd=0.28 topography=normal area=0.063 perim=1.14
MI645 sceb SCE VPWR VPB pfet_01v8_hvt m=1 w=0.64 l=0.15 mult=1
+ sa=0.265 sb=0.265 sd=0.28 topography=normal area=0.063 perim=1.14
MI663 net199 S0 VPWR VPB pfet_01v8_hvt m=1 w=0.64 l=0.15 mult=1
+ sa=0.265 sb=0.265 sd=0.28 topography=normal area=0.063 perim=1.14
MI47 clkpos clkneg VPWR VPB pfet_01v8_hvt m=1 w=0.64 l=0.15 mult=1
+ sa=0.265 sb=0.265 sd=0.28 topography=normal area=0.063 perim=1.14
MI660 Q net199 VPWR VPB pfet_01v8_hvt m=1 w=1.0 l=0.15 mult=1 sa=0.265
+ sb=0.265 sd=0.28 topography=normal area=0.063 perim=1.14
MI24 S0 SET_B VPWR VPB pfet_01v8_hvt m=1 w=0.42 l=0.15 mult=1 sa=0.265
+ sb=0.265 sd=0.28 topography=normal area=0.063 perim=1.14
MI648 S1 S0 VPWR VPB pfet_01v8_hvt m=1 w=0.42 l=0.15 mult=1 sa=0.265
+ sb=0.265 sd=0.28 topography=normal area=0.063 perim=1.14
MI38 S0 clkneg net98 VPB pfet_01v8_hvt m=1 w=0.84 l=0.15 mult=1
+ sa=0.265 sb=0.265 sd=0.28 topography=normal area=0.063 perim=1.14
MI37 net98 M0 VPWR VPB pfet_01v8_hvt m=1 w=0.84 l=0.15 mult=1 sa=0.265
+ sb=0.265 sd=0.28 topography=normal area=0.063 perim=1.14
MI120 db SCE n1 VNB nfet_01v8 m=1 w=0.42 l=0.15 mult=1 sa=0.265
+ sb=0.265 sd=0.28 topography=normal area=0.525 perim=3.1
MI104 n0 sceb VGND VNB nfet_01v8 m=1 w=0.42 l=0.15 mult=1 sa=0.265
+ sb=0.265 sd=0.28 topography=normal area=0.525 perim=3.1
MI103 n1 SCD VGND VNB nfet_01v8 m=1 w=0.42 l=0.15 mult=1 sa=0.265
+ sb=0.265 sd=0.28 topography=normal area=0.525 perim=3.1
MI98 db D n0 VNB nfet_01v8 m=1 w=0.42 l=0.15 mult=1 sa=0.265 sb=0.265
+ sd=0.28 topography=normal area=0.525 perim=3.1
MI27 net243 S1 net215 VNB nfet_01v8 m=1 w=0.42 l=0.15 mult=1 sa=0.265
+ sb=0.265 sd=0.28 topography=normal area=0.063 perim=1.14
MI647 S1 S0 VGND VNB nfet_01v8 m=1 w=0.42 l=0.15 mult=1 sa=0.265
+ sb=0.265 sd=0.28 topography=normal area=0.063 perim=1.14
MI46 clkpos clkneg VGND VNB nfet_01v8 m=1 w=0.42 l=0.15 mult=1
+ sa=0.265 sb=0.265 sd=0.28 topography=normal area=0.063 perim=1.14
MI34 S0 clkpos net230 VNB nfet_01v8 m=1 w=0.64 l=0.15 mult=1 sa=0.265
+ sb=0.265 sd=0.28 topography=normal area=0.063 perim=1.14
MI657 net227 SET_B VGND VNB nfet_01v8 m=1 w=0.42 l=0.15 mult=1
+ sa=0.265 sb=0.265 sd=0.28 topography=normal area=0.063 perim=1.14
MI653 Q net199 VGND VNB nfet_01v8 m=1 w=0.65 l=0.15 mult=1 sa=0.265
+ sb=0.265 sd=0.28 topography=normal area=0.063 perim=1.14
MI644 sceb SCE VGND VNB nfet_01v8 m=1 w=0.42 l=0.15 mult=1 sa=0.265
+ sb=0.265 sd=0.28 topography=normal area=0.063 perim=1.14
MI25 net215 SET_B VGND VNB nfet_01v8 m=1 w=0.42 l=0.15 mult=1 sa=0.265
+ sb=0.265 sd=0.28 topography=normal area=0.063 perim=1.14
MI651 Q_N S0 VGND VNB nfet_01v8 m=1 w=0.65 l=0.15 mult=1 sa=0.265
+ sb=0.265 sd=0.28 topography=normal area=0.063 perim=1.14
MI655 M0 clkpos net206 VNB nfet_01v8 m=1 w=0.42 l=0.15 mult=1 sa=0.265
+ sb=0.265 sd=0.28 topography=normal area=0.063 perim=1.14
MI44 clkneg CLK VGND VNB nfet_01v8 m=1 w=0.42 l=0.15 mult=1 sa=0.265
+ sb=0.265 sd=0.28 topography=normal area=0.063 perim=1.14
MI652 net199 S0 VGND VNB nfet_01v8 m=1 w=0.42 l=0.15 mult=1 sa=0.265
+ sb=0.265 sd=0.28 topography=normal area=0.063 perim=1.14
MI656 M1 M0 net227 VNB nfet_01v8 m=1 w=0.42 l=0.15 mult=1 sa=0.265
+ sb=0.265 sd=0.28 topography=normal area=0.063 perim=1.14
MI654 net206 M1 VGND VNB nfet_01v8 m=1 w=0.42 l=0.15 mult=1 sa=0.265
+ sb=0.265 sd=0.28 topography=normal area=0.063 perim=1.14
MI36 net230 M0 VGND VNB nfet_01v8 m=1 w=0.64 l=0.15 mult=1 sa=0.265
+ sb=0.265 sd=0.28 topography=normal area=0.063 perim=1.14
MI26 S0 clkneg net243 VNB nfet_01v8 m=1 w=0.42 l=0.15 mult=1 sa=0.265
+ sb=0.265 sd=0.28 topography=normal area=0.063 perim=1.14
MI42 db clkneg M0 VNB nfet_01v8 m=1 w=0.42 l=0.15 mult=1 sa=0.265
+ sb=0.265 sd=0.28 topography=normal area=0.063 perim=1.14
.ENDS

.SUBCKT sky130_fd_sc_hd__sdfsbp_2 CLK D SCD SCE SET_B VGND VNB VPB VPWR Q Q_N
MI101 db sceb p1 VPB pfet_01v8_hvt m=1 w=0.64 l=0.15 mult=1 sa=0.265
+ sb=0.265 sd=0.28 topography=normal area=0.063 perim=1.14
MI107 p0 SCE VPWR VPB pfet_01v8_hvt m=1 w=0.64 l=0.15 mult=1 sa=0.265
+ sb=0.265 sd=0.28 topography=normal area=0.063 perim=1.14
MI94 db D p0 VPB pfet_01v8_hvt m=1 w=0.64 l=0.15 mult=1 sa=0.265
+ sb=0.265 sd=0.28 topography=normal area=0.063 perim=1.14
MI108 p1 SCD VPWR VPB pfet_01v8_hvt m=1 w=0.64 l=0.15 mult=1 sa=0.265
+ sb=0.265 sd=0.28 topography=normal area=0.063 perim=1.14
MI645 sceb SCE VPWR VPB pfet_01v8_hvt m=1 w=0.64 l=0.15 mult=1
+ sa=0.265 sb=0.265 sd=0.28 topography=normal area=0.063 perim=1.14
MI658 M1 M0 VPWR VPB pfet_01v8_hvt m=1 w=0.42 l=0.15 mult=1 sa=0.265
+ sb=0.265 sd=0.28 topography=normal area=0.063 perim=1.14
MI47 clkpos clkneg VPWR VPB pfet_01v8_hvt m=1 w=0.64 l=0.15 mult=1
+ sa=0.265 sb=0.265 sd=0.28 topography=normal area=0.063 perim=1.14
MI663 net195 S0 VPWR VPB pfet_01v8_hvt m=1 w=0.64 l=0.15 mult=1
+ sa=0.265 sb=0.265 sd=0.28 topography=normal area=0.063 perim=1.14
MI660 Q net195 VPWR VPB pfet_01v8_hvt m=2 w=1.0 l=0.15 mult=1 sa=0.265
+ sb=0.265 sd=0.28 topography=normal area=0.063 perim=1.14
MI659 M1 SET_B VPWR VPB pfet_01v8_hvt m=1 w=0.42 l=0.15 mult=1
+ sa=0.265 sb=0.265 sd=0.28 topography=normal area=0.063 perim=1.14
MI662 net130 M1 VPWR VPB pfet_01v8_hvt m=1 w=0.42 l=0.15 mult=1
+ sa=0.265 sb=0.265 sd=0.28 topography=normal area=0.063 perim=1.14
MI664 M0 clkneg net130 VPB pfet_01v8_hvt m=1 w=0.42 l=0.15 mult=1
+ sa=0.265 sb=0.265 sd=0.28 topography=normal area=0.063 perim=1.14
MI6 net122 S1 VPWR VPB pfet_01v8_hvt m=1 w=0.42 l=0.15 mult=1 sa=0.265
+ sb=0.265 sd=0.28 topography=normal area=0.063 perim=1.14
MI669 S0 clkpos net122 VPB pfet_01v8_hvt m=1 w=0.42 l=0.15 mult=1
+ sa=0.265 sb=0.265 sd=0.28 topography=normal area=0.063 perim=1.14
MI24 S0 SET_B VPWR VPB pfet_01v8_hvt m=1 w=0.42 l=0.15 mult=1 sa=0.265
+ sb=0.265 sd=0.28 topography=normal area=0.063 perim=1.14
MI648 S1 S0 VPWR VPB pfet_01v8_hvt m=1 w=0.42 l=0.15 mult=1 sa=0.265
+ sb=0.265 sd=0.28 topography=normal area=0.063 perim=1.14
MI38 S0 clkneg net107 VPB pfet_01v8_hvt m=1 w=0.84 l=0.15 mult=1
+ sa=0.265 sb=0.265 sd=0.28 topography=normal area=0.063 perim=1.14
MI37 net107 M0 VPWR VPB pfet_01v8_hvt m=1 w=0.84 l=0.15 mult=1
+ sa=0.265 sb=0.265 sd=0.28 topography=normal area=0.063 perim=1.14
MI43 db clkpos M0 VPB pfet_01v8_hvt m=1 w=0.42 l=0.15 mult=1 sa=0.265
+ sb=0.265 sd=0.28 topography=normal area=0.063 perim=1.14
MI45 clkneg CLK VPWR VPB pfet_01v8_hvt m=1 w=0.64 l=0.15 mult=1
+ sa=0.265 sb=0.265 sd=0.28 topography=normal area=0.063 perim=1.14
MI661 Q_N S0 VPWR VPB pfet_01v8_hvt m=2 w=1.0 l=0.15 mult=1 sa=0.265
+ sb=0.265 sd=0.28 topography=normal area=0.063 perim=1.14
MI98 db D n0 VNB nfet_01v8 m=1 w=0.42 l=0.15 mult=1 sa=0.265 sb=0.265
+ sd=0.28 topography=normal area=0.525 perim=3.1
MI103 n1 SCD VGND VNB nfet_01v8 m=1 w=0.42 l=0.15 mult=1 sa=0.265
+ sb=0.265 sd=0.28 topography=normal area=0.525 perim=3.1
MI120 db SCE n1 VNB nfet_01v8 m=1 w=0.42 l=0.15 mult=1 sa=0.265
+ sb=0.265 sd=0.28 topography=normal area=0.525 perim=3.1
MI104 n0 sceb VGND VNB nfet_01v8 m=1 w=0.42 l=0.15 mult=1 sa=0.265
+ sb=0.265 sd=0.28 topography=normal area=0.525 perim=3.1
MI34 S0 clkpos net219 VNB nfet_01v8 m=1 w=0.64 l=0.15 mult=1 sa=0.265
+ sb=0.265 sd=0.28 topography=normal area=0.063 perim=1.14
MI27 net239 S1 net187 VNB nfet_01v8 m=1 w=0.42 l=0.15 mult=1 sa=0.265
+ sb=0.265 sd=0.28 topography=normal area=0.063 perim=1.14
MI647 S1 S0 VGND VNB nfet_01v8 m=1 w=0.42 l=0.15 mult=1 sa=0.265
+ sb=0.265 sd=0.28 topography=normal area=0.063 perim=1.14
MI655 M0 clkpos net230 VNB nfet_01v8 m=1 w=0.42 l=0.15 mult=1 sa=0.265
+ sb=0.265 sd=0.28 topography=normal area=0.063 perim=1.14
MI656 M1 M0 net199 VNB nfet_01v8 m=1 w=0.42 l=0.15 mult=1 sa=0.265
+ sb=0.265 sd=0.28 topography=normal area=0.063 perim=1.14
MI654 net230 M1 VGND VNB nfet_01v8 m=1 w=0.42 l=0.15 mult=1 sa=0.265
+ sb=0.265 sd=0.28 topography=normal area=0.063 perim=1.14
MI36 net219 M0 VGND VNB nfet_01v8 m=1 w=0.64 l=0.15 mult=1 sa=0.265
+ sb=0.265 sd=0.28 topography=normal area=0.063 perim=1.14
MI26 S0 clkneg net239 VNB nfet_01v8 m=1 w=0.42 l=0.15 mult=1 sa=0.265
+ sb=0.265 sd=0.28 topography=normal area=0.063 perim=1.14
MI42 db clkneg M0 VNB nfet_01v8 m=1 w=0.42 l=0.15 mult=1 sa=0.265
+ sb=0.265 sd=0.28 topography=normal area=0.063 perim=1.14
MI46 clkpos clkneg VGND VNB nfet_01v8 m=1 w=0.42 l=0.15 mult=1
+ sa=0.265 sb=0.265 sd=0.28 topography=normal area=0.063 perim=1.14
MI44 clkneg CLK VGND VNB nfet_01v8 m=1 w=0.42 l=0.15 mult=1 sa=0.265
+ sb=0.265 sd=0.28 topography=normal area=0.063 perim=1.14
MI657 net199 SET_B VGND VNB nfet_01v8 m=1 w=0.42 l=0.15 mult=1
+ sa=0.265 sb=0.265 sd=0.28 topography=normal area=0.063 perim=1.14
MI652 net195 S0 VGND VNB nfet_01v8 m=1 w=0.42 l=0.15 mult=1 sa=0.265
+ sb=0.265 sd=0.28 topography=normal area=0.063 perim=1.14
MI644 sceb SCE VGND VNB nfet_01v8 m=1 w=0.42 l=0.15 mult=1 sa=0.265
+ sb=0.265 sd=0.28 topography=normal area=0.063 perim=1.14
MI25 net187 SET_B VGND VNB nfet_01v8 m=1 w=0.42 l=0.15 mult=1 sa=0.265
+ sb=0.265 sd=0.28 topography=normal area=0.063 perim=1.14
MI653 Q net195 VGND VNB nfet_01v8 m=2 w=0.65 l=0.15 mult=1 sa=0.265
+ sb=0.265 sd=0.28 topography=normal area=0.063 perim=1.14
MI651 Q_N S0 VGND VNB nfet_01v8 m=2 w=0.65 l=0.15 mult=1 sa=0.265
+ sb=0.265 sd=0.28 topography=normal area=0.063 perim=1.14
.ENDS

.SUBCKT sky130_fd_sc_hd__sdfstp_1 CLK D SCD SCE SET_B VGND VNB VPB VPWR Q
MI645 sceb SCE VPWR VPB pfet_01v8_hvt m=1 w=0.64 l=0.15 mult=1
+ sa=0.265 sb=0.265 sd=0.28 topography=normal area=0.063 perim=1.14
MI658 M1 M0 VPWR VPB pfet_01v8_hvt m=1 w=0.42 l=0.15 mult=1 sa=0.265
+ sb=0.265 sd=0.28 topography=normal area=0.063 perim=1.14
MI47 clkpos clkneg VPWR VPB pfet_01v8_hvt m=1 w=0.64 l=0.15 mult=1
+ sa=0.265 sb=0.265 sd=0.28 topography=normal area=0.063 perim=1.14
MI663 net165 S0 VPWR VPB pfet_01v8_hvt m=1 w=0.64 l=0.15 mult=1
+ sa=0.265 sb=0.265 sd=0.28 topography=normal area=0.063 perim=1.14
MI660 Q net165 VPWR VPB pfet_01v8_hvt m=1 w=1.0 l=0.15 mult=1 sa=0.265
+ sb=0.265 sd=0.28 topography=normal area=0.063 perim=1.14
MI659 M1 SET_B VPWR VPB pfet_01v8_hvt m=1 w=0.42 l=0.15 mult=1
+ sa=0.265 sb=0.265 sd=0.28 topography=normal area=0.063 perim=1.14
MI662 net109 M1 VPWR VPB pfet_01v8_hvt m=1 w=0.42 l=0.15 mult=1
+ sa=0.265 sb=0.265 sd=0.28 topography=normal area=0.063 perim=1.14
MI664 M0 clkneg net109 VPB pfet_01v8_hvt m=1 w=0.42 l=0.15 mult=1
+ sa=0.265 sb=0.265 sd=0.28 topography=normal area=0.063 perim=1.14
MI6 net96 S1 VPWR VPB pfet_01v8_hvt m=1 w=0.42 l=0.15 mult=1 sa=0.265
+ sb=0.265 sd=0.28 topography=normal area=0.063 perim=1.14
MI669 S0 clkpos net96 VPB pfet_01v8_hvt m=1 w=0.42 l=0.15 mult=1
+ sa=0.265 sb=0.265 sd=0.28 topography=normal area=0.063 perim=1.14
MI24 S0 SET_B VPWR VPB pfet_01v8_hvt m=1 w=0.42 l=0.15 mult=1 sa=0.265
+ sb=0.265 sd=0.28 topography=normal area=0.063 perim=1.14
MI648 S1 S0 VPWR VPB pfet_01v8_hvt m=1 w=0.42 l=0.15 mult=1 sa=0.265
+ sb=0.265 sd=0.28 topography=normal area=0.063 perim=1.14
MI38 S0 clkneg net84 VPB pfet_01v8_hvt m=1 w=0.84 l=0.15 mult=1
+ sa=0.265 sb=0.265 sd=0.28 topography=normal area=0.063 perim=1.14
MI37 net84 M0 VPWR VPB pfet_01v8_hvt m=1 w=0.84 l=0.15 mult=1 sa=0.265
+ sb=0.265 sd=0.28 topography=normal area=0.063 perim=1.14
MI43 db clkpos M0 VPB pfet_01v8_hvt m=1 w=0.42 l=0.15 mult=1 sa=0.265
+ sb=0.265 sd=0.28 topography=normal area=0.063 perim=1.14
MI45 clkneg CLK VPWR VPB pfet_01v8_hvt m=1 w=0.64 l=0.15 mult=1
+ sa=0.265 sb=0.265 sd=0.28 topography=normal area=0.063 perim=1.14
MI101 db sceb p1 VPB pfet_01v8_hvt m=1 w=0.64 l=0.15 mult=1 sa=0.265
+ sb=0.265 sd=0.28 topography=normal area=0.063 perim=1.14
MI107 p0 SCE VPWR VPB pfet_01v8_hvt m=1 w=0.64 l=0.15 mult=1 sa=0.265
+ sb=0.265 sd=0.28 topography=normal area=0.063 perim=1.14
MI94 db D p0 VPB pfet_01v8_hvt m=1 w=0.64 l=0.15 mult=1 sa=0.265
+ sb=0.265 sd=0.28 topography=normal area=0.063 perim=1.14
MI108 p1 SCD VPWR VPB pfet_01v8_hvt m=1 w=0.64 l=0.15 mult=1 sa=0.265
+ sb=0.265 sd=0.28 topography=normal area=0.063 perim=1.14
MI34 S0 clkpos net189 VNB nfet_01v8 m=1 w=0.64 l=0.15 mult=1 sa=0.265
+ sb=0.265 sd=0.28 topography=normal area=0.063 perim=1.14
MI27 net209 S1 net157 VNB nfet_01v8 m=1 w=0.42 l=0.15 mult=1 sa=0.265
+ sb=0.265 sd=0.28 topography=normal area=0.063 perim=1.14
MI647 S1 S0 VGND VNB nfet_01v8 m=1 w=0.42 l=0.15 mult=1 sa=0.265
+ sb=0.265 sd=0.28 topography=normal area=0.063 perim=1.14
MI655 M0 clkpos net200 VNB nfet_01v8 m=1 w=0.42 l=0.15 mult=1 sa=0.265
+ sb=0.265 sd=0.28 topography=normal area=0.063 perim=1.14
MI656 M1 M0 net169 VNB nfet_01v8 m=1 w=0.42 l=0.15 mult=1 sa=0.265
+ sb=0.265 sd=0.28 topography=normal area=0.063 perim=1.14
MI654 net200 M1 VGND VNB nfet_01v8 m=1 w=0.42 l=0.15 mult=1 sa=0.265
+ sb=0.265 sd=0.28 topography=normal area=0.063 perim=1.14
MI36 net189 M0 VGND VNB nfet_01v8 m=1 w=0.64 l=0.15 mult=1 sa=0.265
+ sb=0.265 sd=0.28 topography=normal area=0.063 perim=1.14
MI26 S0 clkneg net209 VNB nfet_01v8 m=1 w=0.42 l=0.15 mult=1 sa=0.265
+ sb=0.265 sd=0.28 topography=normal area=0.063 perim=1.14
MI42 db clkneg M0 VNB nfet_01v8 m=1 w=0.42 l=0.15 mult=1 sa=0.265
+ sb=0.265 sd=0.28 topography=normal area=0.063 perim=1.14
MI46 clkpos clkneg VGND VNB nfet_01v8 m=1 w=0.42 l=0.15 mult=1
+ sa=0.265 sb=0.265 sd=0.28 topography=normal area=0.063 perim=1.14
MI44 clkneg CLK VGND VNB nfet_01v8 m=1 w=0.42 l=0.15 mult=1 sa=0.265
+ sb=0.265 sd=0.28 topography=normal area=0.063 perim=1.14
MI657 net169 SET_B VGND VNB nfet_01v8 m=1 w=0.42 l=0.15 mult=1
+ sa=0.265 sb=0.265 sd=0.28 topography=normal area=0.063 perim=1.14
MI652 net165 S0 VGND VNB nfet_01v8 m=1 w=0.42 l=0.15 mult=1 sa=0.265
+ sb=0.265 sd=0.28 topography=normal area=0.063 perim=1.14
MI644 sceb SCE VGND VNB nfet_01v8 m=1 w=0.42 l=0.15 mult=1 sa=0.265
+ sb=0.265 sd=0.28 topography=normal area=0.063 perim=1.14
MI25 net157 SET_B VGND VNB nfet_01v8 m=1 w=0.42 l=0.15 mult=1 sa=0.265
+ sb=0.265 sd=0.28 topography=normal area=0.063 perim=1.14
MI653 Q net165 VGND VNB nfet_01v8 m=1 w=0.65 l=0.15 mult=1 sa=0.265
+ sb=0.265 sd=0.28 topography=normal area=0.063 perim=1.14
MI98 db D n0 VNB nfet_01v8 m=1 w=0.42 l=0.15 mult=1 sa=0.265 sb=0.265
+ sd=0.28 topography=normal area=0.525 perim=3.1
MI103 n1 SCD VGND VNB nfet_01v8 m=1 w=0.42 l=0.15 mult=1 sa=0.265
+ sb=0.265 sd=0.28 topography=normal area=0.525 perim=3.1
MI120 db SCE n1 VNB nfet_01v8 m=1 w=0.42 l=0.15 mult=1 sa=0.265
+ sb=0.265 sd=0.28 topography=normal area=0.525 perim=3.1
MI104 n0 sceb VGND VNB nfet_01v8 m=1 w=0.42 l=0.15 mult=1 sa=0.265
+ sb=0.265 sd=0.28 topography=normal area=0.525 perim=3.1
.ENDS

.SUBCKT sky130_fd_sc_hd__sdfstp_2 CLK D SCD SCE SET_B VGND VNB VPB VPWR Q
MI645 sceb SCE VPWR VPB pfet_01v8_hvt m=1 w=0.64 l=0.15 mult=1
+ sa=0.265 sb=0.265 sd=0.28 topography=normal area=0.063 perim=1.14
MI658 M1 M0 VPWR VPB pfet_01v8_hvt m=1 w=0.42 l=0.15 mult=1 sa=0.265
+ sb=0.265 sd=0.28 topography=normal area=0.063 perim=1.14
MI47 clkpos clkneg VPWR VPB pfet_01v8_hvt m=1 w=0.64 l=0.15 mult=1
+ sa=0.265 sb=0.265 sd=0.28 topography=normal area=0.063 perim=1.14
MI663 net165 S0 VPWR VPB pfet_01v8_hvt m=1 w=0.64 l=0.15 mult=1
+ sa=0.265 sb=0.265 sd=0.28 topography=normal area=0.063 perim=1.14
MI660 Q net165 VPWR VPB pfet_01v8_hvt m=2 w=1.0 l=0.15 mult=1 sa=0.265
+ sb=0.265 sd=0.28 topography=normal area=0.063 perim=1.14
MI659 M1 SET_B VPWR VPB pfet_01v8_hvt m=1 w=0.42 l=0.15 mult=1
+ sa=0.265 sb=0.265 sd=0.28 topography=normal area=0.063 perim=1.14
MI662 net109 M1 VPWR VPB pfet_01v8_hvt m=1 w=0.42 l=0.15 mult=1
+ sa=0.265 sb=0.265 sd=0.28 topography=normal area=0.063 perim=1.14
MI664 M0 clkneg net109 VPB pfet_01v8_hvt m=1 w=0.42 l=0.15 mult=1
+ sa=0.265 sb=0.265 sd=0.28 topography=normal area=0.063 perim=1.14
MI6 net96 S1 VPWR VPB pfet_01v8_hvt m=1 w=0.42 l=0.15 mult=1 sa=0.265
+ sb=0.265 sd=0.28 topography=normal area=0.063 perim=1.14
MI669 S0 clkpos net96 VPB pfet_01v8_hvt m=1 w=0.42 l=0.15 mult=1
+ sa=0.265 sb=0.265 sd=0.28 topography=normal area=0.063 perim=1.14
MI24 S0 SET_B VPWR VPB pfet_01v8_hvt m=1 w=0.42 l=0.15 mult=1 sa=0.265
+ sb=0.265 sd=0.28 topography=normal area=0.063 perim=1.14
MI648 S1 S0 VPWR VPB pfet_01v8_hvt m=1 w=0.42 l=0.15 mult=1 sa=0.265
+ sb=0.265 sd=0.28 topography=normal area=0.063 perim=1.14
MI38 S0 clkneg net84 VPB pfet_01v8_hvt m=1 w=0.84 l=0.15 mult=1
+ sa=0.265 sb=0.265 sd=0.28 topography=normal area=0.063 perim=1.14
MI37 net84 M0 VPWR VPB pfet_01v8_hvt m=1 w=0.84 l=0.15 mult=1 sa=0.265
+ sb=0.265 sd=0.28 topography=normal area=0.063 perim=1.14
MI43 db clkpos M0 VPB pfet_01v8_hvt m=1 w=0.42 l=0.15 mult=1 sa=0.265
+ sb=0.265 sd=0.28 topography=normal area=0.063 perim=1.14
MI45 clkneg CLK VPWR VPB pfet_01v8_hvt m=1 w=0.64 l=0.15 mult=1
+ sa=0.265 sb=0.265 sd=0.28 topography=normal area=0.063 perim=1.14
MI101 db sceb p1 VPB pfet_01v8_hvt m=1 w=0.64 l=0.15 mult=1 sa=0.265
+ sb=0.265 sd=0.28 topography=normal area=0.063 perim=1.14
MI107 p0 SCE VPWR VPB pfet_01v8_hvt m=1 w=0.64 l=0.15 mult=1 sa=0.265
+ sb=0.265 sd=0.28 topography=normal area=0.063 perim=1.14
MI94 db D p0 VPB pfet_01v8_hvt m=1 w=0.64 l=0.15 mult=1 sa=0.265
+ sb=0.265 sd=0.28 topography=normal area=0.063 perim=1.14
MI108 p1 SCD VPWR VPB pfet_01v8_hvt m=1 w=0.64 l=0.15 mult=1 sa=0.265
+ sb=0.265 sd=0.28 topography=normal area=0.063 perim=1.14
MI34 S0 clkpos net212 VNB nfet_01v8 m=1 w=0.64 l=0.15 mult=1 sa=0.265
+ sb=0.265 sd=0.28 topography=normal area=0.063 perim=1.14
MI27 net209 S1 net157 VNB nfet_01v8 m=1 w=0.42 l=0.15 mult=1 sa=0.265
+ sb=0.265 sd=0.28 topography=normal area=0.063 perim=1.14
MI647 S1 S0 VGND VNB nfet_01v8 m=1 w=0.42 l=0.15 mult=1 sa=0.265
+ sb=0.265 sd=0.28 topography=normal area=0.063 perim=1.14
MI655 M0 clkpos net200 VNB nfet_01v8 m=1 w=0.42 l=0.15 mult=1 sa=0.265
+ sb=0.265 sd=0.28 topography=normal area=0.063 perim=1.14
MI656 M1 M0 net196 VNB nfet_01v8 m=1 w=0.42 l=0.15 mult=1 sa=0.265
+ sb=0.265 sd=0.28 topography=normal area=0.063 perim=1.14
MI654 net200 M1 VGND VNB nfet_01v8 m=1 w=0.42 l=0.15 mult=1 sa=0.265
+ sb=0.265 sd=0.28 topography=normal area=0.063 perim=1.14
MI36 net212 M0 VGND VNB nfet_01v8 m=1 w=0.64 l=0.15 mult=1 sa=0.265
+ sb=0.265 sd=0.28 topography=normal area=0.063 perim=1.14
MI26 S0 clkneg net209 VNB nfet_01v8 m=1 w=0.42 l=0.15 mult=1 sa=0.265
+ sb=0.265 sd=0.28 topography=normal area=0.063 perim=1.14
MI42 db clkneg M0 VNB nfet_01v8 m=1 w=0.42 l=0.15 mult=1 sa=0.265
+ sb=0.265 sd=0.28 topography=normal area=0.063 perim=1.14
MI46 clkpos clkneg VGND VNB nfet_01v8 m=1 w=0.42 l=0.15 mult=1
+ sa=0.265 sb=0.265 sd=0.28 topography=normal area=0.063 perim=1.14
MI44 clkneg CLK VGND VNB nfet_01v8 m=1 w=0.42 l=0.15 mult=1 sa=0.265
+ sb=0.265 sd=0.28 topography=normal area=0.063 perim=1.14
MI657 net196 SET_B VGND VNB nfet_01v8 m=1 w=0.42 l=0.15 mult=1
+ sa=0.265 sb=0.265 sd=0.28 topography=normal area=0.063 perim=1.14
MI652 net165 S0 VGND VNB nfet_01v8 m=1 w=0.42 l=0.15 mult=1 sa=0.265
+ sb=0.265 sd=0.28 topography=normal area=0.063 perim=1.14
MI644 sceb SCE VGND VNB nfet_01v8 m=1 w=0.42 l=0.15 mult=1 sa=0.265
+ sb=0.265 sd=0.28 topography=normal area=0.063 perim=1.14
MI25 net157 SET_B VGND VNB nfet_01v8 m=1 w=0.42 l=0.15 mult=1 sa=0.265
+ sb=0.265 sd=0.28 topography=normal area=0.063 perim=1.14
MI653 Q net165 VGND VNB nfet_01v8 m=2 w=0.65 l=0.15 mult=1 sa=0.265
+ sb=0.265 sd=0.28 topography=normal area=0.063 perim=1.14
MI98 db D n0 VNB nfet_01v8 m=1 w=0.42 l=0.15 mult=1 sa=0.265 sb=0.265
+ sd=0.28 topography=normal area=0.525 perim=3.1
MI103 n1 SCD VGND VNB nfet_01v8 m=1 w=0.42 l=0.15 mult=1 sa=0.265
+ sb=0.265 sd=0.28 topography=normal area=0.525 perim=3.1
MI120 db SCE n1 VNB nfet_01v8 m=1 w=0.42 l=0.15 mult=1 sa=0.265
+ sb=0.265 sd=0.28 topography=normal area=0.525 perim=3.1
MI104 n0 sceb VGND VNB nfet_01v8 m=1 w=0.42 l=0.15 mult=1 sa=0.265
+ sb=0.265 sd=0.28 topography=normal area=0.525 perim=3.1
.ENDS

.SUBCKT sky130_fd_sc_hd__sdfstp_4 CLK D SCD SCE SET_B VGND VNB VPB VPWR Q
MI645 sceb SCE VPWR VPB pfet_01v8_hvt m=1 w=0.64 l=0.15 mult=1
+ sa=0.265 sb=0.265 sd=0.28 topography=normal area=0.063 perim=1.14
MI658 M1 M0 VPWR VPB pfet_01v8_hvt m=1 w=0.42 l=0.15 mult=1 sa=0.265
+ sb=0.265 sd=0.28 topography=normal area=0.063 perim=1.14
MI47 clkpos clkneg VPWR VPB pfet_01v8_hvt m=1 w=0.64 l=0.15 mult=1
+ sa=0.265 sb=0.265 sd=0.28 topography=normal area=0.063 perim=1.14
MI663 net165 S0 VPWR VPB pfet_01v8_hvt m=1 w=1.0 l=0.15 mult=1
+ sa=0.265 sb=0.265 sd=0.28 topography=normal area=0.063 perim=1.14
MI660 Q net165 VPWR VPB pfet_01v8_hvt m=4 w=1.0 l=0.15 mult=1 sa=0.265
+ sb=0.265 sd=0.28 topography=normal area=0.063 perim=1.14
MI659 M1 SET_B VPWR VPB pfet_01v8_hvt m=1 w=0.42 l=0.15 mult=1
+ sa=0.265 sb=0.265 sd=0.28 topography=normal area=0.063 perim=1.14
MI662 net104 M1 VPWR VPB pfet_01v8_hvt m=1 w=0.42 l=0.15 mult=1
+ sa=0.265 sb=0.265 sd=0.28 topography=normal area=0.063 perim=1.14
MI664 M0 clkneg net104 VPB pfet_01v8_hvt m=1 w=0.42 l=0.15 mult=1
+ sa=0.265 sb=0.265 sd=0.28 topography=normal area=0.063 perim=1.14
MI6 net96 S1 VPWR VPB pfet_01v8_hvt m=1 w=0.42 l=0.15 mult=1 sa=0.265
+ sb=0.265 sd=0.28 topography=normal area=0.063 perim=1.14
MI669 S0 clkpos net96 VPB pfet_01v8_hvt m=1 w=0.42 l=0.15 mult=1
+ sa=0.265 sb=0.265 sd=0.28 topography=normal area=0.063 perim=1.14
MI24 S0 SET_B VPWR VPB pfet_01v8_hvt m=1 w=0.42 l=0.15 mult=1 sa=0.265
+ sb=0.265 sd=0.28 topography=normal area=0.063 perim=1.14
MI648 S1 S0 VPWR VPB pfet_01v8_hvt m=1 w=0.42 l=0.15 mult=1 sa=0.265
+ sb=0.265 sd=0.28 topography=normal area=0.063 perim=1.14
MI38 S0 clkneg net84 VPB pfet_01v8_hvt m=1 w=0.84 l=0.15 mult=1
+ sa=0.265 sb=0.265 sd=0.28 topography=normal area=0.063 perim=1.14
MI37 net84 M0 VPWR VPB pfet_01v8_hvt m=1 w=0.84 l=0.15 mult=1 sa=0.265
+ sb=0.265 sd=0.28 topography=normal area=0.063 perim=1.14
MI43 db clkpos M0 VPB pfet_01v8_hvt m=1 w=0.42 l=0.15 mult=1 sa=0.265
+ sb=0.265 sd=0.28 topography=normal area=0.063 perim=1.14
MI45 clkneg CLK VPWR VPB pfet_01v8_hvt m=1 w=0.64 l=0.15 mult=1
+ sa=0.265 sb=0.265 sd=0.28 topography=normal area=0.063 perim=1.14
MI101 db sceb p1 VPB pfet_01v8_hvt m=1 w=0.64 l=0.15 mult=1 sa=0.265
+ sb=0.265 sd=0.28 topography=normal area=0.063 perim=1.14
MI107 p0 SCE VPWR VPB pfet_01v8_hvt m=1 w=0.64 l=0.15 mult=1 sa=0.265
+ sb=0.265 sd=0.28 topography=normal area=0.063 perim=1.14
MI94 db D p0 VPB pfet_01v8_hvt m=1 w=0.64 l=0.15 mult=1 sa=0.265
+ sb=0.265 sd=0.28 topography=normal area=0.063 perim=1.14
MI108 p1 SCD VPWR VPB pfet_01v8_hvt m=1 w=0.64 l=0.15 mult=1 sa=0.265
+ sb=0.265 sd=0.28 topography=normal area=0.063 perim=1.14
MI34 S0 clkpos net189 VNB nfet_01v8 m=1 w=0.64 l=0.15 mult=1 sa=0.265
+ sb=0.265 sd=0.28 topography=normal area=0.063 perim=1.14
MI27 net209 S1 net157 VNB nfet_01v8 m=1 w=0.42 l=0.15 mult=1 sa=0.265
+ sb=0.265 sd=0.28 topography=normal area=0.063 perim=1.14
MI647 S1 S0 VGND VNB nfet_01v8 m=1 w=0.42 l=0.15 mult=1 sa=0.265
+ sb=0.265 sd=0.28 topography=normal area=0.063 perim=1.14
MI655 M0 clkpos net200 VNB nfet_01v8 m=1 w=0.42 l=0.15 mult=1 sa=0.265
+ sb=0.265 sd=0.28 topography=normal area=0.063 perim=1.14
MI656 M1 M0 net169 VNB nfet_01v8 m=1 w=0.42 l=0.15 mult=1 sa=0.265
+ sb=0.265 sd=0.28 topography=normal area=0.063 perim=1.14
MI654 net200 M1 VGND VNB nfet_01v8 m=1 w=0.42 l=0.15 mult=1 sa=0.265
+ sb=0.265 sd=0.28 topography=normal area=0.063 perim=1.14
MI36 net189 M0 VGND VNB nfet_01v8 m=1 w=0.64 l=0.15 mult=1 sa=0.265
+ sb=0.265 sd=0.28 topography=normal area=0.063 perim=1.14
MI26 S0 clkneg net209 VNB nfet_01v8 m=1 w=0.42 l=0.15 mult=1 sa=0.265
+ sb=0.265 sd=0.28 topography=normal area=0.063 perim=1.14
MI42 db clkneg M0 VNB nfet_01v8 m=1 w=0.42 l=0.15 mult=1 sa=0.265
+ sb=0.265 sd=0.28 topography=normal area=0.063 perim=1.14
MI46 clkpos clkneg VGND VNB nfet_01v8 m=1 w=0.42 l=0.15 mult=1
+ sa=0.265 sb=0.265 sd=0.28 topography=normal area=0.063 perim=1.14
MI44 clkneg CLK VGND VNB nfet_01v8 m=1 w=0.42 l=0.15 mult=1 sa=0.265
+ sb=0.265 sd=0.28 topography=normal area=0.063 perim=1.14
MI657 net169 SET_B VGND VNB nfet_01v8 m=1 w=0.42 l=0.15 mult=1
+ sa=0.265 sb=0.265 sd=0.28 topography=normal area=0.063 perim=1.14
MI652 net165 S0 VGND VNB nfet_01v8 m=1 w=0.65 l=0.15 mult=1 sa=0.265
+ sb=0.265 sd=0.28 topography=normal area=0.063 perim=1.14
MI644 sceb SCE VGND VNB nfet_01v8 m=1 w=0.42 l=0.15 mult=1 sa=0.265
+ sb=0.265 sd=0.28 topography=normal area=0.063 perim=1.14
MI25 net157 SET_B VGND VNB nfet_01v8 m=1 w=0.42 l=0.15 mult=1 sa=0.265
+ sb=0.265 sd=0.28 topography=normal area=0.063 perim=1.14
MI653 Q net165 VGND VNB nfet_01v8 m=4 w=0.65 l=0.15 mult=1 sa=0.265
+ sb=0.265 sd=0.28 topography=normal area=0.063 perim=1.14
MI98 db D n0 VNB nfet_01v8 m=1 w=0.42 l=0.15 mult=1 sa=0.265 sb=0.265
+ sd=0.28 topography=normal area=0.525 perim=3.1
MI103 n1 SCD VGND VNB nfet_01v8 m=1 w=0.42 l=0.15 mult=1 sa=0.265
+ sb=0.265 sd=0.28 topography=normal area=0.525 perim=3.1
MI120 db SCE n1 VNB nfet_01v8 m=1 w=0.42 l=0.15 mult=1 sa=0.265
+ sb=0.265 sd=0.28 topography=normal area=0.525 perim=3.1
MI104 n0 sceb VGND VNB nfet_01v8 m=1 w=0.42 l=0.15 mult=1 sa=0.265
+ sb=0.265 sd=0.28 topography=normal area=0.525 perim=3.1
.ENDS

.SUBCKT sky130_fd_sc_hd__sdfxbp_1 CLK D SCD SCE VGND VNB VPB VPWR Q Q_N
MI98 db D n0 VNB nfet_01v8 m=1 w=0.42 l=0.15 mult=1 sa=0.265 sb=0.265
+ sd=0.28 topography=normal area=0.525 perim=3.1
MI103 n1 SCD VGND VNB nfet_01v8 m=1 w=0.42 l=0.15 mult=1 sa=0.265
+ sb=0.265 sd=0.28 topography=normal area=0.525 perim=3.1
MI120 db SCE n1 VNB nfet_01v8 m=1 w=0.42 l=0.15 mult=1 sa=0.265
+ sb=0.265 sd=0.28 topography=normal area=0.525 perim=3.1
MI104 n0 sceb VGND VNB nfet_01v8 m=1 w=0.42 l=0.15 mult=1 sa=0.265
+ sb=0.265 sd=0.28 topography=normal area=0.525 perim=3.1
MI657 M0 clkpos net129 VNB nfet_01v8 m=1 w=0.36 l=0.15 mult=1 sa=0.265
+ sb=0.265 sd=0.28 topography=normal area=0.063 perim=1.14
MI656 net129 M1 VGND VNB nfet_01v8 m=1 w=0.42 l=0.15 mult=1 sa=0.265
+ sb=0.265 sd=0.28 topography=normal area=0.063 perim=1.14
MI641 net120 S1 VGND VNB nfet_01v8 m=1 w=0.42 l=0.15 mult=1 sa=0.265
+ sb=0.265 sd=0.28 topography=normal area=0.063 perim=1.14
MI642 S0 clkneg net120 VNB nfet_01v8 m=1 w=0.36 l=0.15 mult=1 sa=0.265
+ sb=0.265 sd=0.28 topography=normal area=0.063 perim=1.14
MI646 Q S1 VGND VNB nfet_01v8 m=1 w=0.65 l=0.15 mult=1 sa=0.265
+ sb=0.265 sd=0.28 topography=normal area=0.063 perim=1.14
MI648 db clkneg M0 VNB nfet_01v8 m=1 w=0.36 l=0.15 mult=1 sa=0.265
+ sb=0.265 sd=0.28 topography=normal area=0.063 perim=1.14
MI635 clkneg CLK VGND VNB nfet_01v8 m=1 w=0.42 l=0.15 mult=1 sa=0.265
+ sb=0.265 sd=0.28 topography=normal area=0.063 perim=1.14
MI639 sceb SCE VGND VNB nfet_01v8 m=1 w=0.42 l=0.15 mult=1 sa=0.265
+ sb=0.265 sd=0.28 topography=normal area=0.063 perim=1.14
MI652 M1 clkpos S0 VNB nfet_01v8 m=1 w=0.36 l=0.15 mult=1 sa=0.265
+ sb=0.265 sd=0.28 topography=normal area=0.063 perim=1.14
MI661 Q_N net153 VGND VNB nfet_01v8 m=1 w=0.65 l=0.15 mult=1 sa=0.265
+ sb=0.265 sd=0.28 topography=normal area=0.063 perim=1.14
MI662 net153 S1 VGND VNB nfet_01v8 m=1 w=0.42 l=0.15 mult=1 sa=0.265
+ sb=0.265 sd=0.28 topography=normal area=0.063 perim=1.14
MI649 S1 S0 VGND VNB nfet_01v8 m=1 w=0.65 l=0.15 mult=1 sa=0.265
+ sb=0.265 sd=0.28 topography=normal area=0.063 perim=1.14
MI634 M1 M0 VGND VNB nfet_01v8 m=1 w=0.64 l=0.15 mult=1 sa=0.265
+ sb=0.265 sd=0.28 topography=normal area=0.063 perim=1.14
MI636 clkpos clkneg VGND VNB nfet_01v8 m=1 w=0.42 l=0.15 mult=1
+ sa=0.265 sb=0.265 sd=0.28 topography=normal area=0.063 perim=1.14
MI107 p0 SCE VPWR VPB pfet_01v8_hvt m=1 w=0.64 l=0.15 mult=1 sa=0.265
+ sb=0.265 sd=0.28 topography=normal area=0.063 perim=1.14
MI94 db D p0 VPB pfet_01v8_hvt m=1 w=0.64 l=0.15 mult=1 sa=0.265
+ sb=0.265 sd=0.28 topography=normal area=0.063 perim=1.14
MI101 db sceb p1 VPB pfet_01v8_hvt m=1 w=0.64 l=0.15 mult=1 sa=0.265
+ sb=0.265 sd=0.28 topography=normal area=0.063 perim=1.14
MI108 p1 SCD VPWR VPB pfet_01v8_hvt m=1 w=0.64 l=0.15 mult=1 sa=0.265
+ sb=0.265 sd=0.28 topography=normal area=0.063 perim=1.14
MI637 clkpos clkneg VPWR VPB pfet_01v8_hvt m=1 w=0.64 l=0.15 mult=1
+ sa=0.265 sb=0.265 sd=0.28 topography=normal area=0.063 perim=1.14
MI650 S1 S0 VPWR VPB pfet_01v8_hvt m=1 w=1.0 l=0.15 mult=1 sa=0.265
+ sb=0.265 sd=0.28 topography=normal area=0.063 perim=1.14
MI644 S0 clkpos net177 VPB pfet_01v8_hvt m=1 w=0.42 l=0.15 mult=1
+ sa=0.265 sb=0.265 sd=0.28 topography=normal area=0.063 perim=1.14
MI664 M1 M0 VPWR VPB pfet_01v8_hvt m=1 w=0.75 l=0.15 mult=1 sa=0.265
+ sb=0.265 sd=0.28 topography=normal area=0.063 perim=1.14
MI658 net160 M1 VPWR VPB pfet_01v8_hvt m=1 w=0.42 l=0.15 mult=1
+ sa=0.265 sb=0.265 sd=0.28 topography=normal area=0.063 perim=1.14
MI645 Q S1 VPWR VPB pfet_01v8_hvt m=1 w=1.0 l=0.15 mult=1 sa=0.265
+ sb=0.265 sd=0.28 topography=normal area=0.063 perim=1.14
MI660 Q_N net153 VPWR VPB pfet_01v8_hvt m=1 w=1.0 l=0.15 mult=1
+ sa=0.265 sb=0.265 sd=0.28 topography=normal area=0.063 perim=1.14
MI643 net177 S1 VPWR VPB pfet_01v8_hvt m=1 w=0.42 l=0.15 mult=1
+ sa=0.265 sb=0.265 sd=0.28 topography=normal area=0.063 perim=1.14
MI651 db clkpos M0 VPB pfet_01v8_hvt m=1 w=0.42 l=0.15 mult=1 sa=0.265
+ sb=0.265 sd=0.28 topography=normal area=0.063 perim=1.14
MI653 M1 clkneg S0 VPB pfet_01v8_hvt m=1 w=0.42 l=0.15 mult=1 sa=0.265
+ sb=0.265 sd=0.28 topography=normal area=0.063 perim=1.14
MI640 sceb SCE VPWR VPB pfet_01v8_hvt m=1 w=0.64 l=0.15 mult=1
+ sa=0.265 sb=0.265 sd=0.28 topography=normal area=0.063 perim=1.14
MI659 M0 clkneg net160 VPB pfet_01v8_hvt m=1 w=0.42 l=0.15 mult=1
+ sa=0.265 sb=0.265 sd=0.28 topography=normal area=0.063 perim=1.14
MI638 clkneg CLK VPWR VPB pfet_01v8_hvt m=1 w=0.64 l=0.15 mult=1
+ sa=0.265 sb=0.265 sd=0.28 topography=normal area=0.063 perim=1.14
MI647 net153 S1 VPWR VPB pfet_01v8_hvt m=1 w=0.64 l=0.15 mult=1
+ sa=0.265 sb=0.265 sd=0.28 topography=normal area=0.063 perim=1.14
.ENDS

.SUBCKT sky130_fd_sc_hd__sdfxbp_2 CLK D SCD SCE VGND VNB VPB VPWR Q Q_N
MI98 db D n0 VNB nfet_01v8 m=1 w=0.42 l=0.15 mult=1 sa=0.265 sb=0.265
+ sd=0.28 topography=normal area=0.525 perim=3.1
MI103 n1 SCD VGND VNB nfet_01v8 m=1 w=0.42 l=0.15 mult=1 sa=0.265
+ sb=0.265 sd=0.28 topography=normal area=0.525 perim=3.1
MI120 db SCE n1 VNB nfet_01v8 m=1 w=0.42 l=0.15 mult=1 sa=0.265
+ sb=0.265 sd=0.28 topography=normal area=0.525 perim=3.1
MI104 n0 sceb VGND VNB nfet_01v8 m=1 w=0.42 l=0.15 mult=1 sa=0.265
+ sb=0.265 sd=0.28 topography=normal area=0.525 perim=3.1
MI657 M0 clkpos net129 VNB nfet_01v8 m=1 w=0.36 l=0.15 mult=1 sa=0.265
+ sb=0.265 sd=0.28 topography=normal area=0.063 perim=1.14
MI656 net129 M1 VGND VNB nfet_01v8 m=1 w=0.42 l=0.15 mult=1 sa=0.265
+ sb=0.265 sd=0.28 topography=normal area=0.063 perim=1.14
MI641 net120 S1 VGND VNB nfet_01v8 m=1 w=0.42 l=0.15 mult=1 sa=0.265
+ sb=0.265 sd=0.28 topography=normal area=0.063 perim=1.14
MI642 S0 clkneg net120 VNB nfet_01v8 m=1 w=0.36 l=0.15 mult=1 sa=0.265
+ sb=0.265 sd=0.28 topography=normal area=0.063 perim=1.14
MI646 Q S1 VGND VNB nfet_01v8 m=2 w=0.65 l=0.15 mult=1 sa=0.265
+ sb=0.265 sd=0.28 topography=normal area=0.063 perim=1.14
MI648 db clkneg M0 VNB nfet_01v8 m=1 w=0.36 l=0.15 mult=1 sa=0.265
+ sb=0.265 sd=0.28 topography=normal area=0.063 perim=1.14
MI635 clkneg CLK VGND VNB nfet_01v8 m=1 w=0.42 l=0.15 mult=1 sa=0.265
+ sb=0.265 sd=0.28 topography=normal area=0.063 perim=1.14
MI639 sceb SCE VGND VNB nfet_01v8 m=1 w=0.42 l=0.15 mult=1 sa=0.265
+ sb=0.265 sd=0.28 topography=normal area=0.063 perim=1.14
MI652 M1 clkpos S0 VNB nfet_01v8 m=1 w=0.36 l=0.15 mult=1 sa=0.265
+ sb=0.265 sd=0.28 topography=normal area=0.063 perim=1.14
MI661 Q_N net153 VGND VNB nfet_01v8 m=2 w=0.65 l=0.15 mult=1 sa=0.265
+ sb=0.265 sd=0.28 topography=normal area=0.063 perim=1.14
MI662 net153 S1 VGND VNB nfet_01v8 m=1 w=0.42 l=0.15 mult=1 sa=0.265
+ sb=0.265 sd=0.28 topography=normal area=0.063 perim=1.14
MI649 S1 S0 VGND VNB nfet_01v8 m=1 w=0.65 l=0.15 mult=1 sa=0.265
+ sb=0.265 sd=0.28 topography=normal area=0.063 perim=1.14
MI634 M1 M0 VGND VNB nfet_01v8 m=1 w=0.64 l=0.15 mult=1 sa=0.265
+ sb=0.265 sd=0.28 topography=normal area=0.063 perim=1.14
MI636 clkpos clkneg VGND VNB nfet_01v8 m=1 w=0.42 l=0.15 mult=1
+ sa=0.265 sb=0.265 sd=0.28 topography=normal area=0.063 perim=1.14
MI107 p0 SCE VPWR VPB pfet_01v8_hvt m=1 w=0.64 l=0.15 mult=1 sa=0.265
+ sb=0.265 sd=0.28 topography=normal area=0.063 perim=1.14
MI94 db D p0 VPB pfet_01v8_hvt m=1 w=0.64 l=0.15 mult=1 sa=0.265
+ sb=0.265 sd=0.28 topography=normal area=0.063 perim=1.14
MI101 db sceb p1 VPB pfet_01v8_hvt m=1 w=0.64 l=0.15 mult=1 sa=0.265
+ sb=0.265 sd=0.28 topography=normal area=0.063 perim=1.14
MI108 p1 SCD VPWR VPB pfet_01v8_hvt m=1 w=0.64 l=0.15 mult=1 sa=0.265
+ sb=0.265 sd=0.28 topography=normal area=0.063 perim=1.14
MI637 clkpos clkneg VPWR VPB pfet_01v8_hvt m=1 w=0.64 l=0.15 mult=1
+ sa=0.265 sb=0.265 sd=0.28 topography=normal area=0.063 perim=1.14
MI650 S1 S0 VPWR VPB pfet_01v8_hvt m=1 w=1.0 l=0.15 mult=1 sa=0.265
+ sb=0.265 sd=0.28 topography=normal area=0.063 perim=1.14
MI644 S0 clkpos net196 VPB pfet_01v8_hvt m=1 w=0.42 l=0.15 mult=1
+ sa=0.265 sb=0.265 sd=0.28 topography=normal area=0.063 perim=1.14
MI664 M1 M0 VPWR VPB pfet_01v8_hvt m=1 w=0.75 l=0.15 mult=1 sa=0.265
+ sb=0.265 sd=0.28 topography=normal area=0.063 perim=1.14
MI658 net189 M1 VPWR VPB pfet_01v8_hvt m=1 w=0.42 l=0.15 mult=1
+ sa=0.265 sb=0.265 sd=0.28 topography=normal area=0.063 perim=1.14
MI645 Q S1 VPWR VPB pfet_01v8_hvt m=2 w=1.0 l=0.15 mult=1 sa=0.265
+ sb=0.265 sd=0.28 topography=normal area=0.063 perim=1.14
MI660 Q_N net153 VPWR VPB pfet_01v8_hvt m=2 w=1.0 l=0.15 mult=1
+ sa=0.265 sb=0.265 sd=0.28 topography=normal area=0.063 perim=1.14
MI643 net196 S1 VPWR VPB pfet_01v8_hvt m=1 w=0.42 l=0.15 mult=1
+ sa=0.265 sb=0.265 sd=0.28 topography=normal area=0.063 perim=1.14
MI651 db clkpos M0 VPB pfet_01v8_hvt m=1 w=0.42 l=0.15 mult=1 sa=0.265
+ sb=0.265 sd=0.28 topography=normal area=0.063 perim=1.14
MI653 M1 clkneg S0 VPB pfet_01v8_hvt m=1 w=0.42 l=0.15 mult=1 sa=0.265
+ sb=0.265 sd=0.28 topography=normal area=0.063 perim=1.14
MI640 sceb SCE VPWR VPB pfet_01v8_hvt m=1 w=0.64 l=0.15 mult=1
+ sa=0.265 sb=0.265 sd=0.28 topography=normal area=0.063 perim=1.14
MI659 M0 clkneg net189 VPB pfet_01v8_hvt m=1 w=0.42 l=0.15 mult=1
+ sa=0.265 sb=0.265 sd=0.28 topography=normal area=0.063 perim=1.14
MI638 clkneg CLK VPWR VPB pfet_01v8_hvt m=1 w=0.64 l=0.15 mult=1
+ sa=0.265 sb=0.265 sd=0.28 topography=normal area=0.063 perim=1.14
MI647 net153 S1 VPWR VPB pfet_01v8_hvt m=1 w=0.64 l=0.15 mult=1
+ sa=0.265 sb=0.265 sd=0.28 topography=normal area=0.063 perim=1.14
.ENDS

.SUBCKT sky130_fd_sc_hd__sdfxtp_1 CLK D SCD SCE VGND VNB VPB VPWR Q
MI652 M1 clkpos S0 VNB nfet_01v8 m=1 w=0.36 l=0.15 mult=1 sa=0.265
+ sb=0.265 sd=0.28 topography=normal area=0.063 perim=1.14
MI649 S1 S0 VGND VNB nfet_01v8 m=1 w=0.65 l=0.15 mult=1 sa=0.265
+ sb=0.265 sd=0.28 topography=normal area=0.063 perim=1.14
MI634 M1 M0 VGND VNB nfet_01v8 m=1 w=0.64 l=0.15 mult=1 sa=0.265
+ sb=0.265 sd=0.28 topography=normal area=0.063 perim=1.14
MI636 clkpos clkneg VGND VNB nfet_01v8 m=1 w=0.42 l=0.15 mult=1
+ sa=0.265 sb=0.265 sd=0.28 topography=normal area=0.063 perim=1.14
MI639 sceb SCE VGND VNB nfet_01v8 m=1 w=0.42 l=0.15 mult=1 sa=0.265
+ sb=0.265 sd=0.28 topography=normal area=0.063 perim=1.14
MI657 M0 clkpos net78 VNB nfet_01v8 m=1 w=0.36 l=0.15 mult=1 sa=0.265
+ sb=0.265 sd=0.28 topography=normal area=0.063 perim=1.14
MI656 net78 M1 VGND VNB nfet_01v8 m=1 w=0.42 l=0.15 mult=1 sa=0.265
+ sb=0.265 sd=0.28 topography=normal area=0.063 perim=1.14
MI641 net54 S1 VGND VNB nfet_01v8 m=1 w=0.42 l=0.15 mult=1 sa=0.265
+ sb=0.265 sd=0.28 topography=normal area=0.063 perim=1.14
MI646 Q S1 VGND VNB nfet_01v8 m=1 w=0.65 l=0.15 mult=1 sa=0.265
+ sb=0.265 sd=0.28 topography=normal area=0.063 perim=1.14
MI648 db clkneg M0 VNB nfet_01v8 m=1 w=0.36 l=0.15 mult=1 sa=0.265
+ sb=0.265 sd=0.28 topography=normal area=0.063 perim=1.14
MI635 clkneg CLK VGND VNB nfet_01v8 m=1 w=0.42 l=0.15 mult=1 sa=0.265
+ sb=0.265 sd=0.28 topography=normal area=0.063 perim=1.14
MI642 S0 clkneg net54 VNB nfet_01v8 m=1 w=0.36 l=0.15 mult=1 sa=0.265
+ sb=0.265 sd=0.28 topography=normal area=0.063 perim=1.14
MI98 db D n0 VNB nfet_01v8 m=1 w=0.42 l=0.15 mult=1 sa=0.265 sb=0.265
+ sd=0.28 topography=normal area=0.525 perim=3.1
MI103 n1 SCD VGND VNB nfet_01v8 m=1 w=0.42 l=0.15 mult=1 sa=0.265
+ sb=0.265 sd=0.28 topography=normal area=0.525 perim=3.1
MI120 db SCE n1 VNB nfet_01v8 m=1 w=0.42 l=0.15 mult=1 sa=0.265
+ sb=0.265 sd=0.28 topography=normal area=0.525 perim=3.1
MI104 n0 sceb VGND VNB nfet_01v8 m=1 w=0.42 l=0.15 mult=1 sa=0.265
+ sb=0.265 sd=0.28 topography=normal area=0.525 perim=3.1
MI643 net122 S1 VPWR VPB pfet_01v8_hvt m=1 w=0.42 l=0.15 mult=1
+ sa=0.265 sb=0.265 sd=0.28 topography=normal area=0.063 perim=1.14
MI640 sceb SCE VPWR VPB pfet_01v8_hvt m=1 w=0.64 l=0.15 mult=1
+ sa=0.265 sb=0.265 sd=0.28 topography=normal area=0.063 perim=1.14
MI658 net155 M1 VPWR VPB pfet_01v8_hvt m=1 w=0.42 l=0.15 mult=1
+ sa=0.265 sb=0.265 sd=0.28 topography=normal area=0.063 perim=1.14
MI645 Q S1 VPWR VPB pfet_01v8_hvt m=1 w=1.0 l=0.15 mult=1 sa=0.265
+ sb=0.265 sd=0.28 topography=normal area=0.063 perim=1.14
MI651 db clkpos M0 VPB pfet_01v8_hvt m=1 w=0.42 l=0.15 mult=1 sa=0.265
+ sb=0.265 sd=0.28 topography=normal area=0.063 perim=1.14
MI653 M1 clkneg S0 VPB pfet_01v8_hvt m=1 w=0.42 l=0.15 mult=1 sa=0.265
+ sb=0.265 sd=0.28 topography=normal area=0.063 perim=1.14
MI659 M0 clkneg net155 VPB pfet_01v8_hvt m=1 w=0.42 l=0.15 mult=1
+ sa=0.265 sb=0.265 sd=0.28 topography=normal area=0.063 perim=1.14
MI638 clkneg CLK VPWR VPB pfet_01v8_hvt m=1 w=0.64 l=0.15 mult=1
+ sa=0.265 sb=0.265 sd=0.28 topography=normal area=0.063 perim=1.14
MI637 clkpos clkneg VPWR VPB pfet_01v8_hvt m=1 w=0.64 l=0.15 mult=1
+ sa=0.265 sb=0.265 sd=0.28 topography=normal area=0.063 perim=1.14
MI650 S1 S0 VPWR VPB pfet_01v8_hvt m=1 w=1.0 l=0.15 mult=1 sa=0.265
+ sb=0.265 sd=0.28 topography=normal area=0.063 perim=1.14
MI644 S0 clkpos net122 VPB pfet_01v8_hvt m=1 w=0.42 l=0.15 mult=1
+ sa=0.265 sb=0.265 sd=0.28 topography=normal area=0.063 perim=1.14
MI664 M1 M0 VPWR VPB pfet_01v8_hvt m=1 w=0.75 l=0.15 mult=1 sa=0.265
+ sb=0.265 sd=0.28 topography=normal area=0.063 perim=1.14
MI107 p0 SCE VPWR VPB pfet_01v8_hvt m=1 w=0.64 l=0.15 mult=1 sa=0.265
+ sb=0.265 sd=0.28 topography=normal area=0.063 perim=1.14
MI94 db D p0 VPB pfet_01v8_hvt m=1 w=0.64 l=0.15 mult=1 sa=0.265
+ sb=0.265 sd=0.28 topography=normal area=0.063 perim=1.14
MI108 p1 SCD VPWR VPB pfet_01v8_hvt m=1 w=0.64 l=0.15 mult=1 sa=0.265
+ sb=0.265 sd=0.28 topography=normal area=0.063 perim=1.14
MI101 db sceb p1 VPB pfet_01v8_hvt m=1 w=0.64 l=0.15 mult=1 sa=0.265
+ sb=0.265 sd=0.28 topography=normal area=0.063 perim=1.14
.ENDS

.SUBCKT sky130_fd_sc_hd__sdfxtp_2 CLK D SCD SCE VGND VNB VPB VPWR Q
MI652 M1 clkpos S0 VNB nfet_01v8 m=1 w=0.36 l=0.15 mult=1 sa=0.265
+ sb=0.265 sd=0.28 topography=normal area=0.063 perim=1.14
MI649 S1 S0 VGND VNB nfet_01v8 m=1 w=0.65 l=0.15 mult=1 sa=0.265
+ sb=0.265 sd=0.28 topography=normal area=0.063 perim=1.14
MI634 M1 M0 VGND VNB nfet_01v8 m=1 w=0.64 l=0.15 mult=1 sa=0.265
+ sb=0.265 sd=0.28 topography=normal area=0.063 perim=1.14
MI636 clkpos clkneg VGND VNB nfet_01v8 m=1 w=0.42 l=0.15 mult=1
+ sa=0.265 sb=0.265 sd=0.28 topography=normal area=0.063 perim=1.14
MI639 sceb SCE VGND VNB nfet_01v8 m=1 w=0.42 l=0.15 mult=1 sa=0.265
+ sb=0.265 sd=0.28 topography=normal area=0.063 perim=1.14
MI657 M0 clkpos net78 VNB nfet_01v8 m=1 w=0.36 l=0.15 mult=1 sa=0.265
+ sb=0.265 sd=0.28 topography=normal area=0.063 perim=1.14
MI656 net78 M1 VGND VNB nfet_01v8 m=1 w=0.42 l=0.15 mult=1 sa=0.265
+ sb=0.265 sd=0.28 topography=normal area=0.063 perim=1.14
MI641 net54 S1 VGND VNB nfet_01v8 m=1 w=0.42 l=0.15 mult=1 sa=0.265
+ sb=0.265 sd=0.28 topography=normal area=0.063 perim=1.14
MI646 Q S1 VGND VNB nfet_01v8 m=2 w=0.65 l=0.15 mult=1 sa=0.265
+ sb=0.265 sd=0.28 topography=normal area=0.063 perim=1.14
MI648 db clkneg M0 VNB nfet_01v8 m=1 w=0.36 l=0.15 mult=1 sa=0.265
+ sb=0.265 sd=0.28 topography=normal area=0.063 perim=1.14
MI635 clkneg CLK VGND VNB nfet_01v8 m=1 w=0.42 l=0.15 mult=1 sa=0.265
+ sb=0.265 sd=0.28 topography=normal area=0.063 perim=1.14
MI642 S0 clkneg net54 VNB nfet_01v8 m=1 w=0.36 l=0.15 mult=1 sa=0.265
+ sb=0.265 sd=0.28 topography=normal area=0.063 perim=1.14
MI98 db D n0 VNB nfet_01v8 m=1 w=0.42 l=0.15 mult=1 sa=0.265 sb=0.265
+ sd=0.28 topography=normal area=0.525 perim=3.1
MI103 n1 SCD VGND VNB nfet_01v8 m=1 w=0.42 l=0.15 mult=1 sa=0.265
+ sb=0.265 sd=0.28 topography=normal area=0.525 perim=3.1
MI120 db SCE n1 VNB nfet_01v8 m=1 w=0.42 l=0.15 mult=1 sa=0.265
+ sb=0.265 sd=0.28 topography=normal area=0.525 perim=3.1
MI104 n0 sceb VGND VNB nfet_01v8 m=1 w=0.42 l=0.15 mult=1 sa=0.265
+ sb=0.265 sd=0.28 topography=normal area=0.525 perim=3.1
MI643 net163 S1 VPWR VPB pfet_01v8_hvt m=1 w=0.42 l=0.15 mult=1
+ sa=0.265 sb=0.265 sd=0.28 topography=normal area=0.063 perim=1.14
MI640 sceb SCE VPWR VPB pfet_01v8_hvt m=1 w=0.64 l=0.15 mult=1
+ sa=0.265 sb=0.265 sd=0.28 topography=normal area=0.063 perim=1.14
MI658 net138 M1 VPWR VPB pfet_01v8_hvt m=1 w=0.42 l=0.15 mult=1
+ sa=0.265 sb=0.265 sd=0.28 topography=normal area=0.063 perim=1.14
MI645 Q S1 VPWR VPB pfet_01v8_hvt m=2 w=1.0 l=0.15 mult=1 sa=0.265
+ sb=0.265 sd=0.28 topography=normal area=0.063 perim=1.14
MI651 db clkpos M0 VPB pfet_01v8_hvt m=1 w=0.42 l=0.15 mult=1 sa=0.265
+ sb=0.265 sd=0.28 topography=normal area=0.063 perim=1.14
MI653 M1 clkneg S0 VPB pfet_01v8_hvt m=1 w=0.42 l=0.15 mult=1 sa=0.265
+ sb=0.265 sd=0.28 topography=normal area=0.063 perim=1.14
MI659 M0 clkneg net138 VPB pfet_01v8_hvt m=1 w=0.42 l=0.15 mult=1
+ sa=0.265 sb=0.265 sd=0.28 topography=normal area=0.063 perim=1.14
MI638 clkneg CLK VPWR VPB pfet_01v8_hvt m=1 w=0.64 l=0.15 mult=1
+ sa=0.265 sb=0.265 sd=0.28 topography=normal area=0.063 perim=1.14
MI637 clkpos clkneg VPWR VPB pfet_01v8_hvt m=1 w=0.64 l=0.15 mult=1
+ sa=0.265 sb=0.265 sd=0.28 topography=normal area=0.063 perim=1.14
MI650 S1 S0 VPWR VPB pfet_01v8_hvt m=1 w=1.0 l=0.15 mult=1 sa=0.265
+ sb=0.265 sd=0.28 topography=normal area=0.063 perim=1.14
MI644 S0 clkpos net163 VPB pfet_01v8_hvt m=1 w=0.42 l=0.15 mult=1
+ sa=0.265 sb=0.265 sd=0.28 topography=normal area=0.063 perim=1.14
MI664 M1 M0 VPWR VPB pfet_01v8_hvt m=1 w=0.75 l=0.15 mult=1 sa=0.265
+ sb=0.265 sd=0.28 topography=normal area=0.063 perim=1.14
MI107 p0 SCE VPWR VPB pfet_01v8_hvt m=1 w=0.64 l=0.15 mult=1 sa=0.265
+ sb=0.265 sd=0.28 topography=normal area=0.063 perim=1.14
MI94 db D p0 VPB pfet_01v8_hvt m=1 w=0.64 l=0.15 mult=1 sa=0.265
+ sb=0.265 sd=0.28 topography=normal area=0.063 perim=1.14
MI108 p1 SCD VPWR VPB pfet_01v8_hvt m=1 w=0.64 l=0.15 mult=1 sa=0.265
+ sb=0.265 sd=0.28 topography=normal area=0.063 perim=1.14
MI101 db sceb p1 VPB pfet_01v8_hvt m=1 w=0.64 l=0.15 mult=1 sa=0.265
+ sb=0.265 sd=0.28 topography=normal area=0.063 perim=1.14
.ENDS

.SUBCKT sky130_fd_sc_hd__sdfxtp_4 CLK D SCD SCE VGND VNB VPB VPWR Q
MI652 M1 clkpos S0 VNB nfet_01v8 m=1 w=0.36 l=0.15 mult=1 sa=0.265
+ sb=0.265 sd=0.28 topography=normal area=0.063 perim=1.14
MI649 S1 S0 VGND VNB nfet_01v8 m=1 w=0.65 l=0.15 mult=1 sa=0.265
+ sb=0.265 sd=0.28 topography=normal area=0.063 perim=1.14
MI634 M1 M0 VGND VNB nfet_01v8 m=1 w=0.64 l=0.15 mult=1 sa=0.265
+ sb=0.265 sd=0.28 topography=normal area=0.063 perim=1.14
MI636 clkpos clkneg VGND VNB nfet_01v8 m=1 w=0.42 l=0.15 mult=1
+ sa=0.265 sb=0.265 sd=0.28 topography=normal area=0.063 perim=1.14
MI639 sceb SCE VGND VNB nfet_01v8 m=1 w=0.42 l=0.15 mult=1 sa=0.265
+ sb=0.265 sd=0.28 topography=normal area=0.063 perim=1.14
MI657 M0 clkpos net78 VNB nfet_01v8 m=1 w=0.36 l=0.15 mult=1 sa=0.265
+ sb=0.265 sd=0.28 topography=normal area=0.063 perim=1.14
MI656 net78 M1 VGND VNB nfet_01v8 m=1 w=0.42 l=0.15 mult=1 sa=0.265
+ sb=0.265 sd=0.28 topography=normal area=0.063 perim=1.14
MI641 net54 S1 VGND VNB nfet_01v8 m=1 w=0.42 l=0.15 mult=1 sa=0.265
+ sb=0.265 sd=0.28 topography=normal area=0.063 perim=1.14
MI646 Q S1 VGND VNB nfet_01v8 m=4 w=0.65 l=0.15 mult=1 sa=0.265
+ sb=0.265 sd=0.28 topography=normal area=0.063 perim=1.14
MI648 db clkneg M0 VNB nfet_01v8 m=1 w=0.36 l=0.15 mult=1 sa=0.265
+ sb=0.265 sd=0.28 topography=normal area=0.063 perim=1.14
MI635 clkneg CLK VGND VNB nfet_01v8 m=1 w=0.42 l=0.15 mult=1 sa=0.265
+ sb=0.265 sd=0.28 topography=normal area=0.063 perim=1.14
MI642 S0 clkneg net54 VNB nfet_01v8 m=1 w=0.36 l=0.15 mult=1 sa=0.265
+ sb=0.265 sd=0.28 topography=normal area=0.063 perim=1.14
MI98 db D n0 VNB nfet_01v8 m=1 w=0.42 l=0.15 mult=1 sa=0.265 sb=0.265
+ sd=0.28 topography=normal area=0.525 perim=3.1
MI103 n1 SCD VGND VNB nfet_01v8 m=1 w=0.42 l=0.15 mult=1 sa=0.265
+ sb=0.265 sd=0.28 topography=normal area=0.525 perim=3.1
MI120 db SCE n1 VNB nfet_01v8 m=1 w=0.42 l=0.15 mult=1 sa=0.265
+ sb=0.265 sd=0.28 topography=normal area=0.525 perim=3.1
MI104 n0 sceb VGND VNB nfet_01v8 m=1 w=0.42 l=0.15 mult=1 sa=0.265
+ sb=0.265 sd=0.28 topography=normal area=0.525 perim=3.1
MI643 net163 S1 VPWR VPB pfet_01v8_hvt m=1 w=0.42 l=0.15 mult=1
+ sa=0.265 sb=0.265 sd=0.28 topography=normal area=0.063 perim=1.14
MI640 sceb SCE VPWR VPB pfet_01v8_hvt m=1 w=0.64 l=0.15 mult=1
+ sa=0.265 sb=0.265 sd=0.28 topography=normal area=0.063 perim=1.14
MI658 net155 M1 VPWR VPB pfet_01v8_hvt m=1 w=0.42 l=0.15 mult=1
+ sa=0.265 sb=0.265 sd=0.28 topography=normal area=0.063 perim=1.14
MI645 Q S1 VPWR VPB pfet_01v8_hvt m=4 w=1.0 l=0.15 mult=1 sa=0.265
+ sb=0.265 sd=0.28 topography=normal area=0.063 perim=1.14
MI651 db clkpos M0 VPB pfet_01v8_hvt m=1 w=0.42 l=0.15 mult=1 sa=0.265
+ sb=0.265 sd=0.28 topography=normal area=0.063 perim=1.14
MI653 M1 clkneg S0 VPB pfet_01v8_hvt m=1 w=0.42 l=0.15 mult=1 sa=0.265
+ sb=0.265 sd=0.28 topography=normal area=0.063 perim=1.14
MI659 M0 clkneg net155 VPB pfet_01v8_hvt m=1 w=0.42 l=0.15 mult=1
+ sa=0.265 sb=0.265 sd=0.28 topography=normal area=0.063 perim=1.14
MI638 clkneg CLK VPWR VPB pfet_01v8_hvt m=1 w=0.64 l=0.15 mult=1
+ sa=0.265 sb=0.265 sd=0.28 topography=normal area=0.063 perim=1.14
MI637 clkpos clkneg VPWR VPB pfet_01v8_hvt m=1 w=0.64 l=0.15 mult=1
+ sa=0.265 sb=0.265 sd=0.28 topography=normal area=0.063 perim=1.14
MI650 S1 S0 VPWR VPB pfet_01v8_hvt m=1 w=1.0 l=0.15 mult=1 sa=0.265
+ sb=0.265 sd=0.28 topography=normal area=0.063 perim=1.14
MI644 S0 clkpos net163 VPB pfet_01v8_hvt m=1 w=0.42 l=0.15 mult=1
+ sa=0.265 sb=0.265 sd=0.28 topography=normal area=0.063 perim=1.14
MI664 M1 M0 VPWR VPB pfet_01v8_hvt m=1 w=0.75 l=0.15 mult=1 sa=0.265
+ sb=0.265 sd=0.28 topography=normal area=0.063 perim=1.14
MI107 p0 SCE VPWR VPB pfet_01v8_hvt m=1 w=0.64 l=0.15 mult=1 sa=0.265
+ sb=0.265 sd=0.28 topography=normal area=0.063 perim=1.14
MI94 db D p0 VPB pfet_01v8_hvt m=1 w=0.64 l=0.15 mult=1 sa=0.265
+ sb=0.265 sd=0.28 topography=normal area=0.063 perim=1.14
MI108 p1 SCD VPWR VPB pfet_01v8_hvt m=1 w=0.64 l=0.15 mult=1 sa=0.265
+ sb=0.265 sd=0.28 topography=normal area=0.063 perim=1.14
MI101 db sceb p1 VPB pfet_01v8_hvt m=1 w=0.64 l=0.15 mult=1 sa=0.265
+ sb=0.265 sd=0.28 topography=normal area=0.063 perim=1.14
.ENDS

.SUBCKT sky130_fd_sc_hd__sdlclkp_1 CLK GATE SCE VGND VNB VPB VPWR GCLK
MI662 net88 m1 VPWR VPB pfet_01v8_hvt m=1 w=0.42 l=0.15 mult=1
+ sa=0.265 sb=0.265 sd=0.28 topography=normal area=0.063 perim=1.14
MI664 M0 clkpos net88 VPB pfet_01v8_hvt m=1 w=0.42 l=0.15 mult=1
+ sa=0.265 sb=0.265 sd=0.28 topography=normal area=0.063 perim=1.14
MI659 net76 CLK VPWR VPB pfet_01v8_hvt m=1 w=0.64 l=0.15 mult=1
+ sa=0.265 sb=0.265 sd=0.28 topography=normal area=0.063 perim=1.14
MI658 net76 m1 VPWR VPB pfet_01v8_hvt m=1 w=0.64 l=0.15 mult=1
+ sa=0.265 sb=0.265 sd=0.28 topography=normal area=0.063 perim=1.14
MI19 m1 M0 VPWR VPB pfet_01v8_hvt m=1 w=1.0 l=0.15 mult=1 sa=0.265
+ sb=0.265 sd=0.28 topography=normal area=0.063 perim=1.14
MI22 net63 SCE VPWR VPB pfet_01v8_hvt m=1 w=0.64 l=0.15 mult=1
+ sa=0.265 sb=0.265 sd=0.28 topography=normal area=0.063 perim=1.14
MI21 net116 GATE net63 VPB pfet_01v8_hvt m=1 w=0.64 l=0.15 mult=1
+ sa=0.265 sb=0.265 sd=0.28 topography=normal area=0.063 perim=1.14
MI47 clkneg clkpos VPWR VPB pfet_01v8_hvt m=1 w=0.64 l=0.15 mult=1
+ sa=0.265 sb=0.265 sd=0.28 topography=normal area=0.063 perim=1.14
MI45 clkpos CLK VPWR VPB pfet_01v8_hvt m=1 w=0.64 l=0.15 mult=1
+ sa=0.265 sb=0.265 sd=0.28 topography=normal area=0.063 perim=1.14
MI660 GCLK net76 VPWR VPB pfet_01v8_hvt m=1 w=1.0 l=0.15 mult=1
+ sa=0.265 sb=0.265 sd=0.28 topography=normal area=0.063 perim=1.14
MI43 net116 clkneg M0 VPB pfet_01v8_hvt m=1 w=0.42 l=0.15 mult=1
+ sa=0.265 sb=0.265 sd=0.28 topography=normal area=0.063 perim=1.14
MI42 net116 clkpos M0 VNB nfet_01v8 m=1 w=0.36 l=0.15 mult=1 sa=0.265
+ sb=0.265 sd=0.28 topography=normal area=0.063 perim=1.14
MI20 m1 M0 VGND VNB nfet_01v8 m=1 w=0.65 l=0.15 mult=1 sa=0.265
+ sb=0.265 sd=0.28 topography=normal area=0.063 perim=1.14
MI655 M0 clkneg net123 VNB nfet_01v8 m=1 w=0.36 l=0.15 mult=1 sa=0.265
+ sb=0.265 sd=0.28 topography=normal area=0.063 perim=1.14
MI654 net123 m1 VGND VNB nfet_01v8 m=1 w=0.42 l=0.15 mult=1 sa=0.265
+ sb=0.265 sd=0.28 topography=normal area=0.063 perim=1.14
MI24 net116 SCE VGND VNB nfet_01v8 m=1 w=0.42 l=0.15 mult=1 sa=0.265
+ sb=0.265 sd=0.28 topography=normal area=0.063 perim=1.14
MI657 net112 CLK VGND VNB nfet_01v8 m=1 w=0.42 l=0.15 mult=1 sa=0.265
+ sb=0.265 sd=0.28 topography=normal area=0.063 perim=1.14
MI656 net76 m1 net112 VNB nfet_01v8 m=1 w=0.42 l=0.15 mult=1 sa=0.265
+ sb=0.265 sd=0.28 topography=normal area=0.063 perim=1.14
MI23 net116 GATE VGND VNB nfet_01v8 m=1 w=0.42 l=0.15 mult=1 sa=0.265
+ sb=0.265 sd=0.28 topography=normal area=0.063 perim=1.14
MI46 clkneg clkpos VGND VNB nfet_01v8 m=1 w=0.42 l=0.15 mult=1
+ sa=0.265 sb=0.265 sd=0.28 topography=normal area=0.063 perim=1.14
MI44 clkpos CLK VGND VNB nfet_01v8 m=1 w=0.42 l=0.15 mult=1 sa=0.265
+ sb=0.265 sd=0.28 topography=normal area=0.063 perim=1.14
MI653 GCLK net76 VGND VNB nfet_01v8 m=1 w=0.65 l=0.15 mult=1 sa=0.265
+ sb=0.265 sd=0.28 topography=normal area=0.063 perim=1.14
.ENDS

.SUBCKT sky130_fd_sc_hd__sdlclkp_2 CLK GATE SCE VGND VNB VPB VPWR GCLK
MI662 net88 m1 VPWR VPB pfet_01v8_hvt m=1 w=0.42 l=0.15 mult=1
+ sa=0.265 sb=0.265 sd=0.28 topography=normal area=0.063 perim=1.14
MI664 M0 clkpos net88 VPB pfet_01v8_hvt m=1 w=0.42 l=0.15 mult=1
+ sa=0.265 sb=0.265 sd=0.28 topography=normal area=0.063 perim=1.14
MI659 net76 CLK VPWR VPB pfet_01v8_hvt m=1 w=0.64 l=0.15 mult=1
+ sa=0.265 sb=0.265 sd=0.28 topography=normal area=0.063 perim=1.14
MI658 net76 m1 VPWR VPB pfet_01v8_hvt m=1 w=0.64 l=0.15 mult=1
+ sa=0.265 sb=0.265 sd=0.28 topography=normal area=0.063 perim=1.14
MI19 m1 M0 VPWR VPB pfet_01v8_hvt m=1 w=1.0 l=0.15 mult=1 sa=0.265
+ sb=0.265 sd=0.28 topography=normal area=0.063 perim=1.14
MI22 net63 SCE VPWR VPB pfet_01v8_hvt m=1 w=0.64 l=0.15 mult=1
+ sa=0.265 sb=0.265 sd=0.28 topography=normal area=0.063 perim=1.14
MI21 net116 GATE net63 VPB pfet_01v8_hvt m=1 w=0.64 l=0.15 mult=1
+ sa=0.265 sb=0.265 sd=0.28 topography=normal area=0.063 perim=1.14
MI47 clkneg clkpos VPWR VPB pfet_01v8_hvt m=1 w=0.64 l=0.15 mult=1
+ sa=0.265 sb=0.265 sd=0.28 topography=normal area=0.063 perim=1.14
MI45 clkpos CLK VPWR VPB pfet_01v8_hvt m=1 w=0.64 l=0.15 mult=1
+ sa=0.265 sb=0.265 sd=0.28 topography=normal area=0.063 perim=1.14
MI660 GCLK net76 VPWR VPB pfet_01v8_hvt m=2 w=1.0 l=0.15 mult=1
+ sa=0.265 sb=0.265 sd=0.28 topography=normal area=0.063 perim=1.14
MI43 net116 clkneg M0 VPB pfet_01v8_hvt m=1 w=0.42 l=0.15 mult=1
+ sa=0.265 sb=0.265 sd=0.28 topography=normal area=0.063 perim=1.14
MI42 net116 clkpos M0 VNB nfet_01v8 m=1 w=0.36 l=0.15 mult=1 sa=0.265
+ sb=0.265 sd=0.28 topography=normal area=0.063 perim=1.14
MI20 m1 M0 VGND VNB nfet_01v8 m=1 w=0.65 l=0.15 mult=1 sa=0.265
+ sb=0.265 sd=0.28 topography=normal area=0.063 perim=1.14
MI655 M0 clkneg net123 VNB nfet_01v8 m=1 w=0.36 l=0.15 mult=1 sa=0.265
+ sb=0.265 sd=0.28 topography=normal area=0.063 perim=1.14
MI654 net123 m1 VGND VNB nfet_01v8 m=1 w=0.42 l=0.15 mult=1 sa=0.265
+ sb=0.265 sd=0.28 topography=normal area=0.063 perim=1.14
MI24 net116 SCE VGND VNB nfet_01v8 m=1 w=0.42 l=0.15 mult=1 sa=0.265
+ sb=0.265 sd=0.28 topography=normal area=0.063 perim=1.14
MI657 net112 CLK VGND VNB nfet_01v8 m=1 w=0.42 l=0.15 mult=1 sa=0.265
+ sb=0.265 sd=0.28 topography=normal area=0.063 perim=1.14
MI656 net76 m1 net112 VNB nfet_01v8 m=1 w=0.42 l=0.15 mult=1 sa=0.265
+ sb=0.265 sd=0.28 topography=normal area=0.063 perim=1.14
MI23 net116 GATE VGND VNB nfet_01v8 m=1 w=0.42 l=0.15 mult=1 sa=0.265
+ sb=0.265 sd=0.28 topography=normal area=0.063 perim=1.14
MI46 clkneg clkpos VGND VNB nfet_01v8 m=1 w=0.42 l=0.15 mult=1
+ sa=0.265 sb=0.265 sd=0.28 topography=normal area=0.063 perim=1.14
MI44 clkpos CLK VGND VNB nfet_01v8 m=1 w=0.42 l=0.15 mult=1 sa=0.265
+ sb=0.265 sd=0.28 topography=normal area=0.063 perim=1.14
MI653 GCLK net76 VGND VNB nfet_01v8 m=2 w=0.65 l=0.15 mult=1 sa=0.265
+ sb=0.265 sd=0.28 topography=normal area=0.063 perim=1.14
.ENDS

.SUBCKT sky130_fd_sc_hd__sdlclkp_4 CLK GATE SCE VGND VNB VPB VPWR GCLK
MI662 net88 m1 VPWR VPB pfet_01v8_hvt m=1 w=0.42 l=0.15 mult=1
+ sa=0.265 sb=0.265 sd=0.28 topography=normal area=0.063 perim=1.14
MI664 M0 clkpos net88 VPB pfet_01v8_hvt m=1 w=0.42 l=0.15 mult=1
+ sa=0.265 sb=0.265 sd=0.28 topography=normal area=0.063 perim=1.14
MI659 net76 CLK VPWR VPB pfet_01v8_hvt m=1 w=1.0 l=0.15 mult=1
+ sa=0.265 sb=0.265 sd=0.28 topography=normal area=0.063 perim=1.14
MI658 net76 m1 VPWR VPB pfet_01v8_hvt m=1 w=1.0 l=0.15 mult=1 sa=0.265
+ sb=0.265 sd=0.28 topography=normal area=0.063 perim=1.14
MI19 m1 M0 VPWR VPB pfet_01v8_hvt m=1 w=1.0 l=0.15 mult=1 sa=0.265
+ sb=0.265 sd=0.28 topography=normal area=0.063 perim=1.14
MI22 net63 SCE VPWR VPB pfet_01v8_hvt m=1 w=0.64 l=0.15 mult=1
+ sa=0.265 sb=0.265 sd=0.28 topography=normal area=0.063 perim=1.14
MI21 net116 GATE net63 VPB pfet_01v8_hvt m=1 w=0.64 l=0.15 mult=1
+ sa=0.265 sb=0.265 sd=0.28 topography=normal area=0.063 perim=1.14
MI47 clkneg clkpos VPWR VPB pfet_01v8_hvt m=1 w=0.64 l=0.15 mult=1
+ sa=0.265 sb=0.265 sd=0.28 topography=normal area=0.063 perim=1.14
MI45 clkpos CLK VPWR VPB pfet_01v8_hvt m=1 w=0.64 l=0.15 mult=1
+ sa=0.265 sb=0.265 sd=0.28 topography=normal area=0.063 perim=1.14
MI660 GCLK net76 VPWR VPB pfet_01v8_hvt m=4 w=1.0 l=0.15 mult=1
+ sa=0.265 sb=0.265 sd=0.28 topography=normal area=0.063 perim=1.14
MI43 net116 clkneg M0 VPB pfet_01v8_hvt m=1 w=0.42 l=0.15 mult=1
+ sa=0.265 sb=0.265 sd=0.28 topography=normal area=0.063 perim=1.14
MI42 net116 clkpos M0 VNB nfet_01v8 m=1 w=0.36 l=0.15 mult=1 sa=0.265
+ sb=0.265 sd=0.28 topography=normal area=0.063 perim=1.14
MI20 m1 M0 VGND VNB nfet_01v8 m=1 w=0.65 l=0.15 mult=1 sa=0.265
+ sb=0.265 sd=0.28 topography=normal area=0.063 perim=1.14
MI655 M0 clkneg net123 VNB nfet_01v8 m=1 w=0.36 l=0.15 mult=1 sa=0.265
+ sb=0.265 sd=0.28 topography=normal area=0.063 perim=1.14
MI654 net123 m1 VGND VNB nfet_01v8 m=1 w=0.42 l=0.15 mult=1 sa=0.265
+ sb=0.265 sd=0.28 topography=normal area=0.063 perim=1.14
MI24 net116 SCE VGND VNB nfet_01v8 m=1 w=0.42 l=0.15 mult=1 sa=0.265
+ sb=0.265 sd=0.28 topography=normal area=0.063 perim=1.14
MI657 net112 CLK VGND VNB nfet_01v8 m=1 w=0.65 l=0.15 mult=1 sa=0.265
+ sb=0.265 sd=0.28 topography=normal area=0.063 perim=1.14
MI656 net76 m1 net112 VNB nfet_01v8 m=1 w=0.65 l=0.15 mult=1 sa=0.265
+ sb=0.265 sd=0.28 topography=normal area=0.063 perim=1.14
MI23 net116 GATE VGND VNB nfet_01v8 m=1 w=0.42 l=0.15 mult=1 sa=0.265
+ sb=0.265 sd=0.28 topography=normal area=0.063 perim=1.14
MI46 clkneg clkpos VGND VNB nfet_01v8 m=1 w=0.42 l=0.15 mult=1
+ sa=0.265 sb=0.265 sd=0.28 topography=normal area=0.063 perim=1.14
MI44 clkpos CLK VGND VNB nfet_01v8 m=1 w=0.42 l=0.15 mult=1 sa=0.265
+ sb=0.265 sd=0.28 topography=normal area=0.063 perim=1.14
MI653 GCLK net76 VGND VNB nfet_01v8 m=4 w=0.65 l=0.15 mult=1 sa=0.265
+ sb=0.265 sd=0.28 topography=normal area=0.063 perim=1.14
.ENDS

.SUBCKT sky130_fd_sc_hd__sedfxbp_1 CLK D DE SCD SCE VGND VNB VPB VPWR Q Q_N
MI14 net155 M1 VPWR VPB pfet_01v8_hvt m=1 w=0.42 l=0.15 mult=1
+ sa=0.265 sb=0.265 sd=0.28 topography=normal area=0.063 perim=1.14
MI637 clkpos clkneg VPWR VPB pfet_01v8_hvt m=1 w=0.64 l=0.15 mult=1
+ sa=0.265 sb=0.265 sd=0.28 topography=normal area=0.063 perim=1.14
MI13 S0 clkneg net155 VPB pfet_01v8_hvt m=1 w=0.42 l=0.15 mult=1
+ sa=0.265 sb=0.265 sd=0.28 topography=normal area=0.063 perim=1.14
MI651 db clkpos M0 VPB pfet_01v8_hvt m=1 w=0.42 l=0.15 mult=1 sa=0.265
+ sb=0.265 sd=0.28 topography=normal area=0.063 perim=1.14
MI645 Q S0 VPWR VPB pfet_01v8_hvt m=1 w=1.0 l=0.15 mult=1 sa=0.265
+ sb=0.265 sd=0.28 topography=normal area=0.063 perim=1.14
MI658 net123 M1 VPWR VPB pfet_01v8_hvt m=1 w=0.42 l=0.15 mult=1
+ sa=0.265 sb=0.265 sd=0.28 topography=normal area=0.063 perim=1.14
MI638 clkneg CLK VPWR VPB pfet_01v8_hvt m=1 w=0.64 l=0.15 mult=1
+ sa=0.265 sb=0.265 sd=0.28 topography=normal area=0.063 perim=1.14
MI643 net127 q1 VPWR VPB pfet_01v8_hvt m=1 w=0.42 l=0.15 mult=1
+ sa=0.265 sb=0.265 sd=0.28 topography=normal area=0.063 perim=1.14
MI639 M1 M0 VPWR VPB pfet_01v8_hvt m=1 w=0.75 l=0.15 mult=1 sa=0.265
+ sb=0.265 sd=0.28 topography=normal area=0.063 perim=1.14
MI644 S0 clkpos net127 VPB pfet_01v8_hvt m=1 w=0.42 l=0.15 mult=1
+ sa=0.265 sb=0.265 sd=0.28 topography=normal area=0.063 perim=1.14
MI659 M0 clkneg net123 VPB pfet_01v8_hvt m=1 w=0.42 l=0.15 mult=1
+ sa=0.265 sb=0.265 sd=0.28 topography=normal area=0.063 perim=1.14
MI17 q1 S0 VPWR VPB pfet_01v8_hvt m=1 w=0.64 l=0.15 mult=1 sa=0.265
+ sb=0.265 sd=0.28 topography=normal area=0.063 perim=1.14
MI33 net116 deneg VPWR VPB pfet_01v8_hvt m=1 w=0.64 l=0.15 mult=1
+ sa=0.265 sb=0.265 sd=0.28 topography=normal area=0.063 perim=1.14
MI47 net107 sceneg db VPB pfet_01v8_hvt m=1 w=0.64 l=0.15 mult=1
+ sa=0.265 sb=0.265 sd=0.28 topography=normal area=0.063 perim=1.14
MI46 VPWR SCD net107 VPB pfet_01v8_hvt m=1 w=0.64 l=0.15 mult=1
+ sa=0.265 sb=0.265 sd=0.28 topography=normal area=0.063 perim=1.14
MI31 net104 D net116 VPB pfet_01v8_hvt m=1 w=0.64 l=0.15 mult=1
+ sa=0.265 sb=0.265 sd=0.28 topography=normal area=0.063 perim=1.14
MI42 net104 SCE db VPB pfet_01v8_hvt m=1 w=0.64 l=0.15 mult=1 sa=0.265
+ sb=0.265 sd=0.28 topography=normal area=0.063 perim=1.14
MI40 net87 q1 net104 VPB pfet_01v8_hvt m=1 w=0.64 l=0.15 mult=1
+ sa=0.265 sb=0.265 sd=0.28 topography=normal area=0.063 perim=1.14
MI36 deneg DE VPWR VPB pfet_01v8_hvt m=1 w=0.64 l=0.15 mult=1 sa=0.265
+ sb=0.265 sd=0.28 topography=normal area=0.063 perim=1.14
MI38 VPWR DE net87 VPB pfet_01v8_hvt m=1 w=0.64 l=0.15 mult=1 sa=0.265
+ sb=0.265 sd=0.28 topography=normal area=0.063 perim=1.14
MI44 sceneg SCE VPWR VPB pfet_01v8_hvt m=1 w=0.64 l=0.15 mult=1
+ sa=0.265 sb=0.265 sd=0.28 topography=normal area=0.063 perim=1.14
MI52 Q_N q1 VPWR VPB pfet_01v8_hvt m=1 w=1.0 l=0.15 mult=1 sa=0.265
+ sb=0.265 sd=0.28 topography=normal area=0.063 perim=1.14
MI634 M1 M0 VGND VNB nfet_01v8 m=1 w=0.64 l=0.15 mult=1 sa=0.265
+ sb=0.265 sd=0.28 topography=normal area=0.063 perim=1.14
MI636 clkpos clkneg VGND VNB nfet_01v8 m=1 w=0.42 l=0.15 mult=1
+ sa=0.265 sb=0.265 sd=0.28 topography=normal area=0.063 perim=1.14
MI635 clkneg CLK VGND VNB nfet_01v8 m=1 w=0.42 l=0.15 mult=1 sa=0.265
+ sb=0.265 sd=0.28 topography=normal area=0.063 perim=1.14
MI641 net235 q1 VGND VNB nfet_01v8 m=1 w=0.42 l=0.15 mult=1 sa=0.265
+ sb=0.265 sd=0.28 topography=normal area=0.063 perim=1.14
MI642 S0 clkneg net235 VNB nfet_01v8 m=1 w=0.36 l=0.15 mult=1 sa=0.265
+ sb=0.265 sd=0.28 topography=normal area=0.063 perim=1.14
MI648 db clkneg M0 VNB nfet_01v8 m=1 w=0.36 l=0.15 mult=1 sa=0.265
+ sb=0.265 sd=0.28 topography=normal area=0.063 perim=1.14
MI646 Q S0 VGND VNB nfet_01v8 m=1 w=0.65 l=0.15 mult=1 sa=0.265
+ sb=0.265 sd=0.28 topography=normal area=0.063 perim=1.14
MI656 net224 M1 VGND VNB nfet_01v8 m=1 w=0.42 l=0.15 mult=1 sa=0.265
+ sb=0.265 sd=0.28 topography=normal area=0.063 perim=1.14
MI657 M0 clkpos net224 VNB nfet_01v8 m=1 w=0.36 l=0.15 mult=1 sa=0.265
+ sb=0.265 sd=0.28 topography=normal area=0.063 perim=1.14
MI43 net104 sceneg db VNB nfet_01v8 m=1 w=0.42 l=0.15 mult=1 sa=0.265
+ sb=0.265 sd=0.28 topography=normal area=0.063 perim=1.14
MI18 q1 S0 VGND VNB nfet_01v8 m=1 w=0.42 l=0.15 mult=1 sa=0.265
+ sb=0.265 sd=0.28 topography=normal area=0.063 perim=1.14
MI45 sceneg SCE VGND VNB nfet_01v8 m=1 w=0.42 l=0.15 mult=1 sa=0.265
+ sb=0.265 sd=0.28 topography=normal area=0.063 perim=1.14
MI32 net104 D net203 VNB nfet_01v8 m=1 w=0.42 l=0.15 mult=1 sa=0.265
+ sb=0.265 sd=0.28 topography=normal area=0.063 perim=1.14
MI16 net200 M1 VGND VNB nfet_01v8 m=1 w=0.42 l=0.15 mult=1 sa=0.265
+ sb=0.265 sd=0.28 topography=normal area=0.063 perim=1.14
MI15 S0 clkpos net200 VNB nfet_01v8 m=1 w=0.36 l=0.15 mult=1 sa=0.265
+ sb=0.265 sd=0.28 topography=normal area=0.063 perim=1.14
MI41 net192 q1 net104 VNB nfet_01v8 m=1 w=0.42 l=0.15 mult=1 sa=0.265
+ sb=0.265 sd=0.28 topography=normal area=0.063 perim=1.14
MI39 VGND deneg net192 VNB nfet_01v8 m=1 w=0.42 l=0.15 mult=1 sa=0.265
+ sb=0.265 sd=0.28 topography=normal area=0.063 perim=1.14
MI37 deneg DE VGND VNB nfet_01v8 m=1 w=0.42 l=0.15 mult=1 sa=0.265
+ sb=0.265 sd=0.28 topography=normal area=0.063 perim=1.14
MI34 net203 DE VGND VNB nfet_01v8 m=1 w=0.42 l=0.15 mult=1 sa=0.265
+ sb=0.265 sd=0.28 topography=normal area=0.063 perim=1.14
MI49 net176 SCE db VNB nfet_01v8 m=1 w=0.42 l=0.15 mult=1 sa=0.265
+ sb=0.265 sd=0.28 topography=normal area=0.063 perim=1.14
MI48 VGND SCD net176 VNB nfet_01v8 m=1 w=0.42 l=0.15 mult=1 sa=0.265
+ sb=0.265 sd=0.28 topography=normal area=0.063 perim=1.14
MI53 Q_N q1 VGND VNB nfet_01v8 m=1 w=0.65 l=0.15 mult=1 sa=0.265
+ sb=0.265 sd=0.28 topography=normal area=0.063 perim=1.14
.ENDS

.SUBCKT sky130_fd_sc_hd__sedfxbp_2 CLK D DE SCD SCE VGND VNB VPB VPWR Q Q_N
MI14 net155 M1 VPWR VPB pfet_01v8_hvt m=1 w=0.42 l=0.15 mult=1
+ sa=0.265 sb=0.265 sd=0.28 topography=normal area=0.063 perim=1.14
MI637 clkpos clkneg VPWR VPB pfet_01v8_hvt m=1 w=0.64 l=0.15 mult=1
+ sa=0.265 sb=0.265 sd=0.28 topography=normal area=0.063 perim=1.14
MI13 S0 clkneg net155 VPB pfet_01v8_hvt m=1 w=0.42 l=0.15 mult=1
+ sa=0.265 sb=0.265 sd=0.28 topography=normal area=0.063 perim=1.14
MI651 db clkpos M0 VPB pfet_01v8_hvt m=1 w=0.42 l=0.15 mult=1 sa=0.265
+ sb=0.265 sd=0.28 topography=normal area=0.063 perim=1.14
MI645 Q S0 VPWR VPB pfet_01v8_hvt m=2 w=1.0 l=0.15 mult=1 sa=0.265
+ sb=0.265 sd=0.28 topography=normal area=0.063 perim=1.14
MI658 net144 M1 VPWR VPB pfet_01v8_hvt m=1 w=0.42 l=0.15 mult=1
+ sa=0.265 sb=0.265 sd=0.28 topography=normal area=0.063 perim=1.14
MI638 clkneg CLK VPWR VPB pfet_01v8_hvt m=1 w=0.64 l=0.15 mult=1
+ sa=0.265 sb=0.265 sd=0.28 topography=normal area=0.063 perim=1.14
MI643 net127 q1 VPWR VPB pfet_01v8_hvt m=1 w=0.42 l=0.15 mult=1
+ sa=0.265 sb=0.265 sd=0.28 topography=normal area=0.063 perim=1.14
MI639 M1 M0 VPWR VPB pfet_01v8_hvt m=1 w=0.75 l=0.15 mult=1 sa=0.265
+ sb=0.265 sd=0.28 topography=normal area=0.063 perim=1.14
MI644 S0 clkpos net127 VPB pfet_01v8_hvt m=1 w=0.42 l=0.15 mult=1
+ sa=0.265 sb=0.265 sd=0.28 topography=normal area=0.063 perim=1.14
MI659 M0 clkneg net144 VPB pfet_01v8_hvt m=1 w=0.42 l=0.15 mult=1
+ sa=0.265 sb=0.265 sd=0.28 topography=normal area=0.063 perim=1.14
MI17 q1 S0 VPWR VPB pfet_01v8_hvt m=1 w=0.64 l=0.15 mult=1 sa=0.265
+ sb=0.265 sd=0.28 topography=normal area=0.063 perim=1.14
MI33 net116 deneg VPWR VPB pfet_01v8_hvt m=1 w=0.64 l=0.15 mult=1
+ sa=0.265 sb=0.265 sd=0.28 topography=normal area=0.063 perim=1.14
MI47 net107 sceneg db VPB pfet_01v8_hvt m=1 w=0.64 l=0.15 mult=1
+ sa=0.265 sb=0.265 sd=0.28 topography=normal area=0.063 perim=1.14
MI46 VPWR SCD net107 VPB pfet_01v8_hvt m=1 w=0.64 l=0.15 mult=1
+ sa=0.265 sb=0.265 sd=0.28 topography=normal area=0.063 perim=1.14
MI31 net104 D net116 VPB pfet_01v8_hvt m=1 w=0.64 l=0.15 mult=1
+ sa=0.265 sb=0.265 sd=0.28 topography=normal area=0.063 perim=1.14
MI42 net104 SCE db VPB pfet_01v8_hvt m=1 w=0.64 l=0.15 mult=1 sa=0.265
+ sb=0.265 sd=0.28 topography=normal area=0.063 perim=1.14
MI40 net87 q1 net104 VPB pfet_01v8_hvt m=1 w=0.64 l=0.15 mult=1
+ sa=0.265 sb=0.265 sd=0.28 topography=normal area=0.063 perim=1.14
MI36 deneg DE VPWR VPB pfet_01v8_hvt m=1 w=0.64 l=0.15 mult=1 sa=0.265
+ sb=0.265 sd=0.28 topography=normal area=0.063 perim=1.14
MI38 VPWR DE net87 VPB pfet_01v8_hvt m=1 w=0.64 l=0.15 mult=1 sa=0.265
+ sb=0.265 sd=0.28 topography=normal area=0.063 perim=1.14
MI44 sceneg SCE VPWR VPB pfet_01v8_hvt m=1 w=0.64 l=0.15 mult=1
+ sa=0.265 sb=0.265 sd=0.28 topography=normal area=0.063 perim=1.14
MI52 Q_N q1 VPWR VPB pfet_01v8_hvt m=2 w=1.0 l=0.15 mult=1 sa=0.265
+ sb=0.265 sd=0.28 topography=normal area=0.063 perim=1.14
MI634 M1 M0 VGND VNB nfet_01v8 m=1 w=0.64 l=0.15 mult=1 sa=0.265
+ sb=0.265 sd=0.28 topography=normal area=0.063 perim=1.14
MI636 clkpos clkneg VGND VNB nfet_01v8 m=1 w=0.42 l=0.15 mult=1
+ sa=0.265 sb=0.265 sd=0.28 topography=normal area=0.063 perim=1.14
MI635 clkneg CLK VGND VNB nfet_01v8 m=1 w=0.42 l=0.15 mult=1 sa=0.265
+ sb=0.265 sd=0.28 topography=normal area=0.063 perim=1.14
MI641 net240 q1 VGND VNB nfet_01v8 m=1 w=0.42 l=0.15 mult=1 sa=0.265
+ sb=0.265 sd=0.28 topography=normal area=0.063 perim=1.14
MI642 S0 clkneg net240 VNB nfet_01v8 m=1 w=0.36 l=0.15 mult=1 sa=0.265
+ sb=0.265 sd=0.28 topography=normal area=0.063 perim=1.14
MI648 db clkneg M0 VNB nfet_01v8 m=1 w=0.36 l=0.15 mult=1 sa=0.265
+ sb=0.265 sd=0.28 topography=normal area=0.063 perim=1.14
MI646 Q S0 VGND VNB nfet_01v8 m=2 w=0.65 l=0.15 mult=1 sa=0.265
+ sb=0.265 sd=0.28 topography=normal area=0.063 perim=1.14
MI656 net224 M1 VGND VNB nfet_01v8 m=1 w=0.42 l=0.15 mult=1 sa=0.265
+ sb=0.265 sd=0.28 topography=normal area=0.063 perim=1.14
MI657 M0 clkpos net224 VNB nfet_01v8 m=1 w=0.36 l=0.15 mult=1 sa=0.265
+ sb=0.265 sd=0.28 topography=normal area=0.063 perim=1.14
MI43 net104 sceneg db VNB nfet_01v8 m=1 w=0.42 l=0.15 mult=1 sa=0.265
+ sb=0.265 sd=0.28 topography=normal area=0.063 perim=1.14
MI18 q1 S0 VGND VNB nfet_01v8 m=1 w=0.42 l=0.15 mult=1 sa=0.265
+ sb=0.265 sd=0.28 topography=normal area=0.063 perim=1.14
MI45 sceneg SCE VGND VNB nfet_01v8 m=1 w=0.42 l=0.15 mult=1 sa=0.265
+ sb=0.265 sd=0.28 topography=normal area=0.063 perim=1.14
MI32 net104 D net180 VNB nfet_01v8 m=1 w=0.42 l=0.15 mult=1 sa=0.265
+ sb=0.265 sd=0.28 topography=normal area=0.063 perim=1.14
MI16 net200 M1 VGND VNB nfet_01v8 m=1 w=0.42 l=0.15 mult=1 sa=0.265
+ sb=0.265 sd=0.28 topography=normal area=0.063 perim=1.14
MI15 S0 clkpos net200 VNB nfet_01v8 m=1 w=0.36 l=0.15 mult=1 sa=0.265
+ sb=0.265 sd=0.28 topography=normal area=0.063 perim=1.14
MI41 net192 q1 net104 VNB nfet_01v8 m=1 w=0.42 l=0.15 mult=1 sa=0.265
+ sb=0.265 sd=0.28 topography=normal area=0.063 perim=1.14
MI39 VGND deneg net192 VNB nfet_01v8 m=1 w=0.42 l=0.15 mult=1 sa=0.265
+ sb=0.265 sd=0.28 topography=normal area=0.063 perim=1.14
MI37 deneg DE VGND VNB nfet_01v8 m=1 w=0.42 l=0.15 mult=1 sa=0.265
+ sb=0.265 sd=0.28 topography=normal area=0.063 perim=1.14
MI34 net180 DE VGND VNB nfet_01v8 m=1 w=0.42 l=0.15 mult=1 sa=0.265
+ sb=0.265 sd=0.28 topography=normal area=0.063 perim=1.14
MI49 net176 SCE db VNB nfet_01v8 m=1 w=0.42 l=0.15 mult=1 sa=0.265
+ sb=0.265 sd=0.28 topography=normal area=0.063 perim=1.14
MI48 VGND SCD net176 VNB nfet_01v8 m=1 w=0.42 l=0.15 mult=1 sa=0.265
+ sb=0.265 sd=0.28 topography=normal area=0.063 perim=1.14
MI53 Q_N q1 VGND VNB nfet_01v8 m=2 w=0.65 l=0.15 mult=1 sa=0.265
+ sb=0.265 sd=0.28 topography=normal area=0.063 perim=1.14
.ENDS

.SUBCKT sky130_fd_sc_hd__sedfxtp_1 CLK D DE SCD SCE VGND VNB VPB VPWR Q
MI14 net146 M1 VPWR VPB pfet_01v8_hvt m=1 w=0.42 l=0.15 mult=1
+ sa=0.265 sb=0.265 sd=0.28 topography=normal area=0.063 perim=1.14
MI637 clkpos clkneg VPWR VPB pfet_01v8_hvt m=1 w=0.64 l=0.15 mult=1
+ sa=0.265 sb=0.265 sd=0.28 topography=normal area=0.063 perim=1.14
MI13 S0 clkneg net146 VPB pfet_01v8_hvt m=1 w=0.42 l=0.15 mult=1
+ sa=0.265 sb=0.265 sd=0.28 topography=normal area=0.063 perim=1.14
MI651 db clkpos M0 VPB pfet_01v8_hvt m=1 w=0.42 l=0.15 mult=1 sa=0.265
+ sb=0.265 sd=0.28 topography=normal area=0.063 perim=1.14
MI645 Q S0 VPWR VPB pfet_01v8_hvt m=1 w=1.0 l=0.15 mult=1 sa=0.265
+ sb=0.265 sd=0.28 topography=normal area=0.063 perim=1.14
MI658 net114 M1 VPWR VPB pfet_01v8_hvt m=1 w=0.42 l=0.15 mult=1
+ sa=0.265 sb=0.265 sd=0.28 topography=normal area=0.063 perim=1.14
MI638 clkneg CLK VPWR VPB pfet_01v8_hvt m=1 w=0.64 l=0.15 mult=1
+ sa=0.265 sb=0.265 sd=0.28 topography=normal area=0.063 perim=1.14
MI643 net118 q1 VPWR VPB pfet_01v8_hvt m=1 w=0.42 l=0.15 mult=1
+ sa=0.265 sb=0.265 sd=0.28 topography=normal area=0.063 perim=1.14
MI639 M1 M0 VPWR VPB pfet_01v8_hvt m=1 w=0.75 l=0.15 mult=1 sa=0.265
+ sb=0.265 sd=0.28 topography=normal area=0.063 perim=1.14
MI644 S0 clkpos net118 VPB pfet_01v8_hvt m=1 w=0.42 l=0.15 mult=1
+ sa=0.265 sb=0.265 sd=0.28 topography=normal area=0.063 perim=1.14
MI659 M0 clkneg net114 VPB pfet_01v8_hvt m=1 w=0.42 l=0.15 mult=1
+ sa=0.265 sb=0.265 sd=0.28 topography=normal area=0.063 perim=1.14
MI17 q1 S0 VPWR VPB pfet_01v8_hvt m=1 w=0.64 l=0.15 mult=1 sa=0.265
+ sb=0.265 sd=0.28 topography=normal area=0.063 perim=1.14
MI33 net94 deneg VPWR VPB pfet_01v8_hvt m=1 w=0.64 l=0.15 mult=1
+ sa=0.265 sb=0.265 sd=0.28 topography=normal area=0.063 perim=1.14
MI47 net103 sceneg db VPB pfet_01v8_hvt m=1 w=0.64 l=0.15 mult=1
+ sa=0.265 sb=0.265 sd=0.28 topography=normal area=0.063 perim=1.14
MI46 VPWR SCD net103 VPB pfet_01v8_hvt m=1 w=0.64 l=0.15 mult=1
+ sa=0.265 sb=0.265 sd=0.28 topography=normal area=0.063 perim=1.14
MI31 net95 D net94 VPB pfet_01v8_hvt m=1 w=0.64 l=0.15 mult=1 sa=0.265
+ sb=0.265 sd=0.28 topography=normal area=0.063 perim=1.14
MI42 net95 SCE db VPB pfet_01v8_hvt m=1 w=0.64 l=0.15 mult=1 sa=0.265
+ sb=0.265 sd=0.28 topography=normal area=0.063 perim=1.14
MI40 net87 q1 net95 VPB pfet_01v8_hvt m=1 w=0.64 l=0.15 mult=1
+ sa=0.265 sb=0.265 sd=0.28 topography=normal area=0.063 perim=1.14
MI36 deneg DE VPWR VPB pfet_01v8_hvt m=1 w=0.64 l=0.15 mult=1 sa=0.265
+ sb=0.265 sd=0.28 topography=normal area=0.063 perim=1.14
MI38 VPWR DE net87 VPB pfet_01v8_hvt m=1 w=0.64 l=0.15 mult=1 sa=0.265
+ sb=0.265 sd=0.28 topography=normal area=0.063 perim=1.14
MI44 sceneg SCE VPWR VPB pfet_01v8_hvt m=1 w=0.64 l=0.15 mult=1
+ sa=0.265 sb=0.265 sd=0.28 topography=normal area=0.063 perim=1.14
MI634 M1 M0 VGND VNB nfet_01v8 m=1 w=0.64 l=0.15 mult=1 sa=0.265
+ sb=0.265 sd=0.28 topography=normal area=0.063 perim=1.14
MI636 clkpos clkneg VGND VNB nfet_01v8 m=1 w=0.42 l=0.15 mult=1
+ sa=0.265 sb=0.265 sd=0.28 topography=normal area=0.063 perim=1.14
MI635 clkneg CLK VGND VNB nfet_01v8 m=1 w=0.42 l=0.15 mult=1 sa=0.265
+ sb=0.265 sd=0.28 topography=normal area=0.063 perim=1.14
MI641 net222 q1 VGND VNB nfet_01v8 m=1 w=0.42 l=0.15 mult=1 sa=0.265
+ sb=0.265 sd=0.28 topography=normal area=0.063 perim=1.14
MI642 S0 clkneg net222 VNB nfet_01v8 m=1 w=0.36 l=0.15 mult=1 sa=0.265
+ sb=0.265 sd=0.28 topography=normal area=0.063 perim=1.14
MI648 db clkneg M0 VNB nfet_01v8 m=1 w=0.36 l=0.15 mult=1 sa=0.265
+ sb=0.265 sd=0.28 topography=normal area=0.063 perim=1.14
MI646 Q S0 VGND VNB nfet_01v8 m=1 w=0.65 l=0.15 mult=1 sa=0.265
+ sb=0.265 sd=0.28 topography=normal area=0.063 perim=1.14
MI656 net211 M1 VGND VNB nfet_01v8 m=1 w=0.42 l=0.15 mult=1 sa=0.265
+ sb=0.265 sd=0.28 topography=normal area=0.063 perim=1.14
MI657 M0 clkpos net211 VNB nfet_01v8 m=1 w=0.36 l=0.15 mult=1 sa=0.265
+ sb=0.265 sd=0.28 topography=normal area=0.063 perim=1.14
MI43 net95 sceneg db VNB nfet_01v8 m=1 w=0.42 l=0.15 mult=1 sa=0.265
+ sb=0.265 sd=0.28 topography=normal area=0.063 perim=1.14
MI18 q1 S0 VGND VNB nfet_01v8 m=1 w=0.42 l=0.15 mult=1 sa=0.265
+ sb=0.265 sd=0.28 topography=normal area=0.063 perim=1.14
MI45 sceneg SCE VGND VNB nfet_01v8 m=1 w=0.42 l=0.15 mult=1 sa=0.265
+ sb=0.265 sd=0.28 topography=normal area=0.063 perim=1.14
MI32 net95 D net167 VNB nfet_01v8 m=1 w=0.42 l=0.15 mult=1 sa=0.265
+ sb=0.265 sd=0.28 topography=normal area=0.063 perim=1.14
MI16 net187 M1 VGND VNB nfet_01v8 m=1 w=0.42 l=0.15 mult=1 sa=0.265
+ sb=0.265 sd=0.28 topography=normal area=0.063 perim=1.14
MI15 S0 clkpos net187 VNB nfet_01v8 m=1 w=0.36 l=0.15 mult=1 sa=0.265
+ sb=0.265 sd=0.28 topography=normal area=0.063 perim=1.14
MI41 net179 q1 net95 VNB nfet_01v8 m=1 w=0.42 l=0.15 mult=1 sa=0.265
+ sb=0.265 sd=0.28 topography=normal area=0.063 perim=1.14
MI39 VGND deneg net179 VNB nfet_01v8 m=1 w=0.42 l=0.15 mult=1 sa=0.265
+ sb=0.265 sd=0.28 topography=normal area=0.063 perim=1.14
MI37 deneg DE VGND VNB nfet_01v8 m=1 w=0.42 l=0.15 mult=1 sa=0.265
+ sb=0.265 sd=0.28 topography=normal area=0.063 perim=1.14
MI34 net167 DE VGND VNB nfet_01v8 m=1 w=0.42 l=0.15 mult=1 sa=0.265
+ sb=0.265 sd=0.28 topography=normal area=0.063 perim=1.14
MI49 net158 SCE db VNB nfet_01v8 m=1 w=0.42 l=0.15 mult=1 sa=0.265
+ sb=0.265 sd=0.28 topography=normal area=0.063 perim=1.14
MI48 VGND SCD net158 VNB nfet_01v8 m=1 w=0.42 l=0.15 mult=1 sa=0.265
+ sb=0.265 sd=0.28 topography=normal area=0.063 perim=1.14
.ENDS

.SUBCKT sky130_fd_sc_hd__sedfxtp_2 CLK D DE SCD SCE VGND VNB VPB VPWR Q
MI14 net146 M1 VPWR VPB pfet_01v8_hvt m=1 w=0.42 l=0.15 mult=1
+ sa=0.265 sb=0.265 sd=0.28 topography=normal area=0.063 perim=1.14
MI637 clkpos clkneg VPWR VPB pfet_01v8_hvt m=1 w=0.64 l=0.15 mult=1
+ sa=0.265 sb=0.265 sd=0.28 topography=normal area=0.063 perim=1.14
MI13 S0 clkneg net146 VPB pfet_01v8_hvt m=1 w=0.42 l=0.15 mult=1
+ sa=0.265 sb=0.265 sd=0.28 topography=normal area=0.063 perim=1.14
MI651 db clkpos M0 VPB pfet_01v8_hvt m=1 w=0.42 l=0.15 mult=1 sa=0.265
+ sb=0.265 sd=0.28 topography=normal area=0.063 perim=1.14
MI645 Q S0 VPWR VPB pfet_01v8_hvt m=2 w=1.0 l=0.15 mult=1 sa=0.265
+ sb=0.265 sd=0.28 topography=normal area=0.063 perim=1.14
MI658 net114 M1 VPWR VPB pfet_01v8_hvt m=1 w=0.42 l=0.15 mult=1
+ sa=0.265 sb=0.265 sd=0.28 topography=normal area=0.063 perim=1.14
MI638 clkneg CLK VPWR VPB pfet_01v8_hvt m=1 w=0.64 l=0.15 mult=1
+ sa=0.265 sb=0.265 sd=0.28 topography=normal area=0.063 perim=1.14
MI643 net118 q1 VPWR VPB pfet_01v8_hvt m=1 w=0.42 l=0.15 mult=1
+ sa=0.265 sb=0.265 sd=0.28 topography=normal area=0.063 perim=1.14
MI639 M1 M0 VPWR VPB pfet_01v8_hvt m=1 w=0.75 l=0.15 mult=1 sa=0.265
+ sb=0.265 sd=0.28 topography=normal area=0.063 perim=1.14
MI644 S0 clkpos net118 VPB pfet_01v8_hvt m=1 w=0.42 l=0.15 mult=1
+ sa=0.265 sb=0.265 sd=0.28 topography=normal area=0.063 perim=1.14
MI659 M0 clkneg net114 VPB pfet_01v8_hvt m=1 w=0.42 l=0.15 mult=1
+ sa=0.265 sb=0.265 sd=0.28 topography=normal area=0.063 perim=1.14
MI17 q1 S0 VPWR VPB pfet_01v8_hvt m=1 w=0.64 l=0.15 mult=1 sa=0.265
+ sb=0.265 sd=0.28 topography=normal area=0.063 perim=1.14
MI33 net94 deneg VPWR VPB pfet_01v8_hvt m=1 w=0.64 l=0.15 mult=1
+ sa=0.265 sb=0.265 sd=0.28 topography=normal area=0.063 perim=1.14
MI47 net98 sceneg db VPB pfet_01v8_hvt m=1 w=0.64 l=0.15 mult=1
+ sa=0.265 sb=0.265 sd=0.28 topography=normal area=0.063 perim=1.14
MI46 VPWR SCD net98 VPB pfet_01v8_hvt m=1 w=0.64 l=0.15 mult=1
+ sa=0.265 sb=0.265 sd=0.28 topography=normal area=0.063 perim=1.14
MI31 net95 D net94 VPB pfet_01v8_hvt m=1 w=0.64 l=0.15 mult=1 sa=0.265
+ sb=0.265 sd=0.28 topography=normal area=0.063 perim=1.14
MI42 net95 SCE db VPB pfet_01v8_hvt m=1 w=0.64 l=0.15 mult=1 sa=0.265
+ sb=0.265 sd=0.28 topography=normal area=0.063 perim=1.14
MI40 net87 q1 net95 VPB pfet_01v8_hvt m=1 w=0.64 l=0.15 mult=1
+ sa=0.265 sb=0.265 sd=0.28 topography=normal area=0.063 perim=1.14
MI36 deneg DE VPWR VPB pfet_01v8_hvt m=1 w=0.64 l=0.15 mult=1 sa=0.265
+ sb=0.265 sd=0.28 topography=normal area=0.063 perim=1.14
MI38 VPWR DE net87 VPB pfet_01v8_hvt m=1 w=0.64 l=0.15 mult=1 sa=0.265
+ sb=0.265 sd=0.28 topography=normal area=0.063 perim=1.14
MI44 sceneg SCE VPWR VPB pfet_01v8_hvt m=1 w=0.64 l=0.15 mult=1
+ sa=0.265 sb=0.265 sd=0.28 topography=normal area=0.063 perim=1.14
MI634 M1 M0 VGND VNB nfet_01v8 m=1 w=0.64 l=0.15 mult=1 sa=0.265
+ sb=0.265 sd=0.28 topography=normal area=0.063 perim=1.14
MI636 clkpos clkneg VGND VNB nfet_01v8 m=1 w=0.42 l=0.15 mult=1
+ sa=0.265 sb=0.265 sd=0.28 topography=normal area=0.063 perim=1.14
MI635 clkneg CLK VGND VNB nfet_01v8 m=1 w=0.42 l=0.15 mult=1 sa=0.265
+ sb=0.265 sd=0.28 topography=normal area=0.063 perim=1.14
MI641 net222 q1 VGND VNB nfet_01v8 m=1 w=0.42 l=0.15 mult=1 sa=0.265
+ sb=0.265 sd=0.28 topography=normal area=0.063 perim=1.14
MI642 S0 clkneg net222 VNB nfet_01v8 m=1 w=0.36 l=0.15 mult=1 sa=0.265
+ sb=0.265 sd=0.28 topography=normal area=0.063 perim=1.14
MI648 db clkneg M0 VNB nfet_01v8 m=1 w=0.36 l=0.15 mult=1 sa=0.265
+ sb=0.265 sd=0.28 topography=normal area=0.063 perim=1.14
MI646 Q S0 VGND VNB nfet_01v8 m=2 w=0.65 l=0.15 mult=1 sa=0.265
+ sb=0.265 sd=0.28 topography=normal area=0.063 perim=1.14
MI656 net211 M1 VGND VNB nfet_01v8 m=1 w=0.42 l=0.15 mult=1 sa=0.265
+ sb=0.265 sd=0.28 topography=normal area=0.063 perim=1.14
MI657 M0 clkpos net211 VNB nfet_01v8 m=1 w=0.36 l=0.15 mult=1 sa=0.265
+ sb=0.265 sd=0.28 topography=normal area=0.063 perim=1.14
MI43 net95 sceneg db VNB nfet_01v8 m=1 w=0.42 l=0.15 mult=1 sa=0.265
+ sb=0.265 sd=0.28 topography=normal area=0.063 perim=1.14
MI18 q1 S0 VGND VNB nfet_01v8 m=1 w=0.42 l=0.15 mult=1 sa=0.265
+ sb=0.265 sd=0.28 topography=normal area=0.063 perim=1.14
MI45 sceneg SCE VGND VNB nfet_01v8 m=1 w=0.42 l=0.15 mult=1 sa=0.265
+ sb=0.265 sd=0.28 topography=normal area=0.063 perim=1.14
MI32 net95 D net167 VNB nfet_01v8 m=1 w=0.42 l=0.15 mult=1 sa=0.265
+ sb=0.265 sd=0.28 topography=normal area=0.063 perim=1.14
MI16 net187 M1 VGND VNB nfet_01v8 m=1 w=0.42 l=0.15 mult=1 sa=0.265
+ sb=0.265 sd=0.28 topography=normal area=0.063 perim=1.14
MI15 S0 clkpos net187 VNB nfet_01v8 m=1 w=0.36 l=0.15 mult=1 sa=0.265
+ sb=0.265 sd=0.28 topography=normal area=0.063 perim=1.14
MI41 net174 q1 net95 VNB nfet_01v8 m=1 w=0.42 l=0.15 mult=1 sa=0.265
+ sb=0.265 sd=0.28 topography=normal area=0.063 perim=1.14
MI39 VGND deneg net174 VNB nfet_01v8 m=1 w=0.42 l=0.15 mult=1 sa=0.265
+ sb=0.265 sd=0.28 topography=normal area=0.063 perim=1.14
MI37 deneg DE VGND VNB nfet_01v8 m=1 w=0.42 l=0.15 mult=1 sa=0.265
+ sb=0.265 sd=0.28 topography=normal area=0.063 perim=1.14
MI34 net167 DE VGND VNB nfet_01v8 m=1 w=0.42 l=0.15 mult=1 sa=0.265
+ sb=0.265 sd=0.28 topography=normal area=0.063 perim=1.14
MI49 net158 SCE db VNB nfet_01v8 m=1 w=0.42 l=0.15 mult=1 sa=0.265
+ sb=0.265 sd=0.28 topography=normal area=0.063 perim=1.14
MI48 VGND SCD net158 VNB nfet_01v8 m=1 w=0.42 l=0.15 mult=1 sa=0.265
+ sb=0.265 sd=0.28 topography=normal area=0.063 perim=1.14
.ENDS

.SUBCKT sky130_fd_sc_hd__sedfxtp_4 CLK D DE SCD SCE VGND VNB VPB VPWR Q
MI14 net146 M1 VPWR VPB pfet_01v8_hvt m=1 w=0.42 l=0.15 mult=1
+ sa=0.265 sb=0.265 sd=0.28 topography=normal area=0.063 perim=1.14
MI637 clkpos clkneg VPWR VPB pfet_01v8_hvt m=1 w=0.64 l=0.15 mult=1
+ sa=0.265 sb=0.265 sd=0.28 topography=normal area=0.063 perim=1.14
MI13 S0 clkneg net146 VPB pfet_01v8_hvt m=1 w=0.42 l=0.15 mult=1
+ sa=0.265 sb=0.265 sd=0.28 topography=normal area=0.063 perim=1.14
MI651 db clkpos M0 VPB pfet_01v8_hvt m=1 w=0.42 l=0.15 mult=1 sa=0.265
+ sb=0.265 sd=0.28 topography=normal area=0.063 perim=1.14
MI645 Q S0 VPWR VPB pfet_01v8_hvt m=4 w=1.0 l=0.15 mult=1 sa=0.265
+ sb=0.265 sd=0.28 topography=normal area=0.063 perim=1.14
MI658 net135 M1 VPWR VPB pfet_01v8_hvt m=1 w=0.42 l=0.15 mult=1
+ sa=0.265 sb=0.265 sd=0.28 topography=normal area=0.063 perim=1.14
MI638 clkneg CLK VPWR VPB pfet_01v8_hvt m=1 w=0.64 l=0.15 mult=1
+ sa=0.265 sb=0.265 sd=0.28 topography=normal area=0.063 perim=1.14
MI643 net118 q1 VPWR VPB pfet_01v8_hvt m=1 w=0.42 l=0.15 mult=1
+ sa=0.265 sb=0.265 sd=0.28 topography=normal area=0.063 perim=1.14
MI639 M1 M0 VPWR VPB pfet_01v8_hvt m=1 w=0.75 l=0.15 mult=1 sa=0.265
+ sb=0.265 sd=0.28 topography=normal area=0.063 perim=1.14
MI644 S0 clkpos net118 VPB pfet_01v8_hvt m=1 w=0.42 l=0.15 mult=1
+ sa=0.265 sb=0.265 sd=0.28 topography=normal area=0.063 perim=1.14
MI659 M0 clkneg net135 VPB pfet_01v8_hvt m=1 w=0.42 l=0.15 mult=1
+ sa=0.265 sb=0.265 sd=0.28 topography=normal area=0.063 perim=1.14
MI17 q1 S0 VPWR VPB pfet_01v8_hvt m=1 w=0.64 l=0.15 mult=1 sa=0.265
+ sb=0.265 sd=0.28 topography=normal area=0.063 perim=1.14
MI33 net107 deneg VPWR VPB pfet_01v8_hvt m=1 w=0.64 l=0.15 mult=1
+ sa=0.265 sb=0.265 sd=0.28 topography=normal area=0.063 perim=1.14
MI47 net98 sceneg db VPB pfet_01v8_hvt m=1 w=0.64 l=0.15 mult=1
+ sa=0.265 sb=0.265 sd=0.28 topography=normal area=0.063 perim=1.14
MI46 VPWR SCD net98 VPB pfet_01v8_hvt m=1 w=0.64 l=0.15 mult=1
+ sa=0.265 sb=0.265 sd=0.28 topography=normal area=0.063 perim=1.14
MI31 net95 D net107 VPB pfet_01v8_hvt m=1 w=0.64 l=0.15 mult=1
+ sa=0.265 sb=0.265 sd=0.28 topography=normal area=0.063 perim=1.14
MI42 net95 SCE db VPB pfet_01v8_hvt m=1 w=0.64 l=0.15 mult=1 sa=0.265
+ sb=0.265 sd=0.28 topography=normal area=0.063 perim=1.14
MI40 net87 q1 net95 VPB pfet_01v8_hvt m=1 w=0.64 l=0.15 mult=1
+ sa=0.265 sb=0.265 sd=0.28 topography=normal area=0.063 perim=1.14
MI36 deneg DE VPWR VPB pfet_01v8_hvt m=1 w=0.64 l=0.15 mult=1 sa=0.265
+ sb=0.265 sd=0.28 topography=normal area=0.063 perim=1.14
MI38 VPWR DE net87 VPB pfet_01v8_hvt m=1 w=0.64 l=0.15 mult=1 sa=0.265
+ sb=0.265 sd=0.28 topography=normal area=0.063 perim=1.14
MI44 sceneg SCE VPWR VPB pfet_01v8_hvt m=1 w=0.64 l=0.15 mult=1
+ sa=0.265 sb=0.265 sd=0.28 topography=normal area=0.063 perim=1.14
MI634 M1 M0 VGND VNB nfet_01v8 m=1 w=0.64 l=0.15 mult=1 sa=0.265
+ sb=0.265 sd=0.28 topography=normal area=0.063 perim=1.14
MI636 clkpos clkneg VGND VNB nfet_01v8 m=1 w=0.42 l=0.15 mult=1
+ sa=0.265 sb=0.265 sd=0.28 topography=normal area=0.063 perim=1.14
MI635 clkneg CLK VGND VNB nfet_01v8 m=1 w=0.42 l=0.15 mult=1 sa=0.265
+ sb=0.265 sd=0.28 topography=normal area=0.063 perim=1.14
MI641 net227 q1 VGND VNB nfet_01v8 m=1 w=0.42 l=0.15 mult=1 sa=0.265
+ sb=0.265 sd=0.28 topography=normal area=0.063 perim=1.14
MI642 S0 clkneg net227 VNB nfet_01v8 m=1 w=0.36 l=0.15 mult=1 sa=0.265
+ sb=0.265 sd=0.28 topography=normal area=0.063 perim=1.14
MI648 db clkneg M0 VNB nfet_01v8 m=1 w=0.36 l=0.15 mult=1 sa=0.265
+ sb=0.265 sd=0.28 topography=normal area=0.063 perim=1.14
MI646 Q S0 VGND VNB nfet_01v8 m=4 w=0.65 l=0.15 mult=1 sa=0.265
+ sb=0.265 sd=0.28 topography=normal area=0.063 perim=1.14
MI656 net206 M1 VGND VNB nfet_01v8 m=1 w=0.42 l=0.15 mult=1 sa=0.265
+ sb=0.265 sd=0.28 topography=normal area=0.063 perim=1.14
MI657 M0 clkpos net206 VNB nfet_01v8 m=1 w=0.36 l=0.15 mult=1 sa=0.265
+ sb=0.265 sd=0.28 topography=normal area=0.063 perim=1.14
MI43 net95 sceneg db VNB nfet_01v8 m=1 w=0.42 l=0.15 mult=1 sa=0.265
+ sb=0.265 sd=0.28 topography=normal area=0.063 perim=1.14
MI18 q1 S0 VGND VNB nfet_01v8 m=1 w=0.42 l=0.15 mult=1 sa=0.265
+ sb=0.265 sd=0.28 topography=normal area=0.063 perim=1.14
MI45 sceneg SCE VGND VNB nfet_01v8 m=1 w=0.42 l=0.15 mult=1 sa=0.265
+ sb=0.265 sd=0.28 topography=normal area=0.063 perim=1.14
MI32 net95 D net190 VNB nfet_01v8 m=1 w=0.42 l=0.15 mult=1 sa=0.265
+ sb=0.265 sd=0.28 topography=normal area=0.063 perim=1.14
MI16 net187 M1 VGND VNB nfet_01v8 m=1 w=0.42 l=0.15 mult=1 sa=0.265
+ sb=0.265 sd=0.28 topography=normal area=0.063 perim=1.14
MI15 S0 clkpos net187 VNB nfet_01v8 m=1 w=0.36 l=0.15 mult=1 sa=0.265
+ sb=0.265 sd=0.28 topography=normal area=0.063 perim=1.14
MI41 net174 q1 net95 VNB nfet_01v8 m=1 w=0.42 l=0.15 mult=1 sa=0.265
+ sb=0.265 sd=0.28 topography=normal area=0.063 perim=1.14
MI39 VGND deneg net174 VNB nfet_01v8 m=1 w=0.42 l=0.15 mult=1 sa=0.265
+ sb=0.265 sd=0.28 topography=normal area=0.063 perim=1.14
MI37 deneg DE VGND VNB nfet_01v8 m=1 w=0.42 l=0.15 mult=1 sa=0.265
+ sb=0.265 sd=0.28 topography=normal area=0.063 perim=1.14
MI34 net190 DE VGND VNB nfet_01v8 m=1 w=0.42 l=0.15 mult=1 sa=0.265
+ sb=0.265 sd=0.28 topography=normal area=0.063 perim=1.14
MI49 net163 SCE db VNB nfet_01v8 m=1 w=0.42 l=0.15 mult=1 sa=0.265
+ sb=0.265 sd=0.28 topography=normal area=0.063 perim=1.14
MI48 VGND SCD net163 VNB nfet_01v8 m=1 w=0.42 l=0.15 mult=1 sa=0.265
+ sb=0.265 sd=0.28 topography=normal area=0.063 perim=1.14
.ENDS

.SUBCKT sky130_fd_sc_hd__tap_1 VGND VNB VPB VPWR
.ENDS

.SUBCKT sky130_fd_sc_hd__tap_2 VGND VNB VPB VPWR
.ENDS

.SUBCKT sky130_fd_sc_hd__tapvgnd2_1 VGND VPB VPWR
.ENDS

.SUBCKT sky130_fd_sc_hd__tapvgnd_1 VGND VPB VPWR
.ENDS

.SUBCKT sky130_fd_sc_hd__tapvpwrvgnd_1 VGND VPWR
.ENDS

.SUBCKT sky130_fd_sc_hd__xnor2_1 A B VGND VNB VPB VPWR Y
MMNnand0 VGND A sndNA VNB nfet_01v8 m=1 w=0.65 l=0.15 mult=1 sa=0.265
+ sb=0.265 sd=0.28 topography=normal area=0.063 perim=1.14
MMNnand1 sndNA B inand VNB nfet_01v8 m=1 w=0.65 l=0.15 mult=1 sa=0.265
+ sb=0.265 sd=0.28 topography=normal area=0.063 perim=1.14
MMNaoi10 nmid A VGND VNB nfet_01v8 m=1 w=0.65 l=0.15 mult=1 sa=0.265
+ sb=0.265 sd=0.28 topography=normal area=0.063 perim=1.14
MMNaoi11 nmid B VGND VNB nfet_01v8 m=1 w=0.65 l=0.15 mult=1 sa=0.265
+ sb=0.265 sd=0.28 topography=normal area=0.063 perim=1.14
MMNaoi20 Y inand nmid VNB nfet_01v8 m=1 w=0.65 l=0.15 mult=1 sa=0.265
+ sb=0.265 sd=0.28 topography=normal area=0.063 perim=1.14
MMPnand0 inand A VPWR VPB pfet_01v8_hvt m=1 w=1.0 l=0.15 mult=1
+ sa=0.265 sb=0.265 sd=0.28 topography=normal area=0.063 perim=1.14
MMPnand1 inand B VPWR VPB pfet_01v8_hvt m=1 w=1.0 l=0.15 mult=1
+ sa=0.265 sb=0.265 sd=0.28 topography=normal area=0.063 perim=1.14
MMPaoi10 VPWR A sndPA VPB pfet_01v8_hvt m=1 w=1.0 l=0.15 mult=1
+ sa=0.265 sb=0.265 sd=0.28 topography=normal area=0.063 perim=1.14
MMPaoi11 sndPA B Y VPB pfet_01v8_hvt m=1 w=1.0 l=0.15 mult=1 sa=0.265
+ sb=0.265 sd=0.28 topography=normal area=0.063 perim=1.14
MMPaoi20 Y inand VPWR VPB pfet_01v8_hvt m=1 w=1.0 l=0.15 mult=1
+ sa=0.265 sb=0.265 sd=0.28 topography=normal area=0.063 perim=1.14
.ENDS

.SUBCKT sky130_fd_sc_hd__xnor2_2 A B VGND VNB VPB VPWR Y
MMNnand0 VGND A sndNA VNB nfet_01v8 m=2 w=0.65 l=0.15 mult=1 sa=0.265
+ sb=0.265 sd=0.28 topography=normal area=0.063 perim=1.14
MMNnand1 sndNA B inand VNB nfet_01v8 m=2 w=0.65 l=0.15 mult=1 sa=0.265
+ sb=0.265 sd=0.28 topography=normal area=0.063 perim=1.14
MMNaoi10 nmid A VGND VNB nfet_01v8 m=2 w=0.65 l=0.15 mult=1 sa=0.265
+ sb=0.265 sd=0.28 topography=normal area=0.063 perim=1.14
MMNaoi11 nmid B VGND VNB nfet_01v8 m=2 w=0.65 l=0.15 mult=1 sa=0.265
+ sb=0.265 sd=0.28 topography=normal area=0.063 perim=1.14
MMNaoi20 Y inand nmid VNB nfet_01v8 m=2 w=0.65 l=0.15 mult=1 sa=0.265
+ sb=0.265 sd=0.28 topography=normal area=0.063 perim=1.14
MMPnand0 inand A VPWR VPB pfet_01v8_hvt m=2 w=1.0 l=0.15 mult=1
+ sa=0.265 sb=0.265 sd=0.28 topography=normal area=0.063 perim=1.14
MMPnand1 inand B VPWR VPB pfet_01v8_hvt m=2 w=1.0 l=0.15 mult=1
+ sa=0.265 sb=0.265 sd=0.28 topography=normal area=0.063 perim=1.14
MMPaoi10 VPWR A sndPA VPB pfet_01v8_hvt m=2 w=1.0 l=0.15 mult=1
+ sa=0.265 sb=0.265 sd=0.28 topography=normal area=0.063 perim=1.14
MMPaoi11 sndPA B Y VPB pfet_01v8_hvt m=2 w=1.0 l=0.15 mult=1 sa=0.265
+ sb=0.265 sd=0.28 topography=normal area=0.063 perim=1.14
MMPaoi20 Y inand VPWR VPB pfet_01v8_hvt m=2 w=1.0 l=0.15 mult=1
+ sa=0.265 sb=0.265 sd=0.28 topography=normal area=0.063 perim=1.14
.ENDS

.SUBCKT sky130_fd_sc_hd__xnor2_4 A B VGND VNB VPB VPWR Y
MMNnand0 VGND A sndNA VNB nfet_01v8 m=4 w=0.65 l=0.15 mult=1 sa=0.265
+ sb=0.265 sd=0.28 topography=normal area=0.063 perim=1.14
MMNnand1 sndNA B inand VNB nfet_01v8 m=4 w=0.65 l=0.15 mult=1 sa=0.265
+ sb=0.265 sd=0.28 topography=normal area=0.063 perim=1.14
MMNaoi10 nmid A VGND VNB nfet_01v8 m=4 w=0.65 l=0.15 mult=1 sa=0.265
+ sb=0.265 sd=0.28 topography=normal area=0.063 perim=1.14
MMNaoi11 nmid B VGND VNB nfet_01v8 m=4 w=0.65 l=0.15 mult=1 sa=0.265
+ sb=0.265 sd=0.28 topography=normal area=0.063 perim=1.14
MMNaoi20 Y inand nmid VNB nfet_01v8 m=4 w=0.65 l=0.15 mult=1 sa=0.265
+ sb=0.265 sd=0.28 topography=normal area=0.063 perim=1.14
MMPnand0 inand A VPWR VPB pfet_01v8_hvt m=4 w=1.0 l=0.15 mult=1
+ sa=0.265 sb=0.265 sd=0.28 topography=normal area=0.063 perim=1.14
MMPnand1 inand B VPWR VPB pfet_01v8_hvt m=4 w=1.0 l=0.15 mult=1
+ sa=0.265 sb=0.265 sd=0.28 topography=normal area=0.063 perim=1.14
MMPaoi10 VPWR A sndPA VPB pfet_01v8_hvt m=4 w=1.0 l=0.15 mult=1
+ sa=0.265 sb=0.265 sd=0.28 topography=normal area=0.063 perim=1.14
MMPaoi11 sndPA B Y VPB pfet_01v8_hvt m=4 w=1.0 l=0.15 mult=1 sa=0.265
+ sb=0.265 sd=0.28 topography=normal area=0.063 perim=1.14
MMPaoi20 Y inand VPWR VPB pfet_01v8_hvt m=4 w=1.0 l=0.15 mult=1
+ sa=0.265 sb=0.265 sd=0.28 topography=normal area=0.063 perim=1.14
.ENDS

.SUBCKT sky130_fd_sc_hd__xnor3_1 A B C VGND VNB VPB VPWR X
MMIN3 X net57 VGND VNB nfet_01v8 m=1 w=0.65 l=0.15 mult=1 sa=0.265
+ sb=0.265 sd=0.28 topography=normal area=0.063 perim=1.14
MI29 Ab Bb mid2 VNB nfet_01v8 m=1 w=0.6 l=0.15 mult=1 sa=0.265
+ sb=0.265 sd=0.28 topography=normal area=0.063 perim=1.14
MI25 Abb Bb mid1 VNB nfet_01v8 m=1 w=0.42 l=0.15 mult=1 sa=0.265
+ sb=0.265 sd=0.28 topography=normal area=0.063 perim=1.14
MI17 Bb B VGND VNB nfet_01v8 m=1 w=0.65 l=0.15 mult=1 sa=0.265
+ sb=0.265 sd=0.28 topography=normal area=0.063 perim=1.14
MI649 mid1 Cb net57 VNB nfet_01v8 m=1 w=0.64 l=0.15 mult=1 sa=0.265
+ sb=0.265 sd=0.28 topography=normal area=0.063 perim=1.14
MI44 Ab A VGND VNB nfet_01v8 m=1 w=0.64 l=0.15 mult=1 sa=0.265
+ sb=0.265 sd=0.28 topography=normal area=0.063 perim=1.14
MI34 Cb C VGND VNB nfet_01v8 m=1 w=0.42 l=0.15 mult=1 sa=0.265
+ sb=0.265 sd=0.28 topography=normal area=0.063 perim=1.14
MI2 mid2 C net57 VNB nfet_01v8 m=1 w=0.64 l=0.15 mult=1 sa=0.265
+ sb=0.265 sd=0.28 topography=normal area=0.063 perim=1.14
MI46 Abb Ab VGND VNB nfet_01v8 m=1 w=0.64 l=0.15 mult=1 sa=0.265
+ sb=0.265 sd=0.28 topography=normal area=0.063 perim=1.14
MI24 Ab B mid1 VNB nfet_01v8 m=1 w=0.64 l=0.15 mult=1 sa=0.265
+ sb=0.265 sd=0.28 topography=normal area=0.063 perim=1.14
MI28 Abb B mid2 VNB nfet_01v8 m=1 w=0.64 l=0.15 mult=1 sa=0.265
+ sb=0.265 sd=0.28 topography=normal area=0.063 perim=1.14
MMIP3 X net57 VPWR VPB pfet_01v8_hvt m=1 w=1.0 l=0.15 mult=1 sa=0.265
+ sb=0.265 sd=0.28 topography=normal area=0.063 perim=1.14
MI650 mid1 C net57 VPB pfet_01v8_hvt m=1 w=0.84 l=0.15 mult=1 sa=0.265
+ sb=0.265 sd=0.28 topography=normal area=0.063 perim=1.14
MI27 mid2 B Ab VPB pfet_01v8_hvt m=1 w=0.84 l=0.15 mult=1 sa=0.265
+ sb=0.265 sd=0.28 topography=normal area=0.063 perim=1.14
MI47 Abb Ab VPWR VPB pfet_01v8_hvt m=1 w=1.0 l=0.15 mult=1 sa=0.265
+ sb=0.265 sd=0.28 topography=normal area=0.063 perim=1.14
MI23 mid1 B Abb VPB pfet_01v8_hvt m=1 w=0.64 l=0.15 mult=1 sa=0.265
+ sb=0.265 sd=0.28 topography=normal area=0.063 perim=1.14
MI26 mid2 Bb Abb VPB pfet_01v8_hvt m=1 w=0.64 l=0.15 mult=1 sa=0.265
+ sb=0.265 sd=0.28 topography=normal area=0.063 perim=1.14
MI7 mid2 Cb net57 VPB pfet_01v8_hvt m=1 w=0.84 l=0.15 mult=1 sa=0.265
+ sb=0.265 sd=0.28 topography=normal area=0.063 perim=1.14
MI33 Cb C VPWR VPB pfet_01v8_hvt m=1 w=0.64 l=0.15 mult=1 sa=0.265
+ sb=0.265 sd=0.28 topography=normal area=0.063 perim=1.14
MI45 Ab A VPWR VPB pfet_01v8_hvt m=1 w=1.0 l=0.15 mult=1 sa=0.265
+ sb=0.265 sd=0.28 topography=normal area=0.063 perim=1.14
MI16 Bb B VPWR VPB pfet_01v8_hvt m=1 w=1.0 l=0.15 mult=1 sa=0.265
+ sb=0.265 sd=0.28 topography=normal area=0.063 perim=1.14
MI19 mid1 Bb Ab VPB pfet_01v8_hvt m=1 w=0.84 l=0.15 mult=1 sa=0.265
+ sb=0.265 sd=0.28 topography=normal area=0.063 perim=1.14
.ENDS

.SUBCKT sky130_fd_sc_hd__xnor3_2 A B C VGND VNB VPB VPWR X
MMIN3 X net57 VGND VNB nfet_01v8 m=2 w=0.65 l=0.15 mult=1 sa=0.265
+ sb=0.265 sd=0.28 topography=normal area=0.063 perim=1.14
MI29 Ab Bb mid2 VNB nfet_01v8 m=1 w=0.6 l=0.15 mult=1 sa=0.265
+ sb=0.265 sd=0.28 topography=normal area=0.063 perim=1.14
MI25 Abb Bb mid1 VNB nfet_01v8 m=1 w=0.42 l=0.15 mult=1 sa=0.265
+ sb=0.265 sd=0.28 topography=normal area=0.063 perim=1.14
MI17 Bb B VGND VNB nfet_01v8 m=1 w=0.65 l=0.15 mult=1 sa=0.265
+ sb=0.265 sd=0.28 topography=normal area=0.063 perim=1.14
MI649 mid1 Cb net57 VNB nfet_01v8 m=1 w=0.64 l=0.15 mult=1 sa=0.265
+ sb=0.265 sd=0.28 topography=normal area=0.063 perim=1.14
MI44 Ab A VGND VNB nfet_01v8 m=1 w=0.64 l=0.15 mult=1 sa=0.265
+ sb=0.265 sd=0.28 topography=normal area=0.063 perim=1.14
MI34 Cb C VGND VNB nfet_01v8 m=1 w=0.42 l=0.15 mult=1 sa=0.265
+ sb=0.265 sd=0.28 topography=normal area=0.063 perim=1.14
MI2 mid2 C net57 VNB nfet_01v8 m=1 w=0.64 l=0.15 mult=1 sa=0.265
+ sb=0.265 sd=0.28 topography=normal area=0.063 perim=1.14
MI46 Abb Ab VGND VNB nfet_01v8 m=1 w=0.64 l=0.15 mult=1 sa=0.265
+ sb=0.265 sd=0.28 topography=normal area=0.063 perim=1.14
MI24 Ab B mid1 VNB nfet_01v8 m=1 w=0.64 l=0.15 mult=1 sa=0.265
+ sb=0.265 sd=0.28 topography=normal area=0.063 perim=1.14
MI28 Abb B mid2 VNB nfet_01v8 m=1 w=0.64 l=0.15 mult=1 sa=0.265
+ sb=0.265 sd=0.28 topography=normal area=0.063 perim=1.14
MMIP3 X net57 VPWR VPB pfet_01v8_hvt m=2 w=1.0 l=0.15 mult=1 sa=0.265
+ sb=0.265 sd=0.28 topography=normal area=0.063 perim=1.14
MI650 mid1 C net57 VPB pfet_01v8_hvt m=1 w=0.84 l=0.15 mult=1 sa=0.265
+ sb=0.265 sd=0.28 topography=normal area=0.063 perim=1.14
MI27 mid2 B Ab VPB pfet_01v8_hvt m=1 w=0.84 l=0.15 mult=1 sa=0.265
+ sb=0.265 sd=0.28 topography=normal area=0.063 perim=1.14
MI47 Abb Ab VPWR VPB pfet_01v8_hvt m=1 w=1.0 l=0.15 mult=1 sa=0.265
+ sb=0.265 sd=0.28 topography=normal area=0.063 perim=1.14
MI23 mid1 B Abb VPB pfet_01v8_hvt m=1 w=0.64 l=0.15 mult=1 sa=0.265
+ sb=0.265 sd=0.28 topography=normal area=0.063 perim=1.14
MI26 mid2 Bb Abb VPB pfet_01v8_hvt m=1 w=0.64 l=0.15 mult=1 sa=0.265
+ sb=0.265 sd=0.28 topography=normal area=0.063 perim=1.14
MI7 mid2 Cb net57 VPB pfet_01v8_hvt m=1 w=0.84 l=0.15 mult=1 sa=0.265
+ sb=0.265 sd=0.28 topography=normal area=0.063 perim=1.14
MI33 Cb C VPWR VPB pfet_01v8_hvt m=1 w=0.64 l=0.15 mult=1 sa=0.265
+ sb=0.265 sd=0.28 topography=normal area=0.063 perim=1.14
MI45 Ab A VPWR VPB pfet_01v8_hvt m=1 w=1.0 l=0.15 mult=1 sa=0.265
+ sb=0.265 sd=0.28 topography=normal area=0.063 perim=1.14
MI16 Bb B VPWR VPB pfet_01v8_hvt m=1 w=1.0 l=0.15 mult=1 sa=0.265
+ sb=0.265 sd=0.28 topography=normal area=0.063 perim=1.14
MI19 mid1 Bb Ab VPB pfet_01v8_hvt m=1 w=0.84 l=0.15 mult=1 sa=0.265
+ sb=0.265 sd=0.28 topography=normal area=0.063 perim=1.14
.ENDS

.SUBCKT sky130_fd_sc_hd__xnor3_4 A B C VGND VNB VPB VPWR X
MMIN3 X net57 VGND VNB nfet_01v8 m=4 w=0.65 l=0.15 mult=1 sa=0.265
+ sb=0.265 sd=0.28 topography=normal area=0.063 perim=1.14
MI29 Ab Bb mid2 VNB nfet_01v8 m=1 w=0.6 l=0.15 mult=1 sa=0.265
+ sb=0.265 sd=0.28 topography=normal area=0.063 perim=1.14
MI25 Abb Bb mid1 VNB nfet_01v8 m=1 w=0.42 l=0.15 mult=1 sa=0.265
+ sb=0.265 sd=0.28 topography=normal area=0.063 perim=1.14
MI17 Bb B VGND VNB nfet_01v8 m=1 w=0.65 l=0.15 mult=1 sa=0.265
+ sb=0.265 sd=0.28 topography=normal area=0.063 perim=1.14
MI649 mid1 Cb net57 VNB nfet_01v8 m=1 w=0.64 l=0.15 mult=1 sa=0.265
+ sb=0.265 sd=0.28 topography=normal area=0.063 perim=1.14
MI44 Ab A VGND VNB nfet_01v8 m=1 w=0.64 l=0.15 mult=1 sa=0.265
+ sb=0.265 sd=0.28 topography=normal area=0.063 perim=1.14
MI34 Cb C VGND VNB nfet_01v8 m=1 w=0.42 l=0.15 mult=1 sa=0.265
+ sb=0.265 sd=0.28 topography=normal area=0.063 perim=1.14
MI2 mid2 C net57 VNB nfet_01v8 m=1 w=0.64 l=0.15 mult=1 sa=0.265
+ sb=0.265 sd=0.28 topography=normal area=0.063 perim=1.14
MI46 Abb Ab VGND VNB nfet_01v8 m=1 w=0.64 l=0.15 mult=1 sa=0.265
+ sb=0.265 sd=0.28 topography=normal area=0.063 perim=1.14
MI24 Ab B mid1 VNB nfet_01v8 m=1 w=0.64 l=0.15 mult=1 sa=0.265
+ sb=0.265 sd=0.28 topography=normal area=0.063 perim=1.14
MI28 Abb B mid2 VNB nfet_01v8 m=1 w=0.64 l=0.15 mult=1 sa=0.265
+ sb=0.265 sd=0.28 topography=normal area=0.063 perim=1.14
MMIP3 X net57 VPWR VPB pfet_01v8_hvt m=4 w=1.0 l=0.15 mult=1 sa=0.265
+ sb=0.265 sd=0.28 topography=normal area=0.063 perim=1.14
MI650 mid1 C net57 VPB pfet_01v8_hvt m=1 w=0.84 l=0.15 mult=1 sa=0.265
+ sb=0.265 sd=0.28 topography=normal area=0.063 perim=1.14
MI27 mid2 B Ab VPB pfet_01v8_hvt m=1 w=0.84 l=0.15 mult=1 sa=0.265
+ sb=0.265 sd=0.28 topography=normal area=0.063 perim=1.14
MI47 Abb Ab VPWR VPB pfet_01v8_hvt m=1 w=1.0 l=0.15 mult=1 sa=0.265
+ sb=0.265 sd=0.28 topography=normal area=0.063 perim=1.14
MI23 mid1 B Abb VPB pfet_01v8_hvt m=1 w=0.64 l=0.15 mult=1 sa=0.265
+ sb=0.265 sd=0.28 topography=normal area=0.063 perim=1.14
MI26 mid2 Bb Abb VPB pfet_01v8_hvt m=1 w=0.64 l=0.15 mult=1 sa=0.265
+ sb=0.265 sd=0.28 topography=normal area=0.063 perim=1.14
MI7 mid2 Cb net57 VPB pfet_01v8_hvt m=1 w=0.84 l=0.15 mult=1 sa=0.265
+ sb=0.265 sd=0.28 topography=normal area=0.063 perim=1.14
MI33 Cb C VPWR VPB pfet_01v8_hvt m=1 w=0.64 l=0.15 mult=1 sa=0.265
+ sb=0.265 sd=0.28 topography=normal area=0.063 perim=1.14
MI45 Ab A VPWR VPB pfet_01v8_hvt m=1 w=1.0 l=0.15 mult=1 sa=0.265
+ sb=0.265 sd=0.28 topography=normal area=0.063 perim=1.14
MI16 Bb B VPWR VPB pfet_01v8_hvt m=1 w=1.0 l=0.15 mult=1 sa=0.265
+ sb=0.265 sd=0.28 topography=normal area=0.063 perim=1.14
MI19 mid1 Bb Ab VPB pfet_01v8_hvt m=1 w=0.84 l=0.15 mult=1 sa=0.265
+ sb=0.265 sd=0.28 topography=normal area=0.063 perim=1.14
.ENDS

.SUBCKT sky130_fd_sc_hd__xor2_1 A B VGND VNB VPB VPWR X
MMNnor0 inor A VGND VNB nfet_01v8 m=1 w=0.65 l=0.15 mult=1 sa=0.265
+ sb=0.265 sd=0.28 topography=normal area=0.063 perim=1.14
MMNnor1 inor B VGND VNB nfet_01v8 m=1 w=0.65 l=0.15 mult=1 sa=0.265
+ sb=0.265 sd=0.28 topography=normal area=0.063 perim=1.14
MMNaoi10 VGND A sndNA VNB nfet_01v8 m=1 w=0.65 l=0.15 mult=1 sa=0.265
+ sb=0.265 sd=0.28 topography=normal area=0.063 perim=1.14
MMNaoi11 sndNA B X VNB nfet_01v8 m=1 w=0.65 l=0.15 mult=1 sa=0.265
+ sb=0.265 sd=0.28 topography=normal area=0.063 perim=1.14
MMNaoi20 X inor VGND VNB nfet_01v8 m=1 w=0.65 l=0.15 mult=1 sa=0.265
+ sb=0.265 sd=0.28 topography=normal area=0.063 perim=1.14
MMPnor0 VPWR A sndPA VPB pfet_01v8_hvt m=1 w=1.0 l=0.15 mult=1
+ sa=0.265 sb=0.265 sd=0.28 topography=normal area=0.063 perim=1.14
MMPnor1 sndPA B inor VPB pfet_01v8_hvt m=1 w=1.0 l=0.15 mult=1
+ sa=0.265 sb=0.265 sd=0.28 topography=normal area=0.063 perim=1.14
MMPaoi10 pmid A VPWR VPB pfet_01v8_hvt m=1 w=1.0 l=0.15 mult=1
+ sa=0.265 sb=0.265 sd=0.28 topography=normal area=0.063 perim=1.14
MMPaoi11 pmid B VPWR VPB pfet_01v8_hvt m=1 w=1.0 l=0.15 mult=1
+ sa=0.265 sb=0.265 sd=0.28 topography=normal area=0.063 perim=1.14
MMPaoi20 X inor pmid VPB pfet_01v8_hvt m=1 w=1.0 l=0.15 mult=1
+ sa=0.265 sb=0.265 sd=0.28 topography=normal area=0.063 perim=1.14
.ENDS

.SUBCKT sky130_fd_sc_hd__xor2_2 A B VGND VNB VPB VPWR X
MMNnor0 inor A VGND VNB nfet_01v8 m=2 w=0.65 l=0.15 mult=1 sa=0.265
+ sb=0.265 sd=0.28 topography=normal area=0.063 perim=1.14
MMNnor1 inor B VGND VNB nfet_01v8 m=2 w=0.65 l=0.15 mult=1 sa=0.265
+ sb=0.265 sd=0.28 topography=normal area=0.063 perim=1.14
MMNaoi10 VGND A sndNA VNB nfet_01v8 m=2 w=0.65 l=0.15 mult=1 sa=0.265
+ sb=0.265 sd=0.28 topography=normal area=0.063 perim=1.14
MMNaoi11 sndNA B X VNB nfet_01v8 m=2 w=0.65 l=0.15 mult=1 sa=0.265
+ sb=0.265 sd=0.28 topography=normal area=0.063 perim=1.14
MMNaoi20 X inor VGND VNB nfet_01v8 m=2 w=0.65 l=0.15 mult=1 sa=0.265
+ sb=0.265 sd=0.28 topography=normal area=0.063 perim=1.14
MMPnor0 VPWR A sndPA VPB pfet_01v8_hvt m=2 w=1.0 l=0.15 mult=1
+ sa=0.265 sb=0.265 sd=0.28 topography=normal area=0.063 perim=1.14
MMPnor1 sndPA B inor VPB pfet_01v8_hvt m=2 w=1.0 l=0.15 mult=1
+ sa=0.265 sb=0.265 sd=0.28 topography=normal area=0.063 perim=1.14
MMPaoi10 pmid A VPWR VPB pfet_01v8_hvt m=2 w=1.0 l=0.15 mult=1
+ sa=0.265 sb=0.265 sd=0.28 topography=normal area=0.063 perim=1.14
MMPaoi11 pmid B VPWR VPB pfet_01v8_hvt m=2 w=1.0 l=0.15 mult=1
+ sa=0.265 sb=0.265 sd=0.28 topography=normal area=0.063 perim=1.14
MMPaoi20 X inor pmid VPB pfet_01v8_hvt m=2 w=1.0 l=0.15 mult=1
+ sa=0.265 sb=0.265 sd=0.28 topography=normal area=0.063 perim=1.14
.ENDS

.SUBCKT sky130_fd_sc_hd__xor2_4 A B VGND VNB VPB VPWR X
MMNnor0 inor A VGND VNB nfet_01v8 m=4 w=0.65 l=0.15 mult=1 sa=0.265
+ sb=0.265 sd=0.28 topography=normal area=0.063 perim=1.14
MMNnor1 inor B VGND VNB nfet_01v8 m=4 w=0.65 l=0.15 mult=1 sa=0.265
+ sb=0.265 sd=0.28 topography=normal area=0.063 perim=1.14
MMNaoi10 VGND A sndNA VNB nfet_01v8 m=4 w=0.65 l=0.15 mult=1 sa=0.265
+ sb=0.265 sd=0.28 topography=normal area=0.063 perim=1.14
MMNaoi11 sndNA B X VNB nfet_01v8 m=4 w=0.65 l=0.15 mult=1 sa=0.265
+ sb=0.265 sd=0.28 topography=normal area=0.063 perim=1.14
MMNaoi20 X inor VGND VNB nfet_01v8 m=4 w=0.65 l=0.15 mult=1 sa=0.265
+ sb=0.265 sd=0.28 topography=normal area=0.063 perim=1.14
MMPnor0 VPWR A sndPA VPB pfet_01v8_hvt m=4 w=1.0 l=0.15 mult=1
+ sa=0.265 sb=0.265 sd=0.28 topography=normal area=0.063 perim=1.14
MMPnor1 sndPA B inor VPB pfet_01v8_hvt m=4 w=1.0 l=0.15 mult=1
+ sa=0.265 sb=0.265 sd=0.28 topography=normal area=0.063 perim=1.14
MMPaoi10 pmid A VPWR VPB pfet_01v8_hvt m=4 w=1.0 l=0.15 mult=1
+ sa=0.265 sb=0.265 sd=0.28 topography=normal area=0.063 perim=1.14
MMPaoi11 pmid B VPWR VPB pfet_01v8_hvt m=4 w=1.0 l=0.15 mult=1
+ sa=0.265 sb=0.265 sd=0.28 topography=normal area=0.063 perim=1.14
MMPaoi20 X inor pmid VPB pfet_01v8_hvt m=4 w=1.0 l=0.15 mult=1
+ sa=0.265 sb=0.265 sd=0.28 topography=normal area=0.063 perim=1.14
.ENDS

.SUBCKT sky130_fd_sc_hd__xor3_1 A B C VGND VNB VPB VPWR X
MMIP3 X net117 VPWR VPB pfet_01v8_hvt m=1 w=1.0 l=0.15 mult=1 sa=0.265
+ sb=0.265 sd=0.28 topography=normal area=0.063 perim=1.14
MI650 mid1 Cb net117 VPB pfet_01v8_hvt m=1 w=0.84 l=0.15 mult=1
+ sa=0.265 sb=0.265 sd=0.28 topography=normal area=0.063 perim=1.14
MI1 mid2 C net117 VPB pfet_01v8_hvt m=1 w=0.84 l=0.15 mult=1 sa=0.265
+ sb=0.265 sd=0.28 topography=normal area=0.063 perim=1.14
MI33 Cb C VPWR VPB pfet_01v8_hvt m=1 w=0.64 l=0.15 mult=1 sa=0.265
+ sb=0.265 sd=0.28 topography=normal area=0.063 perim=1.14
MI45 Ab A VPWR VPB pfet_01v8_hvt m=1 w=1.0 l=0.15 mult=1 sa=0.265
+ sb=0.265 sd=0.28 topography=normal area=0.063 perim=1.14
MI47 Abb Ab VPWR VPB pfet_01v8_hvt m=1 w=1.0 l=0.15 mult=1 sa=0.265
+ sb=0.265 sd=0.28 topography=normal area=0.063 perim=1.14
MI19 mid1 Bb Ab VPB pfet_01v8_hvt m=1 w=0.84 l=0.15 mult=1 sa=0.265
+ sb=0.265 sd=0.28 topography=normal area=0.063 perim=1.14
MI16 Bb B VPWR VPB pfet_01v8_hvt m=1 w=1.0 l=0.15 mult=1 sa=0.265
+ sb=0.265 sd=0.28 topography=normal area=0.063 perim=1.14
MI23 mid1 B Abb VPB pfet_01v8_hvt m=1 w=0.64 l=0.15 mult=1 sa=0.265
+ sb=0.265 sd=0.28 topography=normal area=0.063 perim=1.14
MI26 mid2 Bb Abb VPB pfet_01v8_hvt m=1 w=0.64 l=0.15 mult=1 sa=0.265
+ sb=0.265 sd=0.28 topography=normal area=0.063 perim=1.14
MI27 mid2 B Ab VPB pfet_01v8_hvt m=1 w=0.84 l=0.15 mult=1 sa=0.265
+ sb=0.265 sd=0.28 topography=normal area=0.063 perim=1.14
MMIN3 X net117 VGND VNB nfet_01v8 m=1 w=0.65 l=0.15 mult=1 sa=0.265
+ sb=0.265 sd=0.28 topography=normal area=0.063 perim=1.14
MI34 Cb C VGND VNB nfet_01v8 m=1 w=0.42 l=0.15 mult=1 sa=0.265
+ sb=0.265 sd=0.28 topography=normal area=0.063 perim=1.14
MI649 mid1 C net117 VNB nfet_01v8 m=1 w=0.64 l=0.15 mult=1 sa=0.265
+ sb=0.265 sd=0.28 topography=normal area=0.063 perim=1.14
MI2 mid2 Cb net117 VNB nfet_01v8 m=1 w=0.64 l=0.15 mult=1 sa=0.265
+ sb=0.265 sd=0.28 topography=normal area=0.063 perim=1.14
MI44 Ab A VGND VNB nfet_01v8 m=1 w=0.64 l=0.15 mult=1 sa=0.265
+ sb=0.265 sd=0.28 topography=normal area=0.063 perim=1.14
MI46 Abb Ab VGND VNB nfet_01v8 m=1 w=0.64 l=0.15 mult=1 sa=0.265
+ sb=0.265 sd=0.28 topography=normal area=0.063 perim=1.14
MI17 Bb B VGND VNB nfet_01v8 m=1 w=0.65 l=0.15 mult=1 sa=0.265
+ sb=0.265 sd=0.28 topography=normal area=0.063 perim=1.14
MI24 Ab B mid1 VNB nfet_01v8 m=1 w=0.64 l=0.15 mult=1 sa=0.265
+ sb=0.265 sd=0.28 topography=normal area=0.063 perim=1.14
MI25 Abb Bb mid1 VNB nfet_01v8 m=1 w=0.42 l=0.15 mult=1 sa=0.265
+ sb=0.265 sd=0.28 topography=normal area=0.063 perim=1.14
MI28 Abb B mid2 VNB nfet_01v8 m=1 w=0.64 l=0.15 mult=1 sa=0.265
+ sb=0.265 sd=0.28 topography=normal area=0.063 perim=1.14
MI29 Ab Bb mid2 VNB nfet_01v8 m=1 w=0.6 l=0.15 mult=1 sa=0.265
+ sb=0.265 sd=0.28 topography=normal area=0.063 perim=1.14
.ENDS

.SUBCKT sky130_fd_sc_hd__xor3_2 A B C VGND VNB VPB VPWR X
MMIP3 X net117 VPWR VPB pfet_01v8_hvt m=2 w=1.0 l=0.15 mult=1 sa=0.265
+ sb=0.265 sd=0.28 topography=normal area=0.063 perim=1.14
MI650 mid1 Cb net117 VPB pfet_01v8_hvt m=1 w=0.84 l=0.15 mult=1
+ sa=0.265 sb=0.265 sd=0.28 topography=normal area=0.063 perim=1.14
MI1 mid2 C net117 VPB pfet_01v8_hvt m=1 w=0.84 l=0.15 mult=1 sa=0.265
+ sb=0.265 sd=0.28 topography=normal area=0.063 perim=1.14
MI33 Cb C VPWR VPB pfet_01v8_hvt m=1 w=0.64 l=0.15 mult=1 sa=0.265
+ sb=0.265 sd=0.28 topography=normal area=0.063 perim=1.14
MI45 Ab A VPWR VPB pfet_01v8_hvt m=1 w=1.0 l=0.15 mult=1 sa=0.265
+ sb=0.265 sd=0.28 topography=normal area=0.063 perim=1.14
MI47 Abb Ab VPWR VPB pfet_01v8_hvt m=1 w=1.0 l=0.15 mult=1 sa=0.265
+ sb=0.265 sd=0.28 topography=normal area=0.063 perim=1.14
MI19 mid1 Bb Ab VPB pfet_01v8_hvt m=1 w=0.84 l=0.15 mult=1 sa=0.265
+ sb=0.265 sd=0.28 topography=normal area=0.063 perim=1.14
MI16 Bb B VPWR VPB pfet_01v8_hvt m=1 w=1.0 l=0.15 mult=1 sa=0.265
+ sb=0.265 sd=0.28 topography=normal area=0.063 perim=1.14
MI23 mid1 B Abb VPB pfet_01v8_hvt m=1 w=0.64 l=0.15 mult=1 sa=0.265
+ sb=0.265 sd=0.28 topography=normal area=0.063 perim=1.14
MI26 mid2 Bb Abb VPB pfet_01v8_hvt m=1 w=0.64 l=0.15 mult=1 sa=0.265
+ sb=0.265 sd=0.28 topography=normal area=0.063 perim=1.14
MI27 mid2 B Ab VPB pfet_01v8_hvt m=1 w=0.84 l=0.15 mult=1 sa=0.265
+ sb=0.265 sd=0.28 topography=normal area=0.063 perim=1.14
MMIN3 X net117 VGND VNB nfet_01v8 m=2 w=0.65 l=0.15 mult=1 sa=0.265
+ sb=0.265 sd=0.28 topography=normal area=0.063 perim=1.14
MI34 Cb C VGND VNB nfet_01v8 m=1 w=0.42 l=0.15 mult=1 sa=0.265
+ sb=0.265 sd=0.28 topography=normal area=0.063 perim=1.14
MI649 mid1 C net117 VNB nfet_01v8 m=1 w=0.64 l=0.15 mult=1 sa=0.265
+ sb=0.265 sd=0.28 topography=normal area=0.063 perim=1.14
MI2 mid2 Cb net117 VNB nfet_01v8 m=1 w=0.64 l=0.15 mult=1 sa=0.265
+ sb=0.265 sd=0.28 topography=normal area=0.063 perim=1.14
MI44 Ab A VGND VNB nfet_01v8 m=1 w=0.64 l=0.15 mult=1 sa=0.265
+ sb=0.265 sd=0.28 topography=normal area=0.063 perim=1.14
MI46 Abb Ab VGND VNB nfet_01v8 m=1 w=0.64 l=0.15 mult=1 sa=0.265
+ sb=0.265 sd=0.28 topography=normal area=0.063 perim=1.14
MI17 Bb B VGND VNB nfet_01v8 m=1 w=0.65 l=0.15 mult=1 sa=0.265
+ sb=0.265 sd=0.28 topography=normal area=0.063 perim=1.14
MI24 Ab B mid1 VNB nfet_01v8 m=1 w=0.64 l=0.15 mult=1 sa=0.265
+ sb=0.265 sd=0.28 topography=normal area=0.063 perim=1.14
MI25 Abb Bb mid1 VNB nfet_01v8 m=1 w=0.42 l=0.15 mult=1 sa=0.265
+ sb=0.265 sd=0.28 topography=normal area=0.063 perim=1.14
MI28 Abb B mid2 VNB nfet_01v8 m=1 w=0.64 l=0.15 mult=1 sa=0.265
+ sb=0.265 sd=0.28 topography=normal area=0.063 perim=1.14
MI29 Ab Bb mid2 VNB nfet_01v8 m=1 w=0.6 l=0.15 mult=1 sa=0.265
+ sb=0.265 sd=0.28 topography=normal area=0.063 perim=1.14
.ENDS

.SUBCKT sky130_fd_sc_hd__xor3_4 A B C VGND VNB VPB VPWR X
MMIP3 X net117 VPWR VPB pfet_01v8_hvt m=4 w=1.0 l=0.15 mult=1 sa=0.265
+ sb=0.265 sd=0.28 topography=normal area=0.063 perim=1.14
MI650 mid1 Cb net117 VPB pfet_01v8_hvt m=1 w=0.84 l=0.15 mult=1
+ sa=0.265 sb=0.265 sd=0.28 topography=normal area=0.063 perim=1.14
MI1 mid2 C net117 VPB pfet_01v8_hvt m=1 w=0.84 l=0.15 mult=1 sa=0.265
+ sb=0.265 sd=0.28 topography=normal area=0.063 perim=1.14
MI33 Cb C VPWR VPB pfet_01v8_hvt m=1 w=0.64 l=0.15 mult=1 sa=0.265
+ sb=0.265 sd=0.28 topography=normal area=0.063 perim=1.14
MI45 Ab A VPWR VPB pfet_01v8_hvt m=1 w=1.0 l=0.15 mult=1 sa=0.265
+ sb=0.265 sd=0.28 topography=normal area=0.063 perim=1.14
MI47 Abb Ab VPWR VPB pfet_01v8_hvt m=1 w=1.0 l=0.15 mult=1 sa=0.265
+ sb=0.265 sd=0.28 topography=normal area=0.063 perim=1.14
MI19 mid1 Bb Ab VPB pfet_01v8_hvt m=1 w=0.84 l=0.15 mult=1 sa=0.265
+ sb=0.265 sd=0.28 topography=normal area=0.063 perim=1.14
MI16 Bb B VPWR VPB pfet_01v8_hvt m=1 w=1.0 l=0.15 mult=1 sa=0.265
+ sb=0.265 sd=0.28 topography=normal area=0.063 perim=1.14
MI23 mid1 B Abb VPB pfet_01v8_hvt m=1 w=0.64 l=0.15 mult=1 sa=0.265
+ sb=0.265 sd=0.28 topography=normal area=0.063 perim=1.14
MI26 mid2 Bb Abb VPB pfet_01v8_hvt m=1 w=0.64 l=0.15 mult=1 sa=0.265
+ sb=0.265 sd=0.28 topography=normal area=0.063 perim=1.14
MI27 mid2 B Ab VPB pfet_01v8_hvt m=1 w=0.84 l=0.15 mult=1 sa=0.265
+ sb=0.265 sd=0.28 topography=normal area=0.063 perim=1.14
MMIN3 X net117 VGND VNB nfet_01v8 m=4 w=0.65 l=0.15 mult=1 sa=0.265
+ sb=0.265 sd=0.28 topography=normal area=0.063 perim=1.14
MI34 Cb C VGND VNB nfet_01v8 m=1 w=0.42 l=0.15 mult=1 sa=0.265
+ sb=0.265 sd=0.28 topography=normal area=0.063 perim=1.14
MI649 mid1 C net117 VNB nfet_01v8 m=1 w=0.64 l=0.15 mult=1 sa=0.265
+ sb=0.265 sd=0.28 topography=normal area=0.063 perim=1.14
MI2 mid2 Cb net117 VNB nfet_01v8 m=1 w=0.64 l=0.15 mult=1 sa=0.265
+ sb=0.265 sd=0.28 topography=normal area=0.063 perim=1.14
MI44 Ab A VGND VNB nfet_01v8 m=1 w=0.64 l=0.15 mult=1 sa=0.265
+ sb=0.265 sd=0.28 topography=normal area=0.063 perim=1.14
MI46 Abb Ab VGND VNB nfet_01v8 m=1 w=0.64 l=0.15 mult=1 sa=0.265
+ sb=0.265 sd=0.28 topography=normal area=0.063 perim=1.14
MI17 Bb B VGND VNB nfet_01v8 m=1 w=0.65 l=0.15 mult=1 sa=0.265
+ sb=0.265 sd=0.28 topography=normal area=0.063 perim=1.14
MI24 Ab B mid1 VNB nfet_01v8 m=1 w=0.64 l=0.15 mult=1 sa=0.265
+ sb=0.265 sd=0.28 topography=normal area=0.063 perim=1.14
MI25 Abb Bb mid1 VNB nfet_01v8 m=1 w=0.42 l=0.15 mult=1 sa=0.265
+ sb=0.265 sd=0.28 topography=normal area=0.063 perim=1.14
MI28 Abb B mid2 VNB nfet_01v8 m=1 w=0.64 l=0.15 mult=1 sa=0.265
+ sb=0.265 sd=0.28 topography=normal area=0.063 perim=1.14
MI29 Ab Bb mid2 VNB nfet_01v8 m=1 w=0.6 l=0.15 mult=1 sa=0.265
+ sb=0.265 sd=0.28 topography=normal area=0.063 perim=1.14
.ENDS

.subckt mult_comb_32x32 VGND VPWR mcand[0] mcand[10] mcand[11] mcand[12] mcand[13]
+ mcand[14] mcand[15] mcand[16] mcand[17] mcand[18] mcand[19] mcand[1] mcand[20] mcand[21]
+ mcand[22] mcand[23] mcand[24] mcand[25] mcand[26] mcand[27] mcand[28] mcand[29]
+ mcand[2] mcand[30] mcand[31] mcand[3] mcand[4] mcand[5] mcand[6] mcand[7] mcand[8]
+ mcand[9] mplier[0] mplier[10] mplier[11] mplier[12] mplier[13] mplier[14] mplier[15]
+ mplier[16] mplier[17] mplier[18] mplier[19] mplier[1] mplier[20] mplier[21] mplier[22]
+ mplier[23] mplier[24] mplier[25] mplier[26] mplier[27] mplier[28] mplier[29] mplier[2]
+ mplier[30] mplier[31] mplier[3] mplier[4] mplier[5] mplier[6] mplier[7] mplier[8]
+ mplier[9] product[0] product[10] product[11] product[12] product[13] product[14]
+ product[15] product[16] product[17] product[18] product[19] product[1] product[20]
+ product[21] product[22] product[23] product[24] product[25] product[26] product[27]
+ product[28] product[29] product[2] product[30] product[31] product[32] product[33]
+ product[34] product[35] product[36] product[37] product[38] product[39] product[3]
+ product[40] product[41] product[42] product[43] product[44] product[45] product[46]
+ product[47] product[48] product[49] product[4] product[50] product[51] product[52]
+ product[53] product[54] product[55] product[56] product[57] product[58] product[59]
+ product[5] product[60] product[61] product[62] product[63] product[6] product[7]
+ product[8] product[9]
XFILLER_0_94_55 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
X_05903_ _00832_ VGND VGND VPWR VPWR _02513_ sky130_fd_sc_hd__clkbuf_4
X_09671_ _03350_ _03351_ _03352_ VGND VGND VPWR VPWR _03355_ sky130_fd_sc_hd__a21o_1
X_06883_ _00307_ _00309_ _00299_ VGND VGND VPWR VPWR _00311_ sky130_fd_sc_hd__a21o_1
X_05834_ _00395_ VGND VGND VPWR VPWR _01760_ sky130_fd_sc_hd__clkbuf_4
X_08622_ _02007_ _02085_ _02207_ _02209_ VGND VGND VPWR VPWR _02210_ sky130_fd_sc_hd__o211ai_2
X_08553_ _00094_ VGND VGND VPWR VPWR _02134_ sky130_fd_sc_hd__clkbuf_4
X_05765_ _00297_ VGND VGND VPWR VPWR _01007_ sky130_fd_sc_hd__buf_4
XFILLER_0_77_645 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_0_76_133 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
X_08484_ _04737_ _00750_ _01900_ _01899_ _00610_ VGND VGND VPWR VPWR _02058_ sky130_fd_sc_hd__a32o_1
XTAP_TAPCELL_ROW_53_927 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
X_07504_ _00986_ _00988_ VGND VGND VPWR VPWR _00989_ sky130_fd_sc_hd__xnor2_2
X_07435_ _00912_ VGND VGND VPWR VPWR _00913_ sky130_fd_sc_hd__inv_2
XFILLER_0_49_369 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_0_18_701 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_43_81 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XPHY_EDGE_ROW_99_Left_221 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_0_9_455 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_17_222 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XTAP_TAPCELL_ROW_33_673 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_91_169 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XFILLER_0_91_158 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_07366_ _02447_ _00843_ _00695_ _00837_ VGND VGND VPWR VPWR _00838_ sky130_fd_sc_hd__nand4_2
X_09105_ _02734_ _02736_ VGND VGND VPWR VPWR _02737_ sky130_fd_sc_hd__xnor2_2
XFILLER_0_60_501 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
X_07297_ _00623_ VGND VGND VPWR VPWR _00762_ sky130_fd_sc_hd__buf_4
XFILLER_0_17_277 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
X_06317_ _05378_ _05379_ _05447_ VGND VGND VPWR VPWR _05449_ sky130_fd_sc_hd__or3_1
XFILLER_0_115_485 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
X_09036_ _02658_ _02659_ _02618_ VGND VGND VPWR VPWR _02661_ sky130_fd_sc_hd__a21oi_1
XFILLER_0_60_556 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_32_225 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_06248_ _05303_ _05322_ VGND VGND VPWR VPWR _05380_ sky130_fd_sc_hd__and2b_1
XFILLER_0_102_135 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_0_103_669 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_0_102_146 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
X_06179_ _05306_ _05309_ _01236_ _05311_ VGND VGND VPWR VPWR _05312_ sky130_fd_sc_hd__and4b_1
XFILLER_0_7_81 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
X_09938_ _03606_ _03644_ _03645_ VGND VGND VPWR VPWR _03646_ sky130_fd_sc_hd__and3_1
XTAP_TAPCELL_ROW_5_321 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_99_225 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
X_09869_ _00349_ _00983_ _01109_ _00150_ VGND VGND VPWR VPWR _03570_ sky130_fd_sc_hd__a22o_1
XFILLER_0_67_100 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_68_645 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_0_67_133 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_95_464 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_0_68_678 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
X_10713_ _04488_ _04489_ VGND VGND VPWR VPWR _04490_ sky130_fd_sc_hd__xnor2_1
X_10644_ _04316_ _04318_ VGND VGND VPWR VPWR _04416_ sky130_fd_sc_hd__nand2_1
XFILLER_0_82_158 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_0_70_309 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_36_531 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
X_10575_ _04252_ _04230_ _04339_ _04340_ VGND VGND VPWR VPWR _04341_ sky130_fd_sc_hd__o211ai_4
XFILLER_0_51_501 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_0_3_609 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_0_23_214 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_106_474 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XFILLER_0_23_225 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_0_121_444 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_51_589 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_121_477 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
X_11127_ _04938_ _04939_ VGND VGND VPWR VPWR net113 sky130_fd_sc_hd__xnor2_4
X_11058_ _04719_ _04796_ VGND VGND VPWR VPWR _04865_ sky130_fd_sc_hd__nand2_1
XFILLER_0_3_39 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XTAP_TAPCELL_ROW_108_1616 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
X_10009_ _00041_ _03006_ _03720_ _03721_ VGND VGND VPWR VPWR _03723_ sky130_fd_sc_hd__and4_1
XFILLER_0_58_122 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_86_475 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_59_667 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_0_46_306 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XFILLER_0_117_717 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_0_74_626 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_13_51 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_0_73_169 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
X_07220_ _03649_ _05695_ net40 _02699_ VGND VGND VPWR VPWR _00678_ sky130_fd_sc_hd__a22o_1
XFILLER_0_54_361 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
X_07151_ _00514_ _00517_ VGND VGND VPWR VPWR _00603_ sky130_fd_sc_hd__or2_1
XFILLER_0_15_715 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XTAP_TAPCELL_ROW_30_632 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_30_643 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_42_501 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_120_41 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XTAP_TAPCELL_ROW_119_1745 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
X_06102_ _03725_ _03965_ _03976_ VGND VGND VPWR VPWR _04683_ sky130_fd_sc_hd__nor3_1
X_07082_ _04737_ _05557_ _00524_ _00525_ VGND VGND VPWR VPWR _00528_ sky130_fd_sc_hd__a22o_1
XFILLER_0_120_85 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_112_477 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_112_444 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
X_06033_ _03812_ _03911_ _03922_ VGND VGND VPWR VPWR _03932_ sky130_fd_sc_hd__nand3_1
XFILLER_0_10_453 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
X_07984_ _00854_ _00581_ net17 net18 VGND VGND VPWR VPWR _01512_ sky130_fd_sc_hd__and4_1
XFILLER_0_38_81 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
X_09723_ _03286_ _03409_ _03410_ VGND VGND VPWR VPWR _03411_ sky130_fd_sc_hd__nand3_1
X_06935_ _00264_ _00266_ _00365_ _00366_ VGND VGND VPWR VPWR _00367_ sky130_fd_sc_hd__a211o_1
X_09654_ _03329_ _03330_ _03334_ _03335_ VGND VGND VPWR VPWR _03336_ sky130_fd_sc_hd__o211a_1
X_06866_ _00284_ _00291_ VGND VGND VPWR VPWR _00292_ sky130_fd_sc_hd__xor2_2
X_05817_ _00865_ _00876_ _00821_ VGND VGND VPWR VPWR _01574_ sky130_fd_sc_hd__a21bo_1
XTAP_TAPCELL_ROW_38_732 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_38_743 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
X_08605_ _02188_ _02189_ _02190_ VGND VGND VPWR VPWR _02191_ sky130_fd_sc_hd__nand3_1
X_09585_ _00087_ _00894_ _02944_ _01414_ VGND VGND VPWR VPWR _03260_ sky130_fd_sc_hd__a22o_1
X_06797_ _00221_ _00222_ _00117_ _00130_ VGND VGND VPWR VPWR _00224_ sky130_fd_sc_hd__a211o_1
X_08536_ _02106_ _02112_ _02114_ VGND VGND VPWR VPWR _02115_ sky130_fd_sc_hd__nand3_1
X_05748_ _00799_ _00810_ _00548_ _00559_ VGND VGND VPWR VPWR _00821_ sky130_fd_sc_hd__nand4_2
X_08467_ _00461_ _01671_ VGND VGND VPWR VPWR _02039_ sky130_fd_sc_hd__nand2_1
XFILLER_0_65_637 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_0_37_317 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
X_07418_ _00893_ VGND VGND VPWR VPWR _00894_ sky130_fd_sc_hd__clkbuf_4
XFILLER_0_65_659 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
X_08398_ _01962_ _01963_ VGND VGND VPWR VPWR _01964_ sky130_fd_sc_hd__nand2_2
XFILLER_0_18_553 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_107_249 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_18_586 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
X_07349_ _01651_ _00094_ _00691_ _00689_ _00688_ VGND VGND VPWR VPWR _00819_ sky130_fd_sc_hd__a32o_1
XFILLER_0_33_556 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_0_103_433 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XTAP_TAPCELL_ROW_94_1439 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
X_10360_ _02320_ _00894_ _02061_ _01603_ VGND VGND VPWR VPWR _04106_ sky130_fd_sc_hd__a22o_1
XFILLER_0_33_567 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
X_10291_ _04028_ _04029_ _03924_ _03925_ VGND VGND VPWR VPWR _04032_ sky130_fd_sc_hd__o211a_1
X_09019_ _02640_ _02641_ _02104_ _01603_ VGND VGND VPWR VPWR _02642_ sky130_fd_sc_hd__nand4_2
XFILLER_0_20_217 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_103_499 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_0_13_291 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_18_29 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XTAP_TAPCELL_ROW_103_1546 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_95_272 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XTAP_TAPCELL_ROW_16_459 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
X_10627_ _04395_ _04396_ VGND VGND VPWR VPWR _04397_ sky130_fd_sc_hd__nor2_1
XFILLER_0_70_139 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_63_180 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
X_10558_ _04319_ _04320_ _04312_ VGND VGND VPWR VPWR _04322_ sky130_fd_sc_hd__a21o_1
XFILLER_0_24_567 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_0_24_578 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_10489_ _04149_ _04143_ VGND VGND VPWR VPWR _04247_ sky130_fd_sc_hd__or2b_1
XFILLER_0_121_296 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XTAP_TAPCELL_ROW_114_1686 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_75_79 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_75_57 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XTAP_TAPCELL_ROW_69_1121 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
X_06720_ _00136_ _00146_ VGND VGND VPWR VPWR _00147_ sky130_fd_sc_hd__xnor2_2
X_06651_ _04781_ _04998_ _05008_ _04770_ VGND VGND VPWR VPWR _00079_ sky130_fd_sc_hd__a22o_1
XTAP_TAPCELL_ROW_35_702 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_86_250 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
X_09370_ _03022_ _03023_ _02854_ _02856_ VGND VGND VPWR VPWR _03025_ sky130_fd_sc_hd__o211a_1
XFILLER_0_19_306 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
X_06582_ _00008_ _00009_ _05604_ _05673_ VGND VGND VPWR VPWR _00011_ sky130_fd_sc_hd__a211o_1
XFILLER_0_47_615 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_74_401 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
X_08321_ _01877_ _01878_ _01871_ VGND VGND VPWR VPWR _01881_ sky130_fd_sc_hd__a21o_1
XFILLER_0_24_83 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_46_114 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_0_117_514 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_08252_ _00646_ net53 _01805_ _02447_ VGND VGND VPWR VPWR _01806_ sky130_fd_sc_hd__a22o_1
XFILLER_0_105_709 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_34_309 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
X_07203_ _00658_ _00659_ VGND VGND VPWR VPWR _00660_ sky130_fd_sc_hd__xnor2_2
XFILLER_0_46_169 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
X_08183_ _01725_ _01726_ _01728_ VGND VGND VPWR VPWR _01730_ sky130_fd_sc_hd__a21o_1
X_07134_ _00542_ _00543_ _00582_ _00583_ VGND VGND VPWR VPWR _00585_ sky130_fd_sc_hd__o22ai_1
XFILLER_0_30_504 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_0_70_684 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
X_07065_ _00500_ _00508_ VGND VGND VPWR VPWR _00509_ sky130_fd_sc_hd__xnor2_1
X_06016_ _01007_ _00330_ _03223_ VGND VGND VPWR VPWR _03747_ sky130_fd_sc_hd__and3_1
XFILLER_0_10_261 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_10_294 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
X_07967_ _01333_ _01359_ VGND VGND VPWR VPWR _01493_ sky130_fd_sc_hd__and2b_1
X_09706_ _03303_ _03305_ VGND VGND VPWR VPWR _03392_ sky130_fd_sc_hd__nand2_1
X_06918_ _00150_ VGND VGND VPWR VPWR _00348_ sky130_fd_sc_hd__clkbuf_4
XFILLER_0_97_526 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
X_07898_ _01417_ _01418_ _05310_ _00294_ VGND VGND VPWR VPWR _01419_ sky130_fd_sc_hd__and4bb_1
X_09637_ _03314_ _03315_ _03312_ _03313_ VGND VGND VPWR VPWR _03317_ sky130_fd_sc_hd__a211o_2
XPHY_EDGE_ROW_27_Left_149 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
X_06849_ _04737_ _05311_ _00168_ _00167_ VGND VGND VPWR VPWR _00275_ sky130_fd_sc_hd__a31o_1
X_09568_ _05497_ _01680_ _03239_ _03240_ VGND VGND VPWR VPWR _03241_ sky130_fd_sc_hd__o2bb2a_1
X_08519_ _00408_ _00355_ _02093_ _02094_ VGND VGND VPWR VPWR _02096_ sky130_fd_sc_hd__a22o_1
X_09499_ _03163_ _03164_ _03129_ _02998_ VGND VGND VPWR VPWR _03166_ sky130_fd_sc_hd__a211o_1
XFILLER_0_65_456 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XTAP_TAPCELL_ROW_13_429 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_92_253 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
X_11461_ _01345_ _01433_ VGND VGND VPWR VPWR _05292_ sky130_fd_sc_hd__or2_1
XFILLER_0_52_128 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
X_11392_ _05103_ _05107_ _05189_ _05224_ VGND VGND VPWR VPWR _05225_ sky130_fd_sc_hd__a211o_1
XFILLER_0_116_580 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_10412_ _05541_ _05637_ _04157_ _03178_ _04050_ VGND VGND VPWR VPWR _04163_ sky130_fd_sc_hd__a41o_1
XFILLER_0_61_673 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_0_33_364 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XPHY_EDGE_ROW_36_Left_158 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
X_10343_ _01588_ _03237_ _01853_ _00556_ VGND VGND VPWR VPWR _04088_ sky130_fd_sc_hd__a22oi_1
XFILLER_0_21_559 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
X_10274_ _03996_ _03891_ _04011_ _04012_ VGND VGND VPWR VPWR _04013_ sky130_fd_sc_hd__a211oi_2
Xmax_cap5 _00259_ VGND VGND VPWR VPWR net172 sky130_fd_sc_hd__clkbuf_1
XPHY_EDGE_ROW_45_Left_167 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_0_56_401 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_28_103 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_29_615 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XTAP_TAPCELL_ROW_64_1062 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_28_136 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_0_29_659 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_16_309 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_0_37_670 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XFILLER_0_44_629 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_114_506 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XPHY_EDGE_ROW_104_Right_104 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XPHY_EDGE_ROW_54_Left_176 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_0_9_27 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_24_320 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XTAP_TAPCELL_ROW_40_760 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_43_128 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XTAP_TAPCELL_ROW_116_1715 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_101_43 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XFILLER_0_3_225 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_0_52_684 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_0_51_183 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_10_41 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_110_701 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_10_85 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
X_08870_ _02297_ _02305_ _02304_ VGND VGND VPWR VPWR _02479_ sky130_fd_sc_hd__a21bo_1
X_07821_ _01044_ _01191_ net167 VGND VGND VPWR VPWR _01335_ sky130_fd_sc_hd__a21oi_4
XFILLER_0_19_83 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XPHY_EDGE_ROW_63_Left_185 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
X_07752_ _01257_ _01259_ VGND VGND VPWR VPWR _01260_ sky130_fd_sc_hd__xnor2_1
XFILLER_0_79_548 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
X_07683_ _00679_ _00351_ net17 net18 VGND VGND VPWR VPWR _01184_ sky130_fd_sc_hd__and4_1
X_06703_ _00117_ _00118_ _05646_ VGND VGND VPWR VPWR _00130_ sky130_fd_sc_hd__nor3b_1
XTAP_TAPCELL_ROW_48_860 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_94_518 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_94_507 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
X_09422_ _02919_ _02962_ _03081_ VGND VGND VPWR VPWR _03082_ sky130_fd_sc_hd__a21o_1
X_06634_ _04889_ _04585_ _00060_ _00061_ VGND VGND VPWR VPWR _00062_ sky130_fd_sc_hd__nand4_1
X_09353_ _05463_ _05552_ _01278_ VGND VGND VPWR VPWR _03007_ sky130_fd_sc_hd__and3_1
X_08304_ _01171_ _01849_ _01861_ VGND VGND VPWR VPWR _01862_ sky130_fd_sc_hd__a21o_1
X_06565_ _03310_ _03321_ _05593_ _05693_ VGND VGND VPWR VPWR _05694_ sky130_fd_sc_hd__nand4_1
XFILLER_0_117_333 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_0_90_713 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
X_09284_ _02920_ _02921_ _02931_ VGND VGND VPWR VPWR _02932_ sky130_fd_sc_hd__and3_1
XPHY_EDGE_ROW_72_Left_194 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_0_62_415 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XFILLER_0_19_169 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
X_06496_ _05533_ _05536_ _05532_ VGND VGND VPWR VPWR _05626_ sky130_fd_sc_hd__a21oi_1
XFILLER_0_34_139 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
X_08235_ _03649_ net47 _00837_ _02721_ VGND VGND VPWR VPWR _01787_ sky130_fd_sc_hd__a22o_1
X_08166_ _01708_ _01709_ _01570_ _01572_ VGND VGND VPWR VPWR _01711_ sky130_fd_sc_hd__a211oi_1
XFILLER_0_15_397 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
X_07117_ _00799_ _00548_ _00430_ _00565_ VGND VGND VPWR VPWR _00566_ sky130_fd_sc_hd__nand4_1
XFILLER_0_42_161 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_43_673 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_113_561 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
X_08097_ _01633_ _01634_ _01625_ VGND VGND VPWR VPWR _01636_ sky130_fd_sc_hd__a21o_1
XFILLER_0_30_356 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_07048_ _00487_ _00489_ VGND VGND VPWR VPWR _00490_ sky130_fd_sc_hd__or2_1
XFILLER_0_30_389 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
X_08999_ _00802_ _05686_ _01060_ VGND VGND VPWR VPWR _02620_ sky130_fd_sc_hd__and3_1
X_10961_ _02943_ _02061_ _02345_ _01980_ VGND VGND VPWR VPWR _04760_ sky130_fd_sc_hd__nand4_1
X_10892_ _04679_ _04682_ _04684_ VGND VGND VPWR VPWR _04685_ sky130_fd_sc_hd__nand3_2
XFILLER_0_97_389 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_0_78_581 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XTAP_TAPCELL_ROW_100_1516 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_26_587 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_65_275 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_19_670 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XFILLER_0_108_344 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_53_426 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_25_139 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
X_11444_ _05272_ _05253_ _05269_ _05270_ VGND VGND VPWR VPWR _05280_ sky130_fd_sc_hd__o31a_2
XFILLER_0_40_109 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
X_11375_ _05205_ _05206_ VGND VGND VPWR VPWR _05207_ sky130_fd_sc_hd__nand2_1
XFILLER_0_0_217 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_0_33_194 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
X_10326_ _00488_ _03006_ _04067_ _04068_ VGND VGND VPWR VPWR _04069_ sky130_fd_sc_hd__a22o_1
XTAP_TAPCELL_ROW_111_1645 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
X_10257_ _01249_ _02052_ VGND VGND VPWR VPWR _03994_ sky130_fd_sc_hd__nand2_1
X_10188_ _03917_ _03918_ VGND VGND VPWR VPWR _03919_ sky130_fd_sc_hd__or2b_2
XFILLER_0_56_48 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XTAP_TAPCELL_ROW_45_830 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_29_401 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_8_317 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_8_306 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XFILLER_0_72_713 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
X_06350_ _05460_ _05461_ _05479_ VGND VGND VPWR VPWR _05481_ sky130_fd_sc_hd__nor3_1
XFILLER_0_112_53 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
X_06281_ _05406_ _05412_ VGND VGND VPWR VPWR _05413_ sky130_fd_sc_hd__xnor2_2
XFILLER_0_71_267 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
X_08020_ _01542_ _01549_ VGND VGND VPWR VPWR _01551_ sky130_fd_sc_hd__nor2_1
XFILLER_0_21_51 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_0_112_97 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XTAP_TAPCELL_ROW_77_1220 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_4_545 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_25_673 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_4_589 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_24_194 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XFILLER_0_40_643 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_110_531 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
X_09971_ _04596_ _02864_ _02866_ _04085_ VGND VGND VPWR VPWR _03682_ sky130_fd_sc_hd__a22oi_1
XFILLER_0_40_676 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_08922_ _02531_ _02532_ _02534_ VGND VGND VPWR VPWR _02537_ sky130_fd_sc_hd__a21oi_1
XFILLER_0_110_586 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
X_08853_ _02456_ _02457_ _02460_ VGND VGND VPWR VPWR _02461_ sky130_fd_sc_hd__nand3_1
XFILLER_0_34_3 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
X_07804_ _01314_ _01315_ _01179_ VGND VGND VPWR VPWR _01317_ sky130_fd_sc_hd__o21ai_1
X_08784_ _02030_ _02215_ _02214_ VGND VGND VPWR VPWR _02387_ sky130_fd_sc_hd__a21boi_4
X_05996_ _03059_ _02819_ net165 _03518_ VGND VGND VPWR VPWR _03529_ sky130_fd_sc_hd__a211oi_4
XTAP_TAPCELL_ROW_88_1360 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
X_07735_ _01238_ _01239_ _01205_ _01089_ VGND VGND VPWR VPWR _01241_ sky130_fd_sc_hd__o211a_1
XFILLER_0_46_81 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_0_79_389 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
X_09405_ _03061_ _03063_ VGND VGND VPWR VPWR _03064_ sky130_fd_sc_hd__xor2_2
XFILLER_0_67_529 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
X_07666_ _01163_ _01164_ _01057_ VGND VGND VPWR VPWR _01166_ sky130_fd_sc_hd__o21a_1
XPHY_EDGE_ROW_80_Left_202 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_0_62_91 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_06617_ _00040_ _00043_ _05653_ _00044_ VGND VGND VPWR VPWR _00045_ sky130_fd_sc_hd__o211ai_2
X_07597_ _01087_ _01088_ _01074_ VGND VGND VPWR VPWR _01090_ sky130_fd_sc_hd__o21ai_1
X_09336_ _00034_ _01604_ _02986_ _02987_ VGND VGND VPWR VPWR _02988_ sky130_fd_sc_hd__a22o_1
XTAP_TAPCELL_ROW_23_546 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
X_06548_ _02197_ net34 _05416_ _02732_ VGND VGND VPWR VPWR _05677_ sky130_fd_sc_hd__a22o_1
XFILLER_0_47_264 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
X_09267_ _02790_ _02751_ VGND VGND VPWR VPWR _02913_ sky130_fd_sc_hd__and2b_1
XFILLER_0_75_584 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XTAP_TAPCELL_ROW_51_899 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
X_06479_ _05606_ _05607_ _05512_ _05573_ VGND VGND VPWR VPWR _05609_ sky130_fd_sc_hd__a211o_1
X_08218_ _04074_ _00688_ _00830_ _03015_ VGND VGND VPWR VPWR _01768_ sky130_fd_sc_hd__a22o_1
X_09198_ _02837_ VGND VGND VPWR VPWR _02838_ sky130_fd_sc_hd__buf_4
XFILLER_0_90_587 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_22_109 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
X_08149_ _00810_ net17 net18 _00559_ VGND VGND VPWR VPWR _01692_ sky130_fd_sc_hd__a22o_1
XFILLER_0_30_120 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
X_11160_ _04972_ _04974_ VGND VGND VPWR VPWR _04975_ sky130_fd_sc_hd__xnor2_1
X_10111_ _03833_ _03723_ VGND VGND VPWR VPWR _03835_ sky130_fd_sc_hd__or2_1
X_11091_ _01977_ _02345_ _03237_ _01853_ VGND VGND VPWR VPWR _04901_ sky130_fd_sc_hd__and4_1
XFILLER_0_31_698 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
X_10042_ _03623_ _03633_ _03634_ VGND VGND VPWR VPWR _03760_ sky130_fd_sc_hd__nand3_1
XFILLER_0_26_29 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XTAP_TAPCELL_ROW_59_999 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XPHY_EDGE_ROW_119_Left_241 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_0_97_153 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
X_10944_ _01800_ _01674_ _01853_ _01620_ VGND VGND VPWR VPWR _04741_ sky130_fd_sc_hd__a22o_1
X_10875_ _03574_ _02041_ _04582_ _04581_ _01355_ VGND VGND VPWR VPWR _04666_ sky130_fd_sc_hd__a32o_1
XFILLER_0_85_359 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_0_85_337 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XTAP_TAPCELL_ROW_61_1021 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_109_653 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_81_521 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_109_697 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_81_598 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_0_22_610 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
X_11427_ _04040_ _04724_ _05260_ VGND VGND VPWR VPWR _05262_ sky130_fd_sc_hd__and3_1
XANTENNA_5 _00646_ VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
X_11358_ _05101_ _05150_ VGND VGND VPWR VPWR _05189_ sky130_fd_sc_hd__nand2_1
XFILLER_0_21_164 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
X_10309_ _00041_ _03297_ _04047_ _04048_ VGND VGND VPWR VPWR _04050_ sky130_fd_sc_hd__and4_1
X_11289_ _05005_ _05082_ _04505_ _04042_ VGND VGND VPWR VPWR _05114_ sky130_fd_sc_hd__o211a_1
XTAP_TAPCELL_ROW_72_1161 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
X_05850_ _01913_ _01924_ VGND VGND VPWR VPWR _01935_ sky130_fd_sc_hd__and2_1
XFILLER_0_107_53 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
X_05781_ _01171_ VGND VGND VPWR VPWR _01181_ sky130_fd_sc_hd__clkbuf_4
X_07520_ _01003_ _01004_ _00981_ VGND VGND VPWR VPWR _01006_ sky130_fd_sc_hd__o21a_1
XFILLER_0_88_175 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_0_16_73 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_0_88_197 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_0_9_604 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_29_231 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
X_07451_ _05676_ _04976_ _00138_ _05636_ VGND VGND VPWR VPWR _00931_ sky130_fd_sc_hd__nand4_2
XFILLER_0_57_573 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_07382_ _00815_ _00816_ _00853_ _00855_ VGND VGND VPWR VPWR _00856_ sky130_fd_sc_hd__or4bb_4
XFILLER_0_29_242 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
X_06402_ _05455_ _05531_ VGND VGND VPWR VPWR _05533_ sky130_fd_sc_hd__nand2_1
XFILLER_0_45_713 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
X_09121_ _03616_ _02236_ _02586_ VGND VGND VPWR VPWR _02754_ sky130_fd_sc_hd__nand3_1
XFILLER_0_72_521 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_06333_ _05463_ VGND VGND VPWR VPWR _05464_ sky130_fd_sc_hd__buf_4
XFILLER_0_29_286 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_72_543 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XTAP_TAPCELL_ROW_20_516 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
X_09052_ _02675_ _02676_ _02678_ VGND VGND VPWR VPWR _02679_ sky130_fd_sc_hd__nand3_1
XFILLER_0_32_407 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
X_06264_ _00450_ _05310_ VGND VGND VPWR VPWR _05396_ sky130_fd_sc_hd__and2_1
XFILLER_0_114_155 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
X_08003_ _01403_ _01404_ _01469_ _01470_ VGND VGND VPWR VPWR _01533_ sky130_fd_sc_hd__or4bb_2
XFILLER_0_13_654 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
X_06195_ _05327_ _04770_ _02251_ _04705_ VGND VGND VPWR VPWR _05328_ sky130_fd_sc_hd__a22oi_1
XFILLER_0_40_440 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_12_197 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_09954_ _03068_ _03226_ _03381_ _03527_ VGND VGND VPWR VPWR _03664_ sky130_fd_sc_hd__or4_2
XFILLER_0_0_581 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
X_09885_ _03585_ _03586_ _03581_ VGND VGND VPWR VPWR _03588_ sky130_fd_sc_hd__a21o_1
X_08905_ _04802_ _03124_ _01284_ _01449_ VGND VGND VPWR VPWR _02518_ sky130_fd_sc_hd__nand4_2
X_08836_ _02439_ _02440_ _02261_ _02264_ VGND VGND VPWR VPWR _02442_ sky130_fd_sc_hd__o211ai_1
XTAP_TAPCELL_ROW_28_616 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
X_08767_ _02362_ _02367_ VGND VGND VPWR VPWR _02368_ sky130_fd_sc_hd__xnor2_4
X_05979_ net64 VGND VGND VPWR VPWR _03343_ sky130_fd_sc_hd__clkbuf_4
XFILLER_0_95_602 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_79_175 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_08698_ _02285_ _02286_ _02290_ _02291_ VGND VGND VPWR VPWR _02292_ sky130_fd_sc_hd__o211a_1
XTAP_TAPCELL_ROW_56_958 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
X_07718_ _00408_ _05557_ _01137_ _01136_ _01221_ VGND VGND VPWR VPWR _01222_ sky130_fd_sc_hd__a32oi_4
XTAP_TAPCELL_ROW_0_252 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_0_263 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_94_123 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_0_67_337 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
X_07649_ _01143_ _01144_ _01145_ VGND VGND VPWR VPWR _01147_ sky130_fd_sc_hd__a21o_1
X_10660_ _04429_ _04430_ _04413_ VGND VGND VPWR VPWR _04432_ sky130_fd_sc_hd__o21a_1
XFILLER_0_36_713 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_0_48_573 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_0_118_450 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_09319_ _02968_ _02969_ VGND VGND VPWR VPWR _02970_ sky130_fd_sc_hd__xor2_2
XFILLER_0_35_223 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_48_595 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
X_10591_ _02302_ _02228_ _04308_ VGND VGND VPWR VPWR _04358_ sky130_fd_sc_hd__and3_1
XFILLER_0_8_681 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_90_362 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XFILLER_0_63_576 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_0_121_604 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_105_166 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XFILLER_0_121_637 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
X_11212_ _05029_ _05031_ VGND VGND VPWR VPWR _05032_ sky130_fd_sc_hd__nand2_1
X_11143_ _04944_ _04890_ _04956_ VGND VGND VPWR VPWR _04957_ sky130_fd_sc_hd__a21oi_2
XTAP_TAPCELL_ROW_8_363 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
Xoutput75 net75 VGND VGND VPWR VPWR product[19] sky130_fd_sc_hd__clkbuf_4
Xoutput97 net97 VGND VGND VPWR VPWR product[39] sky130_fd_sc_hd__buf_2
X_11074_ _04880_ _04881_ VGND VGND VPWR VPWR _04882_ sky130_fd_sc_hd__nor2_1
Xoutput86 net86 VGND VGND VPWR VPWR product[29] sky130_fd_sc_hd__clkbuf_4
X_10025_ _03680_ _03601_ _03739_ _03740_ VGND VGND VPWR VPWR _03741_ sky130_fd_sc_hd__o211a_2
XFILLER_0_53_38 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
X_10927_ _04719_ _04722_ VGND VGND VPWR VPWR net110 sky130_fd_sc_hd__xor2_1
XTAP_TAPCELL_ROW_106_1588 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_86_657 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
X_10858_ _04564_ _04644_ _04642_ _04643_ VGND VGND VPWR VPWR _04647_ sky130_fd_sc_hd__o211a_1
XFILLER_0_27_713 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_0_39_573 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_10789_ _04561_ _04571_ VGND VGND VPWR VPWR _04572_ sky130_fd_sc_hd__xnor2_1
XFILLER_0_54_554 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_26_267 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_0_26_278 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_41_248 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_120_681 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_10_657 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_94_45 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
X_06951_ _00284_ _00291_ VGND VGND VPWR VPWR _00385_ sky130_fd_sc_hd__nand2_1
XFILLER_0_118_41 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_94_67 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
X_09670_ _03350_ _03351_ _03352_ VGND VGND VPWR VPWR _03353_ sky130_fd_sc_hd__nand3_1
X_05902_ _02469_ _02480_ _02436_ VGND VGND VPWR VPWR _02502_ sky130_fd_sc_hd__a21o_1
XFILLER_0_118_85 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
X_06882_ _00299_ _00307_ _00309_ VGND VGND VPWR VPWR _00310_ sky130_fd_sc_hd__nand3_2
X_08621_ _02205_ _02206_ _02129_ VGND VGND VPWR VPWR _02209_ sky130_fd_sc_hd__a21o_1
XFILLER_0_89_440 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
X_05833_ _01050_ _00395_ _01029_ VGND VGND VPWR VPWR _01749_ sky130_fd_sc_hd__and3_1
XFILLER_0_27_94 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XTAP_TAPCELL_ROW_85_1330 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
X_05764_ _00450_ _00974_ _00985_ _00351_ VGND VGND VPWR VPWR _00996_ sky130_fd_sc_hd__a22oi_1
X_08552_ _01966_ _01973_ _01972_ VGND VGND VPWR VPWR _02133_ sky130_fd_sc_hd__a21o_1
X_08483_ _01874_ _01876_ VGND VGND VPWR VPWR _02057_ sky130_fd_sc_hd__nand2_1
XTAP_TAPCELL_ROW_53_928 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_49_337 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
X_07503_ _01662_ _00987_ VGND VGND VPWR VPWR _00988_ sky130_fd_sc_hd__nand2_1
XFILLER_0_119_214 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_76_156 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
X_07434_ _00493_ _00679_ net14 _00611_ VGND VGND VPWR VPWR _00912_ sky130_fd_sc_hd__and4_2
XFILLER_0_107_409 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_57_381 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_9_445 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_0_18_713 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_0_9_489 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XTAP_TAPCELL_ROW_33_674 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
X_07365_ net48 VGND VGND VPWR VPWR _00837_ sky130_fd_sc_hd__clkbuf_4
X_09104_ _02403_ _02563_ _02735_ VGND VGND VPWR VPWR _02736_ sky130_fd_sc_hd__a21oi_2
X_06316_ _05378_ _05379_ _05447_ VGND VGND VPWR VPWR _05448_ sky130_fd_sc_hd__o21ai_2
X_07296_ _00759_ _00760_ _00504_ _00354_ VGND VGND VPWR VPWR _00761_ sky130_fd_sc_hd__and4b_1
XFILLER_0_103_615 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
X_09035_ _02618_ _02658_ _02659_ VGND VGND VPWR VPWR _02660_ sky130_fd_sc_hd__and3_1
XFILLER_0_5_673 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
X_06247_ _04650_ _05366_ VGND VGND VPWR VPWR _05379_ sky130_fd_sc_hd__and2_1
X_06178_ _05310_ VGND VGND VPWR VPWR _05311_ sky130_fd_sc_hd__clkbuf_8
XFILLER_0_7_93 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_40_292 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
X_09937_ _03642_ _03643_ _03457_ _03459_ VGND VGND VPWR VPWR _03645_ sky130_fd_sc_hd__o211ai_1
XTAP_TAPCELL_ROW_5_322 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
X_09868_ _03433_ _02626_ _03429_ _03431_ VGND VGND VPWR VPWR _03569_ sky130_fd_sc_hd__and4_1
X_09799_ _01221_ _03489_ _03492_ _03493_ VGND VGND VPWR VPWR _03494_ sky130_fd_sc_hd__a22o_1
X_08819_ _02421_ _02422_ VGND VGND VPWR VPWR _02423_ sky130_fd_sc_hd__nor2_1
X_10712_ _04399_ _04402_ VGND VGND VPWR VPWR _04489_ sky130_fd_sc_hd__or2_1
XFILLER_0_67_167 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_67_145 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
X_10643_ _04274_ _04284_ _04283_ VGND VGND VPWR VPWR _04415_ sky130_fd_sc_hd__a21o_1
X_10574_ _04337_ _04338_ _04253_ _04232_ VGND VGND VPWR VPWR _04340_ sky130_fd_sc_hd__o211ai_4
XFILLER_0_91_671 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_36_587 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_2_109 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_121_434 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
X_11126_ _04864_ _04871_ _04862_ VGND VGND VPWR VPWR _04939_ sky130_fd_sc_hd__o21bai_4
XFILLER_0_101_191 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
X_11057_ _04862_ _04863_ VGND VGND VPWR VPWR _04864_ sky130_fd_sc_hd__or2_2
XFILLER_0_64_26 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XFILLER_0_64_15 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XTAP_TAPCELL_ROW_108_1617 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_108_1606 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
X_10008_ _02646_ _02850_ _03720_ _03721_ VGND VGND VPWR VPWR _03722_ sky130_fd_sc_hd__a22oi_2
XFILLER_0_58_112 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_0_104_21 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_0_80_36 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_74_638 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_0_58_189 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XTAP_TAPCELL_ROW_80_1260 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_27_532 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_07150_ _00600_ _00601_ VGND VGND VPWR VPWR net78 sky130_fd_sc_hd__nor2_2
XTAP_TAPCELL_ROW_30_633 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_119_1746 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_112_401 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_89_67 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
X_07081_ _05659_ net6 _00524_ _00525_ VGND VGND VPWR VPWR _00527_ sky130_fd_sc_hd__nand4_2
X_06101_ _04650_ _04661_ VGND VGND VPWR VPWR _04672_ sky130_fd_sc_hd__nor2_1
XFILLER_0_42_546 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_120_53 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_30_719 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_120_97 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XTAP_TAPCELL_ROW_10_390 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_2_643 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
X_06032_ _03878_ _03889_ _03900_ VGND VGND VPWR VPWR _03922_ sky130_fd_sc_hd__a21o_1
XFILLER_0_112_489 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_0_22_292 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_10_465 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_09722_ _03406_ _03407_ _03399_ VGND VGND VPWR VPWR _03410_ sky130_fd_sc_hd__a21o_1
X_07983_ _00559_ net17 _01185_ _00493_ VGND VGND VPWR VPWR _01511_ sky130_fd_sc_hd__a22oi_1
X_06934_ _00908_ _00033_ _00363_ _00364_ VGND VGND VPWR VPWR _00366_ sky130_fd_sc_hd__o2bb2a_1
X_09653_ _02105_ _02626_ _03331_ _03333_ VGND VGND VPWR VPWR _03335_ sky130_fd_sc_hd__nand4_1
X_06865_ _00285_ _00290_ VGND VGND VPWR VPWR _00291_ sky130_fd_sc_hd__xnor2_2
X_09584_ _02113_ _00753_ _03131_ _03130_ _00496_ VGND VGND VPWR VPWR _03259_ sky130_fd_sc_hd__a32o_1
XTAP_TAPCELL_ROW_38_733 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
X_08604_ _01985_ _01986_ _01988_ VGND VGND VPWR VPWR _02190_ sky130_fd_sc_hd__a21bo_1
X_05816_ _01552_ _00439_ _01519_ _01530_ VGND VGND VPWR VPWR _01563_ sky130_fd_sc_hd__a22o_1
XPHY_EDGE_ROW_118_Right_118 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
X_08535_ _02113_ _00034_ _02107_ _02111_ VGND VGND VPWR VPWR _02114_ sky130_fd_sc_hd__nand4_2
XFILLER_0_54_81 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
X_06796_ _00117_ _00130_ _00221_ _00222_ VGND VGND VPWR VPWR _00223_ sky130_fd_sc_hd__o211a_1
X_05747_ net60 VGND VGND VPWR VPWR _00810_ sky130_fd_sc_hd__clkbuf_4
XFILLER_0_92_402 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
X_08466_ _01353_ _02035_ _02037_ VGND VGND VPWR VPWR _02038_ sky130_fd_sc_hd__a21bo_1
XTAP_TAPCELL_ROW_18_490 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_37_329 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
X_07417_ net17 VGND VGND VPWR VPWR _00893_ sky130_fd_sc_hd__clkbuf_4
X_08397_ _01960_ _01961_ _01940_ VGND VGND VPWR VPWR _01963_ sky130_fd_sc_hd__a21o_1
X_07348_ _00677_ _00680_ VGND VGND VPWR VPWR _00818_ sky130_fd_sc_hd__nand2_1
XFILLER_0_45_340 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
X_07279_ _00645_ _00648_ _00740_ VGND VGND VPWR VPWR _00742_ sky130_fd_sc_hd__or3_1
XFILLER_0_33_579 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
X_10290_ _03924_ _03925_ _04028_ _04029_ VGND VGND VPWR VPWR _04030_ sky130_fd_sc_hd__a211oi_2
XFILLER_0_103_456 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
X_09018_ _00139_ VGND VGND VPWR VPWR _02641_ sky130_fd_sc_hd__buf_4
XFILLER_0_88_719 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_34_29 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XTAP_TAPCELL_ROW_103_1547 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_28_307 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_28_329 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_0_95_295 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_83_446 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
X_10626_ _04267_ _04364_ _04394_ VGND VGND VPWR VPWR _04396_ sky130_fd_sc_hd__nor3_1
XFILLER_0_64_671 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_24_524 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XFILLER_0_36_384 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
X_10557_ _04312_ _04319_ _04320_ VGND VGND VPWR VPWR _04321_ sky130_fd_sc_hd__nand3_4
XFILLER_0_12_719 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
X_10488_ _04141_ _04142_ VGND VGND VPWR VPWR _04246_ sky130_fd_sc_hd__or2b_1
XTAP_TAPCELL_ROW_114_1687 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
X_11109_ _04827_ _04844_ _04919_ VGND VGND VPWR VPWR _04920_ sky130_fd_sc_hd__o21ba_1
XFILLER_0_75_69 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XTAP_TAPCELL_ROW_69_1122 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
X_06650_ _04770_ _04781_ _03834_ _05030_ VGND VGND VPWR VPWR _00078_ sky130_fd_sc_hd__and4_1
XFILLER_0_91_57 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XTAP_TAPCELL_ROW_35_703 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_86_240 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
X_06581_ _05604_ _05673_ _00008_ _00009_ VGND VGND VPWR VPWR _00010_ sky130_fd_sc_hd__o211ai_4
X_08320_ _01871_ _01877_ _01878_ VGND VGND VPWR VPWR _01879_ sky130_fd_sc_hd__nand3_2
XFILLER_0_24_73 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
X_08251_ net54 VGND VGND VPWR VPWR _01805_ sky130_fd_sc_hd__clkbuf_4
XFILLER_0_46_148 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
X_07202_ _05574_ _05467_ VGND VGND VPWR VPWR _00659_ sky130_fd_sc_hd__nand2_1
X_08182_ _01725_ _01726_ _01728_ VGND VGND VPWR VPWR _01729_ sky130_fd_sc_hd__and3_1
XFILLER_0_15_513 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_0_40_72 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_70_641 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_0_54_192 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
X_07133_ _00542_ _00543_ _00582_ _00583_ VGND VGND VPWR VPWR _00584_ sky130_fd_sc_hd__or4_1
XFILLER_0_42_365 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_0_70_696 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XPHY_EDGE_ROW_12_Right_12 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
X_07064_ _00506_ _00507_ VGND VGND VPWR VPWR _00508_ sky130_fd_sc_hd__and2_1
XFILLER_0_64_3 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_2_451 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
X_06015_ _03288_ VGND VGND VPWR VPWR _03736_ sky130_fd_sc_hd__buf_4
XFILLER_0_100_437 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_0_49_70 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XFILLER_0_2_495 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
X_07966_ _01330_ _01478_ _01479_ VGND VGND VPWR VPWR _01492_ sky130_fd_sc_hd__nor3_1
X_09705_ _03583_ _03027_ VGND VGND VPWR VPWR _03391_ sky130_fd_sc_hd__nand2_1
X_06917_ _00461_ _01236_ _00344_ _00346_ VGND VGND VPWR VPWR _00347_ sky130_fd_sc_hd__nand4_2
XFILLER_0_4_83 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
X_09636_ _03312_ _03313_ _03314_ _03315_ VGND VGND VPWR VPWR _03316_ sky130_fd_sc_hd__o211ai_2
X_07897_ _03004_ _04063_ _00423_ _00197_ VGND VGND VPWR VPWR _01418_ sky130_fd_sc_hd__and4_1
XFILLER_0_97_538 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XPHY_EDGE_ROW_21_Right_21 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
X_06848_ _00270_ _00273_ VGND VGND VPWR VPWR _00274_ sky130_fd_sc_hd__xnor2_1
X_09567_ _04998_ _05008_ _02036_ _01499_ VGND VGND VPWR VPWR _03240_ sky130_fd_sc_hd__and4_1
X_06779_ _00092_ _00101_ _00100_ VGND VGND VPWR VPWR _00206_ sky130_fd_sc_hd__a21bo_1
XFILLER_0_77_273 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
X_09498_ _03129_ _02998_ _03163_ _03164_ VGND VGND VPWR VPWR _03165_ sky130_fd_sc_hd__o211ai_4
X_08518_ _00409_ _00488_ _02093_ _02094_ VGND VGND VPWR VPWR _02095_ sky130_fd_sc_hd__nand4_1
XFILLER_0_38_638 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_0_108_526 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_0_108_504 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_92_221 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
X_08449_ _01834_ _01844_ _02018_ _02019_ VGND VGND VPWR VPWR _02020_ sky130_fd_sc_hd__o211a_1
XTAP_TAPCELL_ROW_13_419 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_65_468 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
X_11460_ _01433_ _05290_ VGND VGND VPWR VPWR net98 sky130_fd_sc_hd__nor2_2
X_11391_ _05188_ _05221_ VGND VGND VPWR VPWR _05224_ sky130_fd_sc_hd__or2_1
X_10411_ _04159_ _04160_ VGND VGND VPWR VPWR _04162_ sky130_fd_sc_hd__and2b_1
XPHY_EDGE_ROW_30_Right_30 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
X_10342_ _04013_ _04015_ VGND VGND VPWR VPWR _04087_ sky130_fd_sc_hd__or2_1
XFILLER_0_33_376 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
X_10273_ _04008_ _04010_ _03884_ _03886_ VGND VGND VPWR VPWR _04012_ sky130_fd_sc_hd__o211a_1
XFILLER_0_29_18 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XPHY_EDGE_ROW_100_Left_222 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_0_88_527 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_0_56_413 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_0_83_221 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XTAP_TAPCELL_ROW_64_1063 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_83_276 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_0_56_468 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_44_608 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_0_71_449 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_52_630 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_9_39 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XTAP_TAPCELL_ROW_40_761 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_116_1716 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
X_10609_ _04374_ _04375_ _04376_ VGND VGND VPWR VPWR _04377_ sky130_fd_sc_hd__a21bo_1
XFILLER_0_3_215 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XFILLER_0_24_332 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_0_10_53 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_24_365 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_0_110_713 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_0_51_195 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_10_97 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_50_9 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
X_07820_ _01238_ _01240_ VGND VGND VPWR VPWR _01333_ sky130_fd_sc_hd__nor2_1
XFILLER_0_19_51 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
X_07751_ _01141_ _01143_ VGND VGND VPWR VPWR _01259_ sky130_fd_sc_hd__and2_1
XFILLER_0_79_505 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
X_06702_ _00024_ _00123_ VGND VGND VPWR VPWR _00129_ sky130_fd_sc_hd__and2b_1
XFILLER_0_29_6 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
X_07682_ _01059_ _01063_ _01062_ VGND VGND VPWR VPWR _01183_ sky130_fd_sc_hd__a21boi_1
XTAP_TAPCELL_ROW_48_861 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
X_09421_ _02918_ _02963_ VGND VGND VPWR VPWR _03081_ sky130_fd_sc_hd__and2b_1
X_06633_ _03332_ _05304_ _05305_ _04726_ VGND VGND VPWR VPWR _00061_ sky130_fd_sc_hd__a22o_1
XFILLER_0_87_571 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
X_09352_ _01800_ VGND VGND VPWR VPWR _03006_ sky130_fd_sc_hd__buf_4
X_06564_ net40 VGND VGND VPWR VPWR _05693_ sky130_fd_sc_hd__clkbuf_4
X_08303_ _01859_ _01860_ VGND VGND VPWR VPWR _01861_ sky130_fd_sc_hd__xnor2_1
X_09283_ _02929_ _02930_ VGND VGND VPWR VPWR _02931_ sky130_fd_sc_hd__xor2_1
XFILLER_0_62_405 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_0_51_60 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
X_06495_ _05623_ _05624_ VGND VGND VPWR VPWR _05625_ sky130_fd_sc_hd__nor2_1
XFILLER_0_47_479 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_7_576 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
X_08234_ _01622_ _01623_ _01651_ _01278_ VGND VGND VPWR VPWR _01786_ sky130_fd_sc_hd__and4b_1
X_08165_ _01570_ _01572_ _01708_ _01709_ VGND VGND VPWR VPWR _01710_ sky130_fd_sc_hd__o211a_1
X_07116_ net46 VGND VGND VPWR VPWR _00565_ sky130_fd_sc_hd__clkbuf_4
X_08096_ _01625_ _01633_ _01634_ VGND VGND VPWR VPWR _01635_ sky130_fd_sc_hd__nand3_2
X_07047_ _00373_ _00488_ _00484_ _00486_ VGND VGND VPWR VPWR _00489_ sky130_fd_sc_hd__a22oi_1
XFILLER_0_30_379 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
X_08998_ _02490_ _02507_ _02508_ VGND VGND VPWR VPWR _02619_ sky130_fd_sc_hd__nand3_1
X_07949_ _01471_ _01472_ _01305_ _01363_ VGND VGND VPWR VPWR _01474_ sky130_fd_sc_hd__o211a_1
X_10960_ _01040_ _02173_ _01980_ _02060_ VGND VGND VPWR VPWR _04758_ sky130_fd_sc_hd__a22o_1
X_10891_ _02850_ _03489_ _04680_ _04681_ VGND VGND VPWR VPWR _04684_ sky130_fd_sc_hd__nand4_2
X_09619_ _02160_ VGND VGND VPWR VPWR _03297_ sky130_fd_sc_hd__buf_4
XFILLER_0_38_413 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XTAP_TAPCELL_ROW_100_1517 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_100_1506 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_26_588 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_108_323 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_0_53_405 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XFILLER_0_65_298 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_25_118 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
X_11443_ _05277_ _05278_ VGND VGND VPWR VPWR _05279_ sky130_fd_sc_hd__xor2_4
XFILLER_0_21_313 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
X_11374_ _05194_ _05166_ _05204_ VGND VGND VPWR VPWR _05206_ sky130_fd_sc_hd__a21o_1
X_10325_ _00348_ _00350_ _01977_ _02695_ VGND VGND VPWR VPWR _04068_ sky130_fd_sc_hd__nand4_1
XTAP_TAPCELL_ROW_111_1646 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
X_10256_ _03990_ _03992_ VGND VGND VPWR VPWR _03993_ sky130_fd_sc_hd__xor2_1
XFILLER_0_56_27 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
X_10187_ _03915_ _03916_ VGND VGND VPWR VPWR _03918_ sky130_fd_sc_hd__nand2_1
XFILLER_0_72_15 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XTAP_TAPCELL_ROW_45_820 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_69_582 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_29_413 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_118_109 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_56_265 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_29_468 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
X_06280_ _05409_ _05411_ VGND VGND VPWR VPWR _05412_ sky130_fd_sc_hd__or2_2
XFILLER_0_44_427 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_112_65 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XTAP_TAPCELL_ROW_77_1221 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_71_279 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_4_557 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_25_685 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_12_335 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_09970_ _03415_ _03558_ VGND VGND VPWR VPWR _03680_ sky130_fd_sc_hd__nor2_1
XFILLER_0_12_357 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
X_08921_ _02531_ _02532_ _02534_ VGND VGND VPWR VPWR _02536_ sky130_fd_sc_hd__and3_1
X_08852_ _00087_ _00421_ _01379_ _02459_ VGND VGND VPWR VPWR _02460_ sky130_fd_sc_hd__nand4_1
X_07803_ _01179_ _01314_ _01315_ VGND VGND VPWR VPWR _01316_ sky130_fd_sc_hd__nor3_1
X_08783_ _02232_ _02385_ VGND VGND VPWR VPWR _02386_ sky130_fd_sc_hd__xnor2_4
X_05995_ _03485_ _03496_ _03190_ VGND VGND VPWR VPWR _03518_ sky130_fd_sc_hd__o21a_1
X_07734_ _01205_ _01089_ _01238_ _01239_ VGND VGND VPWR VPWR _01240_ sky130_fd_sc_hd__a211oi_2
XFILLER_0_27_3 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XTAP_TAPCELL_ROW_88_1361 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
X_07665_ _01057_ _01163_ _01164_ VGND VGND VPWR VPWR _01165_ sky130_fd_sc_hd__nor3_2
X_09404_ _02748_ _02902_ _03062_ VGND VGND VPWR VPWR _03063_ sky130_fd_sc_hd__a21boi_2
X_06616_ _00472_ _05468_ _05654_ VGND VGND VPWR VPWR _00044_ sky130_fd_sc_hd__nand3_1
X_07596_ _01074_ _01087_ _01088_ VGND VGND VPWR VPWR _01089_ sky130_fd_sc_hd__or3_2
XFILLER_0_47_221 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
X_09335_ _02640_ _02641_ _02320_ _02837_ VGND VGND VPWR VPWR _02987_ sky130_fd_sc_hd__nand4_2
XTAP_TAPCELL_ROW_23_547 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
X_06547_ _02458_ VGND VGND VPWR VPWR _05676_ sky130_fd_sc_hd__buf_4
XFILLER_0_47_243 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_0_117_142 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_90_533 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_90_511 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
X_09266_ _03616_ _02230_ _02767_ _02766_ VGND VGND VPWR VPWR _02912_ sky130_fd_sc_hd__a31o_1
XFILLER_0_62_202 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
X_06478_ _05512_ _05573_ _05606_ _05607_ VGND VGND VPWR VPWR _05608_ sky130_fd_sc_hd__o211ai_4
XFILLER_0_47_276 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_0_117_164 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_0_7_373 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_16_630 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_35_449 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
X_08217_ net3 _00195_ VGND VGND VPWR VPWR _01767_ sky130_fd_sc_hd__and2_1
XFILLER_0_105_337 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_09197_ _00983_ VGND VGND VPWR VPWR _02837_ sky130_fd_sc_hd__buf_4
XFILLER_0_15_151 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
X_08148_ _01512_ _01514_ VGND VGND VPWR VPWR _01691_ sky130_fd_sc_hd__nor2_1
XFILLER_0_30_132 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_30_165 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
X_08079_ _01613_ _01614_ _01443_ _01609_ VGND VGND VPWR VPWR _01616_ sky130_fd_sc_hd__a211o_1
XFILLER_0_101_554 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
X_10110_ _03721_ VGND VGND VPWR VPWR _03833_ sky130_fd_sc_hd__inv_2
X_11090_ _03440_ _01850_ _01500_ _03341_ VGND VGND VPWR VPWR _04899_ sky130_fd_sc_hd__a22o_1
X_10041_ _03756_ _03757_ VGND VGND VPWR VPWR _03759_ sky130_fd_sc_hd__xor2_2
XFILLER_0_11_390 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
X_10943_ _01620_ _01800_ _01675_ VGND VGND VPWR VPWR _04740_ sky130_fd_sc_hd__and3_1
XFILLER_0_58_508 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XTAP_TAPCELL_ROW_3_294 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_97_165 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
X_10874_ _04663_ _04664_ VGND VGND VPWR VPWR _04665_ sky130_fd_sc_hd__xnor2_1
XFILLER_0_85_349 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_0_66_530 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XFILLER_0_42_29 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XTAP_TAPCELL_ROW_61_1022 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_109_665 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_0_93_393 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_53_279 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
X_11426_ _04040_ _04724_ _05260_ VGND VGND VPWR VPWR _05261_ sky130_fd_sc_hd__a21oi_1
XFILLER_0_22_622 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XANTENNA_6 _00646_ VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
X_11357_ _05186_ _05187_ VGND VGND VPWR VPWR _05188_ sky130_fd_sc_hd__or2_2
XFILLER_0_6_29 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_21_132 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_0_21_154 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
X_10308_ _02646_ _03297_ _04047_ _04048_ VGND VGND VPWR VPWR _04049_ sky130_fd_sc_hd__a22oi_2
XFILLER_0_67_15 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_22_699 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
X_11288_ _05013_ _05085_ VGND VGND VPWR VPWR _05113_ sky130_fd_sc_hd__nand2_1
X_10239_ _03971_ _03972_ _03847_ _03849_ VGND VGND VPWR VPWR _03974_ sky130_fd_sc_hd__o211a_1
XTAP_TAPCELL_ROW_72_1162 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_107_21 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
X_05780_ _00406_ VGND VGND VPWR VPWR _01171_ sky130_fd_sc_hd__clkbuf_4
XFILLER_0_16_41 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_107_87 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_57_530 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
X_07450_ _05497_ _05655_ _00796_ _00795_ _05320_ VGND VGND VPWR VPWR _00929_ sky130_fd_sc_hd__a32o_1
XFILLER_0_57_541 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
X_07381_ _00851_ _00852_ _00707_ _00817_ VGND VGND VPWR VPWR _00855_ sky130_fd_sc_hd__o211ai_1
X_06401_ _05455_ _05531_ VGND VGND VPWR VPWR _05532_ sky130_fd_sc_hd__nor2_1
X_09120_ _02584_ _02585_ VGND VGND VPWR VPWR _02752_ sky130_fd_sc_hd__or2b_1
X_06332_ _05318_ VGND VGND VPWR VPWR _05463_ sky130_fd_sc_hd__buf_4
XTAP_TAPCELL_ROW_20_506 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_32_51 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_72_555 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_09051_ _02498_ _02499_ _02500_ VGND VGND VPWR VPWR _02678_ sky130_fd_sc_hd__a21bo_1
XTAP_TAPCELL_ROW_20_517 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_115_635 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
X_06263_ _05393_ _05394_ VGND VGND VPWR VPWR _05395_ sky130_fd_sc_hd__nand2_1
X_08002_ _01528_ _01529_ _01496_ _01498_ VGND VGND VPWR VPWR _01532_ sky130_fd_sc_hd__o211a_1
XPHY_EDGE_ROW_6_Right_6 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_0_4_321 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XFILLER_0_32_419 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_4_365 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_13_633 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
X_06194_ _03223_ VGND VGND VPWR VPWR _05327_ sky130_fd_sc_hd__clkbuf_8
XFILLER_0_110_362 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
X_09953_ _03661_ _03662_ VGND VGND VPWR VPWR _03663_ sky130_fd_sc_hd__or2_2
X_09884_ _03581_ _03585_ _03586_ VGND VGND VPWR VPWR _03587_ sky130_fd_sc_hd__nand3_1
X_08904_ _02219_ _01284_ _01449_ _01771_ VGND VGND VPWR VPWR _02517_ sky130_fd_sc_hd__a22o_1
X_08835_ _02261_ _02264_ _02439_ _02440_ VGND VGND VPWR VPWR _02441_ sky130_fd_sc_hd__a211oi_1
XTAP_TAPCELL_ROW_28_606 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
X_08766_ _02365_ _02366_ VGND VGND VPWR VPWR _02367_ sky130_fd_sc_hd__xnor2_4
XFILLER_0_79_143 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
X_07717_ _00187_ VGND VGND VPWR VPWR _01221_ sky130_fd_sc_hd__buf_4
XTAP_TAPCELL_ROW_28_617 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
X_05978_ _02458_ VGND VGND VPWR VPWR _03332_ sky130_fd_sc_hd__clkbuf_4
XFILLER_0_95_614 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
X_08697_ _02287_ _02288_ _02289_ VGND VGND VPWR VPWR _02291_ sky130_fd_sc_hd__nand3_1
XTAP_TAPCELL_ROW_56_959 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_0_253 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_67_349 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XTAP_TAPCELL_ROW_0_264 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
X_07648_ _01143_ _01144_ _01145_ VGND VGND VPWR VPWR _01146_ sky130_fd_sc_hd__nand3_2
X_07579_ _00920_ _00922_ _01068_ _01069_ VGND VGND VPWR VPWR _01070_ sky130_fd_sc_hd__o211a_1
X_09318_ _01221_ _01903_ VGND VGND VPWR VPWR _02969_ sky130_fd_sc_hd__nand2_1
XFILLER_0_118_462 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
X_10590_ _04305_ _04307_ VGND VGND VPWR VPWR _04356_ sky130_fd_sc_hd__and2_1
XFILLER_0_90_330 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
X_09249_ _02834_ _02893_ VGND VGND VPWR VPWR _02894_ sky130_fd_sc_hd__xnor2_4
XFILLER_0_8_693 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_0_35_279 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_50_249 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_0_50_238 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_105_189 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
X_11211_ _05028_ _05023_ VGND VGND VPWR VPWR _05031_ sky130_fd_sc_hd__or2b_1
XFILLER_0_31_441 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_0_120_148 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_11142_ _04953_ _04955_ VGND VGND VPWR VPWR _04956_ sky130_fd_sc_hd__or2_1
Xoutput76 net76 VGND VGND VPWR VPWR product[1] sky130_fd_sc_hd__clkbuf_4
Xoutput65 net65 VGND VGND VPWR VPWR product[0] sky130_fd_sc_hd__clkbuf_4
X_11073_ _00895_ _01041_ _03690_ _03172_ VGND VGND VPWR VPWR _04881_ sky130_fd_sc_hd__and4_1
XTAP_TAPCELL_ROW_8_364 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
Xoutput87 net87 VGND VGND VPWR VPWR product[2] sky130_fd_sc_hd__buf_2
Xoutput98 net98 VGND VGND VPWR VPWR product[3] sky130_fd_sc_hd__clkbuf_4
X_10024_ _03737_ _03738_ _03699_ VGND VGND VPWR VPWR _03740_ sky130_fd_sc_hd__o21ai_1
XFILLER_0_98_474 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XFILLER_0_86_614 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
X_10926_ _04550_ _04720_ _04721_ VGND VGND VPWR VPWR _04722_ sky130_fd_sc_hd__o21ai_2
XTAP_TAPCELL_ROW_106_1589 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
X_10857_ _04645_ VGND VGND VPWR VPWR _04646_ sky130_fd_sc_hd__inv_2
XFILLER_0_86_669 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_109_440 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
X_10788_ _04569_ _04570_ VGND VGND VPWR VPWR _04571_ sky130_fd_sc_hd__or2b_1
XPHY_EDGE_ROW_59_Right_59 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_0_14_419 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_78_14 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
X_11409_ _05241_ _05242_ VGND VGND VPWR VPWR _05243_ sky130_fd_sc_hd__nand2_1
XFILLER_0_1_313 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XFILLER_0_22_441 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_111_137 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_0_1_357 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_0_10_669 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_120_693 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
X_06950_ _00285_ _00290_ VGND VGND VPWR VPWR _00383_ sky130_fd_sc_hd__or2b_1
XPHY_EDGE_ROW_68_Right_68 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
X_06881_ _00304_ _00305_ _00306_ VGND VGND VPWR VPWR _00309_ sky130_fd_sc_hd__a21o_1
X_05901_ _02436_ _02469_ _02480_ VGND VGND VPWR VPWR _02491_ sky130_fd_sc_hd__nand3_1
XFILLER_0_118_53 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
X_05832_ _01694_ _01705_ _01716_ VGND VGND VPWR VPWR _01738_ sky130_fd_sc_hd__a21oi_1
XFILLER_0_27_51 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
X_08620_ _02129_ _02205_ _02206_ VGND VGND VPWR VPWR _02207_ sky130_fd_sc_hd__nand3_2
XFILLER_0_118_97 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XTAP_TAPCELL_ROW_85_1320 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
X_08551_ _01955_ _01958_ VGND VGND VPWR VPWR _02132_ sky130_fd_sc_hd__nand2_1
X_05763_ net27 VGND VGND VPWR VPWR _00985_ sky130_fd_sc_hd__buf_4
XFILLER_0_77_625 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
X_08482_ _01905_ _01914_ _01912_ VGND VGND VPWR VPWR _02056_ sky130_fd_sc_hd__a21oi_1
XTAP_TAPCELL_ROW_53_929 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_49_327 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
X_07502_ _00301_ VGND VGND VPWR VPWR _00987_ sky130_fd_sc_hd__clkbuf_4
X_07433_ _00769_ _00782_ _00783_ VGND VGND VPWR VPWR _00911_ sky130_fd_sc_hd__and3_1
XFILLER_0_9_413 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XPHY_EDGE_ROW_77_Right_77 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
X_09103_ _02560_ _02562_ VGND VGND VPWR VPWR _02735_ sky130_fd_sc_hd__nor2_1
XFILLER_0_17_246 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
X_07364_ _00428_ _00565_ VGND VGND VPWR VPWR _00836_ sky130_fd_sc_hd__and2_1
XTAP_TAPCELL_ROW_33_675 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_45_533 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_115_410 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_94_3 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_5_641 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_32_205 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
X_06315_ _05381_ _05446_ VGND VGND VPWR VPWR _05447_ sky130_fd_sc_hd__xnor2_1
X_07295_ _02513_ _00485_ _00349_ _01486_ VGND VGND VPWR VPWR _00760_ sky130_fd_sc_hd__a22o_1
XFILLER_0_72_385 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
X_09034_ _02656_ _02657_ _02619_ _02511_ VGND VGND VPWR VPWR _02659_ sky130_fd_sc_hd__o211ai_2
X_06246_ _05364_ _05365_ VGND VGND VPWR VPWR _05378_ sky130_fd_sc_hd__and2b_1
XFILLER_0_45_599 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XFILLER_0_102_115 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XFILLER_0_102_104 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XTAP_TAPCELL_ROW_96_1460 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_5_685 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_4_195 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
X_06177_ net3 VGND VGND VPWR VPWR _05310_ sky130_fd_sc_hd__buf_4
XFILLER_0_110_181 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
X_09936_ _03457_ _03459_ _03642_ _03643_ VGND VGND VPWR VPWR _03644_ sky130_fd_sc_hd__a211o_2
XPHY_EDGE_ROW_86_Right_86 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_0_0_390 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XTAP_TAPCELL_ROW_5_323 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_99_205 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
X_09867_ _00152_ _00237_ _02321_ _01606_ VGND VGND VPWR VPWR _03568_ sky130_fd_sc_hd__and4_1
X_09798_ _01580_ _01759_ _03490_ _01041_ VGND VGND VPWR VPWR _03493_ sky130_fd_sc_hd__nand4_2
X_08818_ _02409_ _02410_ _02420_ VGND VGND VPWR VPWR _02422_ sky130_fd_sc_hd__a21oi_1
X_08749_ _04770_ _04781_ _01976_ _02173_ VGND VGND VPWR VPWR _02348_ sky130_fd_sc_hd__nand4_2
XFILLER_0_67_113 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XPHY_EDGE_ROW_95_Right_95 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
X_10711_ _04485_ _04486_ VGND VGND VPWR VPWR _04488_ sky130_fd_sc_hd__or2_1
XFILLER_0_82_127 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
X_10642_ _04311_ _04321_ _04322_ VGND VGND VPWR VPWR _04414_ sky130_fd_sc_hd__nand3_2
XFILLER_0_76_691 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_10573_ _04253_ _04232_ _04337_ _04338_ VGND VGND VPWR VPWR _04339_ sky130_fd_sc_hd__a211o_2
XFILLER_0_106_421 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_0_106_454 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_51_536 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_0_51_569 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_121_468 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_121_457 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
X_11125_ _04936_ _04937_ VGND VGND VPWR VPWR _04938_ sky130_fd_sc_hd__or2b_2
X_11056_ _04787_ _04789_ _04861_ VGND VGND VPWR VPWR _04863_ sky130_fd_sc_hd__and3_1
X_10007_ _02108_ _02110_ _02516_ _02345_ VGND VGND VPWR VPWR _03721_ sky130_fd_sc_hd__nand4_2
XTAP_TAPCELL_ROW_108_1618 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_108_1607 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_64_38 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_86_400 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XTAP_TAPCELL_ROW_67_1094 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_58_157 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
X_10909_ _04700_ _04701_ _04659_ VGND VGND VPWR VPWR _04703_ sky130_fd_sc_hd__o21a_1
XFILLER_0_86_477 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XTAP_TAPCELL_ROW_80_1261 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_73_149 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_6_416 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_0_109_281 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_6_438 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XTAP_TAPCELL_ROW_30_634 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_120_21 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XTAP_TAPCELL_ROW_119_1747 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_89_57 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XFILLER_0_81_182 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_81_160 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
X_07080_ net64 _05318_ net5 _02458_ VGND VGND VPWR VPWR _00525_ sky130_fd_sc_hd__a22o_1
X_06100_ _04498_ _04509_ _04640_ VGND VGND VPWR VPWR _04661_ sky130_fd_sc_hd__and3_1
XFILLER_0_120_65 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
X_06031_ _03878_ _03889_ _03900_ VGND VGND VPWR VPWR _03911_ sky130_fd_sc_hd__nand3_1
XFILLER_0_42_569 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XTAP_TAPCELL_ROW_10_391 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_10_444 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_2_699 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
X_07982_ _01341_ _01343_ VGND VGND VPWR VPWR _01510_ sky130_fd_sc_hd__nor2_1
XFILLER_0_10_477 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
X_09721_ _03399_ _03406_ _03407_ VGND VGND VPWR VPWR _03409_ sky130_fd_sc_hd__nand3_1
X_06933_ _00363_ _00364_ _00908_ _00033_ VGND VGND VPWR VPWR _00365_ sky130_fd_sc_hd__and4bb_1
XFILLER_0_97_709 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
X_09652_ _02105_ _00355_ _03331_ _03333_ VGND VGND VPWR VPWR _03334_ sky130_fd_sc_hd__a22o_1
X_06864_ _00286_ _00289_ VGND VGND VPWR VPWR _00290_ sky130_fd_sc_hd__xnor2_2
XFILLER_0_96_208 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
X_09583_ _03107_ _03109_ VGND VGND VPWR VPWR _03258_ sky130_fd_sc_hd__nand2_1
X_05815_ _00854_ VGND VGND VPWR VPWR _01552_ sky130_fd_sc_hd__clkbuf_4
X_06795_ _00219_ _00220_ _00131_ _00132_ VGND VGND VPWR VPWR _00222_ sky130_fd_sc_hd__a211o_1
XTAP_TAPCELL_ROW_38_734 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
X_08603_ _02184_ _02187_ _02183_ VGND VGND VPWR VPWR _02189_ sky130_fd_sc_hd__a21o_1
XFILLER_0_89_293 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
X_08534_ _01580_ VGND VGND VPWR VPWR _02113_ sky130_fd_sc_hd__clkbuf_4
X_05746_ net1 VGND VGND VPWR VPWR _00799_ sky130_fd_sc_hd__clkbuf_8
X_08465_ _01552_ _02036_ _01852_ _00668_ VGND VGND VPWR VPWR _02037_ sky130_fd_sc_hd__a22o_1
XFILLER_0_65_617 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_0_9_210 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XTAP_TAPCELL_ROW_18_491 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_108_719 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_107_218 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
X_08396_ _01940_ _01960_ _01961_ VGND VGND VPWR VPWR _01962_ sky130_fd_sc_hd__nand3_2
X_07416_ _00758_ _00768_ VGND VGND VPWR VPWR _00892_ sky130_fd_sc_hd__or2_1
XFILLER_0_18_533 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_92_469 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
X_07347_ _00685_ _00707_ _00708_ VGND VGND VPWR VPWR _00817_ sky130_fd_sc_hd__nand3_1
XFILLER_0_18_577 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_33_503 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_45_352 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_0_115_262 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XFILLER_0_103_424 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
X_09017_ _00138_ VGND VGND VPWR VPWR _02640_ sky130_fd_sc_hd__buf_4
XFILLER_0_5_482 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XFILLER_0_5_460 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
X_07278_ _00645_ _00648_ _00740_ VGND VGND VPWR VPWR _00741_ sky130_fd_sc_hd__o21ai_1
XFILLER_0_21_709 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_60_399 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_60_388 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_60_377 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
X_06229_ _05324_ _05360_ _05361_ VGND VGND VPWR VPWR _05362_ sky130_fd_sc_hd__or3_1
XFILLER_0_103_468 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
X_09919_ _02976_ _02281_ _03423_ _03422_ _00496_ VGND VGND VPWR VPWR _03625_ sky130_fd_sc_hd__a32o_1
XFILLER_0_68_411 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XTAP_TAPCELL_ROW_103_1548 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_68_477 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_56_628 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
X_10625_ _04267_ _04364_ _04394_ VGND VGND VPWR VPWR _04395_ sky130_fd_sc_hd__o21a_1
XFILLER_0_64_683 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_36_396 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_106_251 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
X_10556_ _04317_ _04318_ _04313_ VGND VGND VPWR VPWR _04320_ sky130_fd_sc_hd__a21o_1
X_10487_ _04243_ _04244_ VGND VGND VPWR VPWR _04245_ sky130_fd_sc_hd__xnor2_2
XFILLER_0_121_276 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XTAP_TAPCELL_ROW_114_1688 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
X_11108_ _04825_ _04826_ VGND VGND VPWR VPWR _04919_ sky130_fd_sc_hd__nor2_1
X_11039_ _04842_ _04843_ VGND VGND VPWR VPWR _04844_ sky130_fd_sc_hd__xor2_2
XFILLER_0_79_709 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XTAP_TAPCELL_ROW_69_1123 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_35_704 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_59_433 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
X_06580_ _00006_ _00007_ _05684_ VGND VGND VPWR VPWR _00009_ sky130_fd_sc_hd__o21ai_2
XFILLER_0_24_41 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_47_617 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_0_74_458 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XTAP_TAPCELL_ROW_15_450 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
X_08250_ _01978_ net52 VGND VGND VPWR VPWR _01803_ sky130_fd_sc_hd__and2_1
XFILLER_0_117_538 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
X_08181_ _05419_ _00623_ _01545_ _01544_ _00344_ VGND VGND VPWR VPWR _01728_ sky130_fd_sc_hd__a32o_1
XFILLER_0_6_224 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_0_39_190 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
X_07201_ _00655_ _00656_ VGND VGND VPWR VPWR _00658_ sky130_fd_sc_hd__or2b_1
X_07132_ _00579_ _00580_ _00442_ _00544_ VGND VGND VPWR VPWR _00583_ sky130_fd_sc_hd__o211a_1
XFILLER_0_27_385 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
X_07063_ _00503_ _00505_ _00386_ _00389_ VGND VGND VPWR VPWR _00507_ sky130_fd_sc_hd__o211ai_1
XFILLER_0_42_388 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XTAP_TAPCELL_ROW_93_1430 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_23_580 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_42_399 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
X_06014_ _03594_ _03714_ VGND VGND VPWR VPWR _03725_ sky130_fd_sc_hd__xnor2_1
XFILLER_0_100_427 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_57_3 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
X_07965_ _00888_ _01488_ _01490_ VGND VGND VPWR VPWR _01491_ sky130_fd_sc_hd__o21ba_2
X_09704_ _03316_ _03317_ _03360_ _03361_ VGND VGND VPWR VPWR _03390_ sky130_fd_sc_hd__nand4_2
X_06916_ _00345_ VGND VGND VPWR VPWR _00346_ sky130_fd_sc_hd__clkbuf_4
X_09635_ _03184_ _03204_ _03205_ VGND VGND VPWR VPWR _03315_ sky130_fd_sc_hd__nand3_1
XFILLER_0_65_81 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
X_07896_ _04542_ _00423_ _00195_ _04520_ VGND VGND VPWR VPWR _01417_ sky130_fd_sc_hd__a22oi_1
X_06847_ _00271_ _00272_ VGND VGND VPWR VPWR _00273_ sky130_fd_sc_hd__and2b_1
X_09566_ _05689_ _03237_ _03238_ _05589_ VGND VGND VPWR VPWR _03239_ sky130_fd_sc_hd__a22oi_1
X_06778_ _00202_ _00203_ _00193_ VGND VGND VPWR VPWR _00205_ sky130_fd_sc_hd__a21o_1
X_09497_ _03161_ _03162_ _03022_ _03024_ VGND VGND VPWR VPWR _03164_ sky130_fd_sc_hd__a211o_1
X_08517_ _05585_ _05686_ _00343_ _00345_ VGND VGND VPWR VPWR _02094_ sky130_fd_sc_hd__nand4_2
X_05729_ _00482_ _00602_ VGND VGND VPWR VPWR _00613_ sky130_fd_sc_hd__xor2_1
XFILLER_0_108_516 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_0_92_233 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_65_447 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
X_08448_ _02016_ _02017_ _01845_ VGND VGND VPWR VPWR _02019_ sky130_fd_sc_hd__o21ai_1
XFILLER_0_108_538 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
X_10410_ _04156_ _04158_ _04044_ VGND VGND VPWR VPWR _04160_ sky130_fd_sc_hd__a21o_1
XFILLER_0_92_299 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_08379_ _05319_ _05387_ _00686_ VGND VGND VPWR VPWR _01944_ sky130_fd_sc_hd__and3_1
X_11390_ _05221_ _05222_ VGND VGND VPWR VPWR net119 sky130_fd_sc_hd__xor2_2
XFILLER_0_60_141 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
X_10341_ _03975_ _04082_ _04083_ VGND VGND VPWR VPWR _04086_ sky130_fd_sc_hd__nor3_2
XFILLER_0_60_163 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_33_388 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
X_10272_ _03884_ _03886_ _04008_ _04010_ VGND VGND VPWR VPWR _04011_ sky130_fd_sc_hd__a211oi_4
XFILLER_0_103_287 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_88_539 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_84_701 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XTAP_TAPCELL_ROW_64_1064 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_56_425 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_28_149 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_37_650 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XTAP_TAPCELL_ROW_40_762 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_43_119 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XTAP_TAPCELL_ROW_116_1706 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
X_10608_ _00614_ _03012_ _02174_ _00610_ VGND VGND VPWR VPWR _04376_ sky130_fd_sc_hd__a22o_1
XFILLER_0_64_491 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_52_642 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XFILLER_0_36_193 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XTAP_TAPCELL_ROW_116_1717 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
X_10539_ _04192_ _04195_ VGND VGND VPWR VPWR _04301_ sky130_fd_sc_hd__or2_2
XFILLER_0_52_697 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_0_12_539 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_10_65 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
X_07750_ _01255_ _01256_ VGND VGND VPWR VPWR _01257_ sky130_fd_sc_hd__nor2_1
X_06701_ _00126_ _00127_ VGND VGND VPWR VPWR _00128_ sky130_fd_sc_hd__and2b_1
XFILLER_0_35_51 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
X_07681_ _01065_ _01071_ _01070_ VGND VGND VPWR VPWR _01182_ sky130_fd_sc_hd__a21oi_1
XTAP_TAPCELL_ROW_48_862 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
X_09420_ _04716_ _02230_ _02934_ _02933_ VGND VGND VPWR VPWR _03079_ sky130_fd_sc_hd__a31o_2
X_06632_ _05659_ _05676_ _05307_ _05308_ VGND VGND VPWR VPWR _00060_ sky130_fd_sc_hd__nand4_1
XFILLER_0_87_561 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
X_09351_ _02871_ _02879_ _02878_ VGND VGND VPWR VPWR _03005_ sky130_fd_sc_hd__a21bo_1
XFILLER_0_19_105 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
X_06563_ _01978_ _05502_ VGND VGND VPWR VPWR _05692_ sky130_fd_sc_hd__and2_1
X_09282_ _04900_ _02045_ VGND VGND VPWR VPWR _02930_ sky130_fd_sc_hd__nand2_1
X_08302_ _01677_ _01681_ VGND VGND VPWR VPWR _01860_ sky130_fd_sc_hd__or2_1
XFILLER_0_7_500 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_0_47_447 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_117_302 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_0_74_266 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
X_06494_ _05529_ _05537_ _05621_ VGND VGND VPWR VPWR _05624_ sky130_fd_sc_hd__nor3_1
X_08233_ _01612_ _01613_ VGND VGND VPWR VPWR _01785_ sky130_fd_sc_hd__nand2_1
XFILLER_0_34_119 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_0_117_379 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
X_08164_ _01706_ _01707_ _01686_ VGND VGND VPWR VPWR _01709_ sky130_fd_sc_hd__o21ai_2
XFILLER_0_70_472 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_0_70_461 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_0_15_388 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
X_08095_ _01630_ _01631_ _01632_ VGND VGND VPWR VPWR _01634_ sky130_fd_sc_hd__a21o_1
X_07115_ _00428_ _00301_ VGND VGND VPWR VPWR _00564_ sky130_fd_sc_hd__and2_1
XFILLER_0_42_141 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
X_07046_ _00354_ VGND VGND VPWR VPWR _00488_ sky130_fd_sc_hd__clkbuf_4
XFILLER_0_42_174 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XFILLER_0_11_561 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_08997_ _02481_ _02483_ VGND VGND VPWR VPWR _02618_ sky130_fd_sc_hd__nand2_1
X_07948_ _01305_ _01363_ _01471_ _01472_ VGND VGND VPWR VPWR _01473_ sky130_fd_sc_hd__a211oi_4
X_07879_ _01385_ _01396_ _01397_ VGND VGND VPWR VPWR _01398_ sky130_fd_sc_hd__nor3_2
X_10890_ _02850_ _02941_ _04680_ _04681_ VGND VGND VPWR VPWR _04682_ sky130_fd_sc_hd__a22o_1
X_09618_ _03293_ _03295_ VGND VGND VPWR VPWR _03296_ sky130_fd_sc_hd__xor2_1
X_09549_ _03058_ _03056_ VGND VGND VPWR VPWR _03221_ sky130_fd_sc_hd__or2b_1
XFILLER_0_66_701 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XTAP_TAPCELL_ROW_100_1507 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_65_222 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XFILLER_0_65_200 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XTAP_TAPCELL_ROW_26_589 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_100_1518 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_81_715 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_19_650 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_38_469 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_0_80_214 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
X_11442_ _05241_ _05263_ _05265_ VGND VGND VPWR VPWR _05278_ sky130_fd_sc_hd__o21ai_4
Xwire135 _01668_ VGND VGND VPWR VPWR net135 sky130_fd_sc_hd__buf_1
XFILLER_0_34_653 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
X_11373_ _05194_ _05166_ _05204_ VGND VGND VPWR VPWR _05205_ sky130_fd_sc_hd__nand3_1
XFILLER_0_1_709 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_34_686 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_0_104_563 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
X_10324_ _02459_ _02516_ _02345_ _01379_ VGND VGND VPWR VPWR _04067_ sky130_fd_sc_hd__a22o_1
XFILLER_0_21_358 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
X_10255_ _01249_ _03478_ _03868_ _03991_ VGND VGND VPWR VPWR _03992_ sky130_fd_sc_hd__a31o_1
XTAP_TAPCELL_ROW_111_1647 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
X_10186_ _03915_ _03916_ VGND VGND VPWR VPWR _03917_ sky130_fd_sc_hd__nor2_1
XFILLER_0_88_358 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_0_88_347 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XTAP_TAPCELL_ROW_45_821 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_69_561 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_84_531 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_29_425 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_0_56_233 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_0_71_225 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_44_417 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_0_115_3 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_112_77 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_0_37_491 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XTAP_TAPCELL_ROW_77_1222 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_24_163 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_4_569 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_25_697 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_97_57 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_0_40_667 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XFILLER_0_110_544 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
X_08920_ _00439_ _02185_ _02533_ VGND VGND VPWR VPWR _02534_ sky130_fd_sc_hd__and3_1
X_08851_ _00235_ VGND VGND VPWR VPWR _02459_ sky130_fd_sc_hd__buf_4
X_07802_ _01311_ _01312_ _01163_ _01165_ VGND VGND VPWR VPWR _01315_ sky130_fd_sc_hd__a211oi_1
X_08782_ _02381_ _02384_ VGND VGND VPWR VPWR _02385_ sky130_fd_sc_hd__xor2_4
X_05994_ _03190_ _03485_ _03496_ VGND VGND VPWR VPWR _03507_ sky130_fd_sc_hd__nor3_1
XFILLER_0_79_325 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_07733_ _01235_ _01237_ _01151_ _01153_ VGND VGND VPWR VPWR _01239_ sky130_fd_sc_hd__o211a_1
XTAP_TAPCELL_ROW_88_1362 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
X_07664_ _01161_ _01162_ _01012_ net146 VGND VGND VPWR VPWR _01164_ sky130_fd_sc_hd__a211oi_2
XFILLER_0_94_317 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_94_306 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
X_09403_ _02901_ _02899_ VGND VGND VPWR VPWR _03062_ sky130_fd_sc_hd__or2b_1
X_06615_ _00406_ _00042_ _00037_ _00039_ VGND VGND VPWR VPWR _00043_ sky130_fd_sc_hd__a22oi_4
X_07595_ _01084_ _01085_ _01086_ VGND VGND VPWR VPWR _01088_ sky130_fd_sc_hd__a21oi_1
XFILLER_0_118_633 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_09334_ _02110_ _01610_ _01605_ _02108_ VGND VGND VPWR VPWR _02986_ sky130_fd_sc_hd__a22o_1
X_06546_ _01039_ _04998_ _05587_ _05586_ _05585_ VGND VGND VPWR VPWR _05675_ sky130_fd_sc_hd__a32o_1
X_09265_ _02909_ _02911_ VGND VGND VPWR VPWR net93 sky130_fd_sc_hd__xor2_4
XTAP_TAPCELL_ROW_23_548 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
X_06477_ _05604_ _05605_ _05584_ VGND VGND VPWR VPWR _05607_ sky130_fd_sc_hd__o21ai_2
XFILLER_0_35_417 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_118_699 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
X_09196_ _02689_ _02698_ _02697_ VGND VGND VPWR VPWR _02836_ sky130_fd_sc_hd__a21bo_1
X_08216_ _01761_ _01765_ VGND VGND VPWR VPWR _01766_ sky130_fd_sc_hd__xor2_2
XFILLER_0_16_642 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XFILLER_0_90_589 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
X_08147_ _01547_ _01548_ VGND VGND VPWR VPWR _01690_ sky130_fd_sc_hd__and2_1
XFILLER_0_15_185 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_0_113_360 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
X_08078_ _01443_ _01609_ _01613_ _01614_ VGND VGND VPWR VPWR _01615_ sky130_fd_sc_hd__o211a_1
X_07029_ _00121_ _00225_ _00333_ _00335_ _00336_ VGND VGND VPWR VPWR _00470_ sky130_fd_sc_hd__a32o_1
X_10040_ _00283_ _02052_ VGND VGND VPWR VPWR _03757_ sky130_fd_sc_hd__nand2_1
XFILLER_0_87_90 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_98_601 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
X_10942_ _04696_ VGND VGND VPWR VPWR _04739_ sky130_fd_sc_hd__inv_2
XFILLER_0_97_111 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XTAP_TAPCELL_ROW_3_295 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_97_177 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
X_10873_ _02838_ _01856_ VGND VGND VPWR VPWR _04664_ sky130_fd_sc_hd__nand2_1
XFILLER_0_109_633 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XTAP_TAPCELL_ROW_61_1023 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_53_203 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_38_266 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_0_53_258 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XTAP_TAPCELL_ROW_50_890 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
X_11425_ _05258_ _05259_ VGND VGND VPWR VPWR _05260_ sky130_fd_sc_hd__nor2_1
XANTENNA_7 _01441_ VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_0_22_634 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_22_645 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
X_11356_ _05153_ _05185_ _05154_ VGND VGND VPWR VPWR _05187_ sky130_fd_sc_hd__and3_1
X_10307_ _02108_ _02110_ _02178_ _03030_ VGND VGND VPWR VPWR _04048_ sky130_fd_sc_hd__nand4_1
X_11287_ _03396_ _04724_ _05077_ _05111_ VGND VGND VPWR VPWR _05112_ sky130_fd_sc_hd__a31oi_2
X_10238_ _03847_ _03849_ _03971_ _03972_ VGND VGND VPWR VPWR _03973_ sky130_fd_sc_hd__a211oi_4
XTAP_TAPCELL_ROW_72_1163 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
X_10169_ _03895_ _03896_ _03734_ _03737_ VGND VGND VPWR VPWR _03898_ sky130_fd_sc_hd__a211o_1
XFILLER_0_107_33 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_89_634 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_16_53 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XTAP_TAPCELL_ROW_58_990 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_9_617 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
X_06400_ _05529_ _05530_ VGND VGND VPWR VPWR _05531_ sky130_fd_sc_hd__xnor2_1
XFILLER_0_91_309 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_57_553 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
X_07380_ _00707_ _00817_ _00851_ _00852_ VGND VGND VPWR VPWR _00853_ sky130_fd_sc_hd__a211o_2
XFILLER_0_45_704 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
X_06331_ _00461_ _05320_ _05388_ _00373_ VGND VGND VPWR VPWR _05462_ sky130_fd_sc_hd__a22oi_1
XFILLER_0_32_41 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_0_32_63 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
X_09050_ _02673_ _02674_ _02672_ VGND VGND VPWR VPWR _02676_ sky130_fd_sc_hd__a21o_1
X_06262_ _03605_ _00908_ _04531_ _04552_ VGND VGND VPWR VPWR _05394_ sky130_fd_sc_hd__nand4_1
XTAP_TAPCELL_ROW_20_507 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_20_518 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_115_647 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
X_08001_ _01496_ _01498_ _01528_ _01529_ VGND VGND VPWR VPWR _01531_ sky130_fd_sc_hd__a211oi_2
XFILLER_0_44_258 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_13_645 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
X_06193_ _03627_ _04900_ _04943_ _04933_ VGND VGND VPWR VPWR _05326_ sky130_fd_sc_hd__a31oi_2
XFILLER_0_102_319 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_12_122 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XFILLER_0_4_377 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
X_09952_ _03657_ _03658_ _03659_ VGND VGND VPWR VPWR _03662_ sky130_fd_sc_hd__a21oi_1
XFILLER_0_40_475 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
X_08903_ _01114_ VGND VGND VPWR VPWR _02516_ sky130_fd_sc_hd__buf_4
XFILLER_0_0_561 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
X_09883_ _00042_ _02984_ _03582_ _03584_ VGND VGND VPWR VPWR _03586_ sky130_fd_sc_hd__nand4_1
X_08834_ _02437_ _02438_ _02427_ VGND VGND VPWR VPWR _02440_ sky130_fd_sc_hd__a21boi_1
X_08765_ _02183_ _02184_ _02187_ VGND VGND VPWR VPWR _02366_ sky130_fd_sc_hd__a21bo_2
XFILLER_0_79_133 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XTAP_TAPCELL_ROW_28_607 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_28_618 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
X_07716_ _01077_ _01079_ VGND VGND VPWR VPWR _01220_ sky130_fd_sc_hd__nand2_1
X_05977_ _00537_ VGND VGND VPWR VPWR _03321_ sky130_fd_sc_hd__buf_4
XFILLER_0_79_155 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XPHY_EDGE_ROW_69_Left_191 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
X_08696_ _02287_ _02288_ _02289_ VGND VGND VPWR VPWR _02290_ sky130_fd_sc_hd__a21o_1
XTAP_TAPCELL_ROW_0_254 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_0_265 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
X_07647_ _00957_ _00958_ _00956_ VGND VGND VPWR VPWR _01145_ sky130_fd_sc_hd__a21bo_1
XFILLER_0_82_309 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
X_07578_ _03791_ _00354_ _01066_ _01067_ VGND VGND VPWR VPWR _01069_ sky130_fd_sc_hd__a22o_1
X_09317_ _01898_ _02966_ _02967_ VGND VGND VPWR VPWR _02968_ sky130_fd_sc_hd__a21bo_1
X_06529_ _05654_ _05657_ VGND VGND VPWR VPWR _05658_ sky130_fd_sc_hd__xnor2_2
XFILLER_0_118_474 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XFILLER_0_90_320 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_118_485 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XFILLER_0_106_658 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
X_09248_ _02890_ _02892_ VGND VGND VPWR VPWR _02893_ sky130_fd_sc_hd__xor2_4
XFILLER_0_7_193 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XFILLER_0_121_617 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
X_09179_ _00034_ _02105_ _02815_ _02816_ VGND VGND VPWR VPWR _02817_ sky130_fd_sc_hd__a22o_1
X_11210_ _05023_ _05028_ VGND VGND VPWR VPWR _05029_ sky130_fd_sc_hd__or2b_1
XFILLER_0_31_453 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
X_11141_ _04951_ _04952_ VGND VGND VPWR VPWR _04955_ sky130_fd_sc_hd__nor2_1
XFILLER_0_31_486 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
Xoutput66 net66 VGND VGND VPWR VPWR product[10] sky130_fd_sc_hd__clkbuf_4
XFILLER_0_9_3 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
X_11072_ _01041_ _04157_ _03172_ _00895_ VGND VGND VPWR VPWR _04880_ sky130_fd_sc_hd__a22oi_2
Xoutput99 net99 VGND VGND VPWR VPWR product[40] sky130_fd_sc_hd__clkbuf_4
XTAP_TAPCELL_ROW_8_365 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
Xoutput77 net77 VGND VGND VPWR VPWR product[20] sky130_fd_sc_hd__clkbuf_4
Xoutput88 net88 VGND VGND VPWR VPWR product[30] sky130_fd_sc_hd__clkbuf_4
X_10023_ _03699_ _03737_ _03738_ VGND VGND VPWR VPWR _03739_ sky130_fd_sc_hd__or3_2
XFILLER_0_98_464 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_0_58_306 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
X_10925_ _04538_ _04635_ _04636_ VGND VGND VPWR VPWR _04721_ sky130_fd_sc_hd__o21bai_2
XFILLER_0_86_626 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_85_103 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
X_10856_ _04642_ _04643_ _04564_ _04644_ VGND VGND VPWR VPWR _04645_ sky130_fd_sc_hd__a211o_1
XFILLER_0_94_670 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_85_169 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_26_203 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_109_463 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_0_93_180 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
X_10787_ _04566_ _04567_ _04568_ VGND VGND VPWR VPWR _04570_ sky130_fd_sc_hd__a21o_1
XFILLER_0_42_707 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_111_105 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
X_11408_ _05228_ _05240_ VGND VGND VPWR VPWR _05242_ sky130_fd_sc_hd__or2_1
XFILLER_0_10_615 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
X_11339_ _05156_ _05128_ _05167_ VGND VGND VPWR VPWR _05168_ sky130_fd_sc_hd__and3_1
X_06880_ _00304_ _00305_ _00306_ VGND VGND VPWR VPWR _00307_ sky130_fd_sc_hd__nand3_1
X_05900_ _00537_ _02000_ _02458_ net1 VGND VGND VPWR VPWR _02480_ sky130_fd_sc_hd__a22o_1
XFILLER_0_118_65 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
X_05831_ _01694_ _01705_ _01716_ VGND VGND VPWR VPWR _01727_ sky130_fd_sc_hd__and3_1
XTAP_TAPCELL_ROW_85_1321 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
X_08550_ _01817_ _01965_ _02001_ _02002_ VGND VGND VPWR VPWR _02130_ sky130_fd_sc_hd__a211o_1
X_05762_ _00963_ VGND VGND VPWR VPWR _00974_ sky130_fd_sc_hd__buf_4
XFILLER_0_77_637 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_08481_ _02050_ _02053_ VGND VGND VPWR VPWR _02055_ sky130_fd_sc_hd__xor2_4
XTAP_TAPCELL_ROW_53_919 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
X_07501_ _00982_ _00984_ VGND VGND VPWR VPWR _00986_ sky130_fd_sc_hd__nor2_1
X_07432_ _00782_ VGND VGND VPWR VPWR _00910_ sky130_fd_sc_hd__inv_2
XFILLER_0_9_425 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_91_117 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
X_09102_ _02570_ _02733_ VGND VGND VPWR VPWR _02734_ sky130_fd_sc_hd__xnor2_2
XTAP_TAPCELL_ROW_33_676 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
X_07363_ _00829_ _00834_ VGND VGND VPWR VPWR _00835_ sky130_fd_sc_hd__xor2_2
XFILLER_0_115_422 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_60_515 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
X_06314_ _05444_ _05445_ VGND VGND VPWR VPWR _05446_ sky130_fd_sc_hd__nor2_1
XFILLER_0_45_556 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
X_07294_ _02513_ _01486_ _00485_ _00235_ VGND VGND VPWR VPWR _00759_ sky130_fd_sc_hd__and4_1
XFILLER_0_115_444 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_0_87_3 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
X_09033_ _02619_ _02511_ _02656_ _02657_ VGND VGND VPWR VPWR _02658_ sky130_fd_sc_hd__a211o_1
XFILLER_0_5_653 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_4_141 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
X_06245_ _05291_ _05369_ VGND VGND VPWR VPWR _05377_ sky130_fd_sc_hd__nor2_2
XFILLER_0_103_617 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XTAP_TAPCELL_ROW_96_1461 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
X_06176_ _00668_ _05307_ _05308_ _00690_ VGND VGND VPWR VPWR _05309_ sky130_fd_sc_hd__a22o_1
XFILLER_0_5_697 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_13_475 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_40_272 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_111_661 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_09935_ _03640_ _03641_ _03621_ VGND VGND VPWR VPWR _03643_ sky130_fd_sc_hd__o21a_1
XFILLER_0_110_193 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
X_09866_ _03565_ _03566_ VGND VGND VPWR VPWR _03567_ sky130_fd_sc_hd__and2_1
XTAP_TAPCELL_ROW_5_324 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
X_08817_ _02409_ _02410_ _02420_ VGND VGND VPWR VPWR _02421_ sky130_fd_sc_hd__and3_1
X_09797_ _01759_ _03490_ _03491_ _01580_ VGND VGND VPWR VPWR _03492_ sky130_fd_sc_hd__a22o_1
X_08748_ _03124_ _01114_ _02173_ _04802_ VGND VGND VPWR VPWR _02347_ sky130_fd_sc_hd__a22o_1
X_08679_ _02071_ _02073_ VGND VGND VPWR VPWR _02271_ sky130_fd_sc_hd__nor2_2
X_10710_ _04483_ _04484_ _01604_ _01680_ VGND VGND VPWR VPWR _04486_ sky130_fd_sc_hd__and4bb_1
XFILLER_0_67_169 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_36_501 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_0_36_512 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
X_10641_ _04410_ _04411_ VGND VGND VPWR VPWR _04413_ sky130_fd_sc_hd__xor2_1
XFILLER_0_82_139 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
X_10572_ _04291_ _04293_ _04334_ _04335_ VGND VGND VPWR VPWR _04338_ sky130_fd_sc_hd__a22oi_4
XFILLER_0_91_673 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_36_589 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_106_466 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_121_403 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_0_106_488 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_51_559 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_48_29 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
X_11124_ _04855_ _04859_ _04935_ VGND VGND VPWR VPWR _04937_ sky130_fd_sc_hd__or3_1
X_11055_ _04787_ _04789_ _04861_ VGND VGND VPWR VPWR _04862_ sky130_fd_sc_hd__a21oi_1
X_10006_ _00038_ _01976_ _02173_ _05540_ VGND VGND VPWR VPWR _03720_ sky130_fd_sc_hd__a22o_1
XTAP_TAPCELL_ROW_108_1608 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_98_272 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
X_10908_ _04659_ _04700_ _04701_ VGND VGND VPWR VPWR _04702_ sky130_fd_sc_hd__nor3_1
XFILLER_0_86_467 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_80_27 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_117_709 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_73_117 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XTAP_TAPCELL_ROW_67_1095 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_39_361 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_46_309 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
X_10839_ _04521_ _04523_ _04625_ _04626_ VGND VGND VPWR VPWR _04627_ sky130_fd_sc_hd__a211o_1
XFILLER_0_104_78 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XTAP_TAPCELL_ROW_80_1262 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_73_128 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_54_353 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_27_567 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XTAP_TAPCELL_ROW_30_635 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_119_1748 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_109_293 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_89_47 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_0_81_194 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_2_601 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
X_06030_ _03299_ _03386_ _03354_ VGND VGND VPWR VPWR _03900_ sky130_fd_sc_hd__a21bo_1
XFILLER_0_120_77 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XTAP_TAPCELL_ROW_10_392 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_10_381 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_1_111 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_2_645 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
X_07981_ _01381_ _01377_ VGND VGND VPWR VPWR _01509_ sky130_fd_sc_hd__and2b_1
X_09720_ _03404_ _03405_ _03300_ _03400_ VGND VGND VPWR VPWR _03407_ sky130_fd_sc_hd__o211ai_2
X_06932_ _02513_ _05539_ _00139_ _01486_ VGND VGND VPWR VPWR _00364_ sky130_fd_sc_hd__a22oi_1
XFILLER_0_38_73 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
X_09651_ _00151_ _01603_ _02459_ _01610_ VGND VGND VPWR VPWR _03333_ sky130_fd_sc_hd__nand4_1
X_06863_ _00287_ _00288_ VGND VGND VPWR VPWR _00289_ sky130_fd_sc_hd__and2b_1
X_09582_ _03134_ _03143_ _03142_ VGND VGND VPWR VPWR _03257_ sky130_fd_sc_hd__a21o_1
X_05814_ _01486_ _01497_ _01519_ _01530_ VGND VGND VPWR VPWR _01541_ sky130_fd_sc_hd__nand4_2
X_06794_ _00131_ _00132_ _00219_ _00220_ VGND VGND VPWR VPWR _00221_ sky130_fd_sc_hd__o211ai_4
XTAP_TAPCELL_ROW_38_735 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
X_08602_ _02183_ _02184_ _02187_ VGND VGND VPWR VPWR _02188_ sky130_fd_sc_hd__nand3_1
XFILLER_0_77_401 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
X_08533_ _01580_ _00041_ _02107_ _02111_ VGND VGND VPWR VPWR _02112_ sky130_fd_sc_hd__a22o_1
X_05745_ _00766_ _00777_ VGND VGND VPWR VPWR _00788_ sky130_fd_sc_hd__nand2_1
X_08464_ net20 VGND VGND VPWR VPWR _02036_ sky130_fd_sc_hd__clkbuf_4
XFILLER_0_9_222 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XTAP_TAPCELL_ROW_18_481 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_18_492 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_70_71 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_0_64_139 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
X_08395_ _01958_ _01959_ _01941_ VGND VGND VPWR VPWR _01961_ sky130_fd_sc_hd__a21o_1
XFILLER_0_9_244 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
X_07415_ _00765_ _00767_ VGND VGND VPWR VPWR _00891_ sky130_fd_sc_hd__or2b_1
XFILLER_0_18_523 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XFILLER_0_18_545 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XFILLER_0_73_673 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_70_93 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_9_299 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
X_07346_ _00813_ _00814_ _00792_ _00793_ VGND VGND VPWR VPWR _00816_ sky130_fd_sc_hd__o211a_1
XFILLER_0_115_241 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_103_403 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
X_09016_ _02110_ _02104_ _01603_ _05540_ VGND VGND VPWR VPWR _02639_ sky130_fd_sc_hd__a22o_1
X_07277_ _00616_ _00617_ _00628_ _00738_ _00739_ VGND VGND VPWR VPWR _00740_ sky130_fd_sc_hd__o32ai_2
X_06228_ _05358_ _05359_ _05138_ _05159_ VGND VGND VPWR VPWR _05361_ sky130_fd_sc_hd__o211a_1
X_06159_ _04249_ _04455_ _05266_ _05276_ VGND VGND VPWR VPWR _05291_ sky130_fd_sc_hd__nand4_4
X_09918_ _03493_ _03495_ VGND VGND VPWR VPWR _03624_ sky130_fd_sc_hd__nand2_2
X_09849_ _03401_ _03403_ _03402_ VGND VGND VPWR VPWR _03548_ sky130_fd_sc_hd__a21bo_1
XTAP_TAPCELL_ROW_103_1549 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_68_489 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_68_467 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XFILLER_0_56_618 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_0_49_670 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XFILLER_0_28_309 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_55_128 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_48_180 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_10624_ _04392_ _04393_ VGND VGND VPWR VPWR _04394_ sky130_fd_sc_hd__nor2_1
XFILLER_0_70_109 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_0_64_695 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_0_63_161 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_63_150 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
X_10555_ _04313_ _04317_ _04318_ VGND VGND VPWR VPWR _04319_ sky130_fd_sc_hd__nand3_4
X_10486_ _04137_ _04139_ _04135_ VGND VGND VPWR VPWR _04244_ sky130_fd_sc_hd__a21oi_2
XFILLER_0_121_266 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XFILLER_0_121_288 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XTAP_TAPCELL_ROW_114_1689 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
X_11107_ _04898_ _04917_ VGND VGND VPWR VPWR _04918_ sky130_fd_sc_hd__xor2_1
XFILLER_0_75_38 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_11038_ _02838_ _02227_ VGND VGND VPWR VPWR _04843_ sky130_fd_sc_hd__nand2_1
XTAP_TAPCELL_ROW_69_1124 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_35_705 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_115_55 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_86_253 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_24_53 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XTAP_TAPCELL_ROW_15_451 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_27_320 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_0_61_109 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
X_08180_ _01723_ _01724_ _01722_ VGND VGND VPWR VPWR _01726_ sky130_fd_sc_hd__a21o_1
X_07200_ _03834_ _05463_ _05552_ _04976_ VGND VGND VPWR VPWR _00656_ sky130_fd_sc_hd__a22o_1
X_07131_ _00442_ _00544_ _00579_ _00580_ VGND VGND VPWR VPWR _00582_ sky130_fd_sc_hd__a211oi_4
XFILLER_0_40_41 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_15_559 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_40_85 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_0_42_334 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_0_112_233 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
X_07062_ _00386_ _00389_ _00503_ _00505_ VGND VGND VPWR VPWR _00506_ sky130_fd_sc_hd__a211o_1
XFILLER_0_112_266 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XTAP_TAPCELL_ROW_93_1420 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
X_06013_ _03638_ _03703_ VGND VGND VPWR VPWR _03714_ sky130_fd_sc_hd__xor2_1
XFILLER_0_10_253 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_4_41 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
X_07964_ _01320_ _01322_ _01485_ _01489_ _01484_ VGND VGND VPWR VPWR _01490_ sky130_fd_sc_hd__a32o_1
X_09703_ _03280_ _03281_ _03364_ _03366_ VGND VGND VPWR VPWR _03389_ sky130_fd_sc_hd__or4bb_2
X_06915_ net11 VGND VGND VPWR VPWR _00345_ sky130_fd_sc_hd__clkbuf_4
XFILLER_0_4_85 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
X_07895_ _01413_ _01415_ VGND VGND VPWR VPWR _01416_ sky130_fd_sc_hd__and2_2
X_09634_ _03041_ _03183_ VGND VGND VPWR VPWR _03314_ sky130_fd_sc_hd__or2_1
XFILLER_0_65_93 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
X_06846_ _03856_ _04520_ _04542_ _05416_ VGND VGND VPWR VPWR _00272_ sky130_fd_sc_hd__a22o_1
X_09565_ _01852_ VGND VGND VPWR VPWR _03238_ sky130_fd_sc_hd__clkbuf_4
X_06777_ _00193_ _00202_ _00203_ VGND VGND VPWR VPWR _00204_ sky130_fd_sc_hd__nand3_2
XFILLER_0_77_264 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
X_09496_ _03022_ _03024_ _03161_ _03162_ VGND VGND VPWR VPWR _03163_ sky130_fd_sc_hd__o211ai_4
X_08516_ _05423_ _00150_ _00349_ _05585_ VGND VGND VPWR VPWR _02093_ sky130_fd_sc_hd__a22o_1
X_05728_ _00515_ _00570_ _00592_ VGND VGND VPWR VPWR _00602_ sky130_fd_sc_hd__a21bo_1
XFILLER_0_37_106 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_0_92_212 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
X_08447_ _01845_ _02016_ _02017_ VGND VGND VPWR VPWR _02018_ sky130_fd_sc_hd__or3_1
XFILLER_0_92_245 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_0_46_651 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_61_610 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
X_08378_ _00558_ VGND VGND VPWR VPWR _01943_ sky130_fd_sc_hd__buf_4
XFILLER_0_46_684 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_104_701 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_33_334 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
X_07329_ _05320_ _00795_ _00796_ VGND VGND VPWR VPWR _00797_ sky130_fd_sc_hd__a21bo_1
X_10340_ _04082_ _04083_ _03975_ VGND VGND VPWR VPWR _04084_ sky130_fd_sc_hd__o21a_1
X_10271_ _04006_ _04007_ _03997_ VGND VGND VPWR VPWR _04010_ sky130_fd_sc_hd__a21oi_2
XFILLER_0_60_197 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_0_84_713 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_0_68_253 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XPHY_EDGE_ROW_14_Left_136 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XTAP_TAPCELL_ROW_64_1065 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_12_410 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_37_662 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_37_673 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XTAP_TAPCELL_ROW_40_763 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_43_109 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XTAP_TAPCELL_ROW_116_1707 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_107_561 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
X_10607_ _00610_ _00614_ _03341_ VGND VGND VPWR VPWR _04375_ sky130_fd_sc_hd__and3_1
XFILLER_0_52_654 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_24_345 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XTAP_TAPCELL_ROW_116_1718 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_101_57 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_10538_ _04298_ _04299_ VGND VGND VPWR VPWR _04300_ sky130_fd_sc_hd__or2_1
XFILLER_0_12_518 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_101_79 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_10_77 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XPHY_EDGE_ROW_23_Left_145 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
X_10469_ _04206_ _04223_ _04224_ VGND VGND VPWR VPWR _04225_ sky130_fd_sc_hd__or3_2
XFILLER_0_86_15 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XTAP_TAPCELL_ROW_75_1194 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
X_06700_ _00126_ _00127_ VGND VGND VPWR VPWR net73 sky130_fd_sc_hd__xnor2_4
X_07680_ _01091_ _01093_ VGND VGND VPWR VPWR _01180_ sky130_fd_sc_hd__nor2_1
XTAP_TAPCELL_ROW_48_863 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_59_220 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
X_06631_ _00055_ _00058_ VGND VGND VPWR VPWR _00059_ sky130_fd_sc_hd__xnor2_4
XPHY_EDGE_ROW_32_Left_154 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_0_35_63 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
X_09350_ _03000_ _03001_ _02965_ _02827_ VGND VGND VPWR VPWR _03003_ sky130_fd_sc_hd__a211o_1
XFILLER_0_59_253 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
X_06562_ _05688_ _05690_ VGND VGND VPWR VPWR _05691_ sky130_fd_sc_hd__xnor2_2
X_09281_ _02926_ _02927_ VGND VGND VPWR VPWR _02929_ sky130_fd_sc_hd__xnor2_1
X_08301_ _01855_ _01857_ VGND VGND VPWR VPWR _01859_ sky130_fd_sc_hd__xnor2_1
X_08232_ _01619_ _01638_ _01639_ VGND VGND VPWR VPWR _01784_ sky130_fd_sc_hd__nand3_2
X_06493_ _05622_ VGND VGND VPWR VPWR _05623_ sky130_fd_sc_hd__inv_2
XFILLER_0_62_429 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XFILLER_0_51_95 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_0_15_301 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_0_55_481 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
X_08163_ _01686_ _01706_ _01707_ VGND VGND VPWR VPWR _01708_ sky130_fd_sc_hd__or3_2
XFILLER_0_70_451 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
X_08094_ _01630_ _01631_ _01632_ VGND VGND VPWR VPWR _01633_ sky130_fd_sc_hd__nand3_1
X_07114_ _00557_ _00562_ VGND VGND VPWR VPWR _00563_ sky130_fd_sc_hd__xor2_2
XPHY_EDGE_ROW_41_Left_163 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_0_70_484 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
X_07045_ _01236_ _00354_ _00484_ _00486_ VGND VGND VPWR VPWR _00487_ sky130_fd_sc_hd__and4_1
XFILLER_0_2_250 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XFILLER_0_43_698 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XFILLER_0_30_348 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
X_08996_ _02575_ _02616_ VGND VGND VPWR VPWR _02617_ sky130_fd_sc_hd__xnor2_4
X_07947_ _01403_ _01404_ _01469_ _01470_ VGND VGND VPWR VPWR _01472_ sky130_fd_sc_hd__a2bb2oi_2
XPHY_EDGE_ROW_50_Left_172 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
X_07878_ _01228_ _01230_ _01395_ VGND VGND VPWR VPWR _01397_ sky130_fd_sc_hd__and3_1
XFILLER_0_97_337 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_92_80 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
X_09617_ _05468_ _03294_ VGND VGND VPWR VPWR _03295_ sky130_fd_sc_hd__nand2_1
X_06829_ _00174_ _00234_ _00254_ VGND VGND VPWR VPWR _00255_ sky130_fd_sc_hd__a21o_2
XFILLER_0_92_91 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
X_09548_ _03083_ _03219_ VGND VGND VPWR VPWR _03220_ sky130_fd_sc_hd__xnor2_4
XFILLER_0_78_551 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_66_713 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XTAP_TAPCELL_ROW_100_1508 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
X_09479_ _03142_ _03143_ VGND VGND VPWR VPWR _03144_ sky130_fd_sc_hd__or2b_1
XFILLER_0_65_245 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_0_19_662 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_19_673 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
X_11441_ _05274_ _05275_ VGND VGND VPWR VPWR _05277_ sky130_fd_sc_hd__nand2_2
XFILLER_0_80_226 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_0_18_172 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
X_11372_ _05201_ _05203_ VGND VGND VPWR VPWR _05204_ sky130_fd_sc_hd__nand2_1
Xwire158 _00791_ VGND VGND VPWR VPWR net158 sky130_fd_sc_hd__buf_1
X_10323_ _00355_ _02163_ _03960_ _03961_ VGND VGND VPWR VPWR _04066_ sky130_fd_sc_hd__and4_1
XFILLER_0_0_209 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_0_21_337 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
X_10254_ _03865_ _03866_ VGND VGND VPWR VPWR _03991_ sky130_fd_sc_hd__and2b_1
XTAP_TAPCELL_ROW_111_1648 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
X_10185_ _03792_ _03794_ VGND VGND VPWR VPWR _03916_ sky130_fd_sc_hd__nor2_1
XFILLER_0_56_29 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XFILLER_0_88_304 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_0_69_573 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_0_69_551 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XTAP_TAPCELL_ROW_45_822 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_8_309 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_84_565 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_29_459 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XFILLER_0_37_470 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_0_114_306 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XFILLER_0_71_248 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_25_621 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_114_328 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_0_108_3 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_107_391 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XTAP_TAPCELL_ROW_77_1223 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_52_495 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_110_589 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_110_578 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_08850_ _00421_ _00343_ _00345_ _00089_ VGND VGND VPWR VPWR _02457_ sky130_fd_sc_hd__a22o_1
X_07801_ _01163_ _01165_ _01311_ _01312_ VGND VGND VPWR VPWR _01314_ sky130_fd_sc_hd__o211a_1
X_08781_ _02083_ _02084_ _02382_ _02210_ VGND VGND VPWR VPWR _02384_ sky130_fd_sc_hd__o31a_2
X_05993_ _03452_ _03463_ _03474_ VGND VGND VPWR VPWR _03496_ sky130_fd_sc_hd__a21oi_1
X_07732_ _01151_ _01153_ _01235_ _01237_ VGND VGND VPWR VPWR _01238_ sky130_fd_sc_hd__a211oi_2
XFILLER_0_46_73 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XTAP_TAPCELL_ROW_88_1363 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_79_337 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
X_07663_ _01012_ _01058_ _01161_ _01162_ VGND VGND VPWR VPWR _01163_ sky130_fd_sc_hd__o211a_1
X_09402_ _02915_ _03060_ VGND VGND VPWR VPWR _03061_ sky130_fd_sc_hd__xnor2_2
X_06614_ _00041_ VGND VGND VPWR VPWR _00042_ sky130_fd_sc_hd__clkbuf_8
XFILLER_0_1_53 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
X_09333_ _00798_ _01606_ _02844_ _02842_ _02984_ VGND VGND VPWR VPWR _02985_ sky130_fd_sc_hd__a32o_1
XFILLER_0_75_521 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_07594_ _01084_ _01085_ _01086_ VGND VGND VPWR VPWR _01087_ sky130_fd_sc_hd__and3_1
XFILLER_0_47_201 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
X_06545_ _05578_ _05580_ VGND VGND VPWR VPWR _05674_ sky130_fd_sc_hd__nand2_1
XFILLER_0_47_256 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_118_645 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_117_133 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_0_117_111 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_75_576 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_09264_ _02737_ _02741_ _02910_ VGND VGND VPWR VPWR _02911_ sky130_fd_sc_hd__o21ba_1
XTAP_TAPCELL_ROW_23_549 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
X_06476_ _05584_ _05604_ _05605_ VGND VGND VPWR VPWR _05606_ sky130_fd_sc_hd__or3_2
XFILLER_0_47_289 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_105_306 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
X_09195_ _02679_ _02681_ VGND VGND VPWR VPWR _02835_ sky130_fd_sc_hd__nand2_1
X_08215_ _01762_ _01763_ _01764_ VGND VGND VPWR VPWR _01765_ sky130_fd_sc_hd__a21bo_1
XFILLER_0_90_568 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
X_08146_ _01510_ _01517_ VGND VGND VPWR VPWR _01689_ sky130_fd_sc_hd__or2b_1
XFILLER_0_15_142 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_120_309 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XFILLER_0_15_164 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_0_30_112 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
X_08077_ _03080_ _00830_ _01611_ _01612_ VGND VGND VPWR VPWR _01614_ sky130_fd_sc_hd__a22o_1
X_07028_ _00027_ _00126_ _00129_ VGND VGND VPWR VPWR _00469_ sky130_fd_sc_hd__o21bai_1
XFILLER_0_30_178 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_11_370 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
X_08979_ _00533_ _02060_ _01040_ _05497_ VGND VGND VPWR VPWR _02598_ sky130_fd_sc_hd__a22o_1
XFILLER_0_98_613 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
X_10941_ _04734_ _04736_ VGND VGND VPWR VPWR _04738_ sky130_fd_sc_hd__xor2_1
XTAP_TAPCELL_ROW_3_296 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
X_10872_ _01850_ _04660_ _04662_ VGND VGND VPWR VPWR _04663_ sky130_fd_sc_hd__a21bo_1
XFILLER_0_81_502 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XTAP_TAPCELL_ROW_61_1024 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
X_11424_ _05022_ _04040_ _05033_ _04873_ VGND VGND VPWR VPWR _05259_ sky130_fd_sc_hd__and4_2
XTAP_TAPCELL_ROW_50_891 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_61_281 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XANTENNA_8 _01497_ VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
X_11355_ _05153_ _05154_ _05185_ VGND VGND VPWR VPWR _05186_ sky130_fd_sc_hd__a21oi_1
XFILLER_0_22_657 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
X_11286_ _05075_ _05076_ VGND VGND VPWR VPWR _05111_ sky130_fd_sc_hd__and2b_1
X_10306_ _00038_ _02692_ _02529_ _05540_ VGND VGND VPWR VPWR _04047_ sky130_fd_sc_hd__a22o_1
X_10237_ _03969_ _03970_ _03811_ VGND VGND VPWR VPWR _03972_ sky130_fd_sc_hd__o21a_1
XTAP_TAPCELL_ROW_72_1164 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
X_10168_ _03734_ _03737_ _03895_ _03896_ VGND VGND VPWR VPWR _03897_ sky130_fd_sc_hd__o211ai_4
X_10099_ _00152_ _00346_ _02813_ _02984_ VGND VGND VPWR VPWR _03821_ sky130_fd_sc_hd__and4_1
XFILLER_0_107_45 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_89_646 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_88_112 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XFILLER_0_16_21 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XTAP_TAPCELL_ROW_58_991 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_16_65 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_88_189 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_0_69_370 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_0_9_629 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_29_223 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_84_351 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_57_598 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_0_8_139 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_29_278 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
X_06330_ _05405_ _05413_ VGND VGND VPWR VPWR _05461_ sky130_fd_sc_hd__and2_1
XFILLER_0_115_615 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_115_604 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
X_06261_ _01552_ _05304_ _05308_ _00668_ VGND VGND VPWR VPWR _05393_ sky130_fd_sc_hd__a22o_1
XTAP_TAPCELL_ROW_20_508 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_72_568 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_60_719 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_4_334 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
X_08000_ _01526_ _01527_ _01401_ _01403_ VGND VGND VPWR VPWR _01529_ sky130_fd_sc_hd__a211oi_2
XFILLER_0_115_659 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_114_136 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_0_102_309 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
X_06192_ _04792_ _05301_ VGND VGND VPWR VPWR _05325_ sky130_fd_sc_hd__and2_1
X_09951_ _03657_ _03658_ _03659_ VGND VGND VPWR VPWR _03661_ sky130_fd_sc_hd__and3_1
X_08902_ _02348_ _02352_ VGND VGND VPWR VPWR _02515_ sky130_fd_sc_hd__nand2_1
X_09882_ _00034_ _02984_ _03582_ _03584_ VGND VGND VPWR VPWR _03585_ sky130_fd_sc_hd__a22o_1
XFILLER_0_0_595 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
X_08833_ _02427_ _02437_ _02438_ VGND VGND VPWR VPWR _02439_ sky130_fd_sc_hd__and3b_1
X_05976_ net1 VGND VGND VPWR VPWR _03310_ sky130_fd_sc_hd__buf_4
X_08764_ _02363_ _02364_ VGND VGND VPWR VPWR _02365_ sky130_fd_sc_hd__or2_2
XTAP_TAPCELL_ROW_28_608 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
X_07715_ _01210_ _01218_ VGND VGND VPWR VPWR _01219_ sky130_fd_sc_hd__xnor2_4
XFILLER_0_79_167 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
X_08695_ _05585_ net13 VGND VGND VPWR VPWR _02289_ sky130_fd_sc_hd__and2_1
XTAP_TAPCELL_ROW_0_244 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_94_104 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XTAP_TAPCELL_ROW_0_255 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_0_266 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
X_07646_ _00269_ _00089_ _01141_ _01142_ VGND VGND VPWR VPWR _01144_ sky130_fd_sc_hd__a22o_1
XFILLER_0_94_159 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
X_07577_ _03791_ _00623_ _01066_ _01067_ VGND VGND VPWR VPWR _01068_ sky130_fd_sc_hd__nand4_2
X_09316_ _00421_ _00609_ _00748_ _00087_ VGND VGND VPWR VPWR _02967_ sky130_fd_sc_hd__a22o_1
X_06528_ _00472_ _05656_ VGND VGND VPWR VPWR _05657_ sky130_fd_sc_hd__nand2_1
XFILLER_0_48_587 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_63_557 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
X_09247_ _02687_ _02715_ _02891_ VGND VGND VPWR VPWR _02892_ sky130_fd_sc_hd__a21oi_4
XFILLER_0_35_237 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_118_497 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_0_90_365 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_90_354 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_06459_ _03834_ VGND VGND VPWR VPWR _05589_ sky130_fd_sc_hd__buf_4
XFILLER_0_7_161 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_0_105_136 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_90_387 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
X_09178_ _02640_ _02641_ _02492_ _02320_ VGND VGND VPWR VPWR _02816_ sky130_fd_sc_hd__nand4_2
XFILLER_0_114_681 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
X_08129_ _01503_ VGND VGND VPWR VPWR _01670_ sky130_fd_sc_hd__inv_2
XFILLER_0_31_432 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_43_281 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_120_139 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
X_11140_ _04951_ _04952_ VGND VGND VPWR VPWR _04953_ sky130_fd_sc_hd__and2_1
XFILLER_0_31_465 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_101_364 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
Xoutput67 net67 VGND VGND VPWR VPWR product[11] sky130_fd_sc_hd__clkbuf_4
XFILLER_0_31_498 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
Xoutput78 net78 VGND VGND VPWR VPWR product[21] sky130_fd_sc_hd__clkbuf_4
X_11071_ _04804_ _04806_ VGND VGND VPWR VPWR _04879_ sky130_fd_sc_hd__nor2_1
Xoutput89 net89 VGND VGND VPWR VPWR product[31] sky130_fd_sc_hd__buf_2
XTAP_TAPCELL_ROW_8_366 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
X_10022_ _03734_ _03735_ _03592_ _03595_ VGND VGND VPWR VPWR _03738_ sky130_fd_sc_hd__o211a_1
X_10924_ _04540_ _04637_ VGND VGND VPWR VPWR _04720_ sky130_fd_sc_hd__nand2_1
XPHY_EDGE_ROW_113_Right_113 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_0_86_638 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_0_85_126 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XTAP_TAPCELL_ROW_55_950 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_39_510 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_0_39_521 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_10855_ _04562_ _04564_ _04565_ VGND VGND VPWR VPWR _04644_ sky130_fd_sc_hd__nor3_1
XFILLER_0_85_148 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_39_554 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_0_94_682 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_66_340 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_54_502 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XFILLER_0_27_705 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_10786_ _04566_ _04567_ _04568_ VGND VGND VPWR VPWR _04569_ sky130_fd_sc_hd__and3_1
XFILLER_0_26_215 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
X_11407_ _05228_ _05240_ VGND VGND VPWR VPWR _05241_ sky130_fd_sc_hd__nand2_2
XFILLER_0_78_49 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_22_421 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_0_34_281 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_120_640 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
X_11338_ _05165_ _05166_ VGND VGND VPWR VPWR _05167_ sky130_fd_sc_hd__nand2_1
XFILLER_0_10_627 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_1_337 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
X_11269_ _05091_ _05092_ VGND VGND VPWR VPWR _05093_ sky130_fd_sc_hd__nor2_1
XFILLER_0_94_15 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
X_05830_ _00941_ _01072_ _00930_ VGND VGND VPWR VPWR _01716_ sky130_fd_sc_hd__a21o_1
XFILLER_0_118_77 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_0_89_432 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XPHY_EDGE_ROW_6_Left_128 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_0_27_75 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_89_454 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XTAP_TAPCELL_ROW_85_1322 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
X_07500_ _02065_ _00430_ _00983_ _00308_ VGND VGND VPWR VPWR _00984_ sky130_fd_sc_hd__a22oi_2
X_05761_ net26 VGND VGND VPWR VPWR _00963_ sky130_fd_sc_hd__clkbuf_4
XFILLER_0_89_476 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_76_104 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
X_08480_ _01181_ _02052_ VGND VGND VPWR VPWR _02053_ sky130_fd_sc_hd__nand2_2
XFILLER_0_76_148 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_07431_ _00711_ net157 _00856_ _00857_ VGND VGND VPWR VPWR _00909_ sky130_fd_sc_hd__o211a_1
XFILLER_0_92_619 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_0_85_671 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_9_459 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_9_437 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
X_07362_ _00830_ _00831_ _00833_ VGND VGND VPWR VPWR _00834_ sky130_fd_sc_hd__a21bo_1
XFILLER_0_72_332 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
X_09101_ _02729_ _02731_ VGND VGND VPWR VPWR _02733_ sky130_fd_sc_hd__xor2_4
X_06313_ _05382_ _05362_ _05443_ VGND VGND VPWR VPWR _05445_ sky130_fd_sc_hd__and3_1
XTAP_TAPCELL_ROW_33_677 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_72_365 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
X_07293_ _00752_ _00757_ VGND VGND VPWR VPWR _00758_ sky130_fd_sc_hd__or2_4
XFILLER_0_115_434 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
X_09032_ _02653_ _02654_ _02636_ VGND VGND VPWR VPWR _02657_ sky130_fd_sc_hd__a21oi_1
XFILLER_0_60_527 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_0_5_665 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
X_06244_ _05373_ _05375_ _05372_ VGND VGND VPWR VPWR _05376_ sky130_fd_sc_hd__a21o_2
XTAP_TAPCELL_ROW_96_1462 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_4_153 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_25_281 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
X_06175_ _04542_ VGND VGND VPWR VPWR _05308_ sky130_fd_sc_hd__clkbuf_8
XFILLER_0_102_139 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_7_41 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_4_197 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_0_13_487 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_0_111_673 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_110_150 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_40_284 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_09934_ _03621_ _03640_ _03641_ VGND VGND VPWR VPWR _03642_ sky130_fd_sc_hd__nor3_1
X_09865_ _02645_ _01903_ _03563_ _03564_ VGND VGND VPWR VPWR _03566_ sky130_fd_sc_hd__nand4_2
XTAP_TAPCELL_ROW_5_325 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
X_08816_ _02418_ _02419_ VGND VGND VPWR VPWR _02420_ sky130_fd_sc_hd__xor2_1
XFILLER_0_99_229 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
X_09796_ _01185_ VGND VGND VPWR VPWR _03491_ sky130_fd_sc_hd__buf_4
X_08747_ _02677_ _02345_ _02180_ _02179_ _02178_ VGND VGND VPWR VPWR _02346_ sky130_fd_sc_hd__a32o_1
X_05959_ _02208_ VGND VGND VPWR VPWR _03124_ sky130_fd_sc_hd__buf_4
XFILLER_0_68_649 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_68_638 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
X_08678_ _02268_ _02269_ VGND VGND VPWR VPWR _02270_ sky130_fd_sc_hd__or2b_2
XFILLER_0_95_446 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
X_07629_ _00989_ _00999_ _00998_ VGND VGND VPWR VPWR _01125_ sky130_fd_sc_hd__a21bo_1
X_10640_ _02976_ _02052_ VGND VGND VPWR VPWR _04411_ sky130_fd_sc_hd__nand2_1
XTAP_TAPCELL_ROW_105_1580 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_48_340 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
X_10571_ _04291_ _04293_ _04334_ _04335_ VGND VGND VPWR VPWR _04337_ sky130_fd_sc_hd__and4_1
XFILLER_0_36_557 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_91_685 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_90_184 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_0_63_398 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_0_8_492 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_0_121_415 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_0_90_195 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_51_549 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_0_31_262 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_102_651 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
X_11123_ _04855_ _04859_ _04935_ VGND VGND VPWR VPWR _04936_ sky130_fd_sc_hd__o21a_1
X_11054_ _04859_ _04860_ VGND VGND VPWR VPWR _04861_ sky130_fd_sc_hd__or2_1
X_10005_ _03584_ _03586_ VGND VGND VPWR VPWR _03719_ sky130_fd_sc_hd__nand2_1
XTAP_TAPCELL_ROW_108_1609 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_64_29 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_0_98_251 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
X_10907_ _04698_ _04699_ _04614_ _04616_ VGND VGND VPWR VPWR _04701_ sky130_fd_sc_hd__a211oi_1
XFILLER_0_59_649 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XTAP_TAPCELL_ROW_67_1096 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_27_502 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
X_10838_ _04623_ _04624_ _04525_ VGND VGND VPWR VPWR _04626_ sky130_fd_sc_hd__a21boi_1
XTAP_TAPCELL_ROW_80_1263 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_13_55 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_39_384 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_10769_ _04540_ _04550_ VGND VGND VPWR VPWR net107 sky130_fd_sc_hd__xnor2_4
XFILLER_0_89_15 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XTAP_TAPCELL_ROW_30_636 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_119_1749 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_54_365 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_2_613 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XTAP_TAPCELL_ROW_10_393 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_10_382 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_2_657 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_1_167 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_22_273 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
X_07980_ _01338_ _01346_ VGND VGND VPWR VPWR _01507_ sky130_fd_sc_hd__or2b_1
XFILLER_0_38_52 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
X_06931_ _00832_ _00854_ _00035_ _05635_ VGND VGND VPWR VPWR _00363_ sky130_fd_sc_hd__and4_1
X_09650_ _00987_ _00345_ _01610_ _00343_ VGND VGND VPWR VPWR _03331_ sky130_fd_sc_hd__a22o_1
XFILLER_0_38_85 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_06862_ _02732_ _05342_ net37 _02197_ VGND VGND VPWR VPWR _00288_ sky130_fd_sc_hd__a22o_1
X_08601_ _03310_ _03321_ _01987_ _02185_ VGND VGND VPWR VPWR _02187_ sky130_fd_sc_hd__nand4_1
X_09581_ _02949_ _02952_ _03115_ _03116_ VGND VGND VPWR VPWR _03256_ sky130_fd_sc_hd__a211oi_2
X_06793_ _00217_ _00218_ _00133_ _00134_ VGND VGND VPWR VPWR _00220_ sky130_fd_sc_hd__a211o_1
XTAP_TAPCELL_ROW_38_736 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
X_05813_ net60 _00537_ _01508_ net1 VGND VGND VPWR VPWR _01530_ sky130_fd_sc_hd__a22o_1
X_08532_ _00546_ _02108_ _00411_ _02110_ VGND VGND VPWR VPWR _02111_ sky130_fd_sc_hd__nand4_2
X_05744_ _00613_ _00734_ VGND VGND VPWR VPWR _00777_ sky130_fd_sc_hd__xor2_1
XFILLER_0_49_104 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XFILLER_0_77_457 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
X_08463_ _01552_ _00668_ _01852_ VGND VGND VPWR VPWR _02035_ sky130_fd_sc_hd__and3_1
XFILLER_0_58_660 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
X_07414_ _00735_ _00867_ _00868_ VGND VGND VPWR VPWR _00890_ sky130_fd_sc_hd__nand3_1
XTAP_TAPCELL_ROW_18_482 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_18_493 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
X_08394_ _01941_ _01958_ _01959_ VGND VGND VPWR VPWR _01960_ sky130_fd_sc_hd__nand3_2
XFILLER_0_9_256 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_0_57_192 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_0_18_557 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
X_07345_ _00792_ _00793_ _00813_ _00814_ VGND VGND VPWR VPWR _00815_ sky130_fd_sc_hd__a211oi_4
XFILLER_0_73_685 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
X_07276_ _00617_ _00736_ VGND VGND VPWR VPWR _00739_ sky130_fd_sc_hd__nor2_1
XFILLER_0_33_505 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_103_415 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
X_09015_ _00798_ _01604_ _02495_ _02494_ _01606_ VGND VGND VPWR VPWR _02638_ sky130_fd_sc_hd__a32o_1
XFILLER_0_60_357 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_60_346 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
X_06227_ _05138_ _05159_ _05358_ _05359_ VGND VGND VPWR VPWR _05360_ sky130_fd_sc_hd__a211oi_2
XFILLER_0_79_81 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_06158_ _04249_ _04455_ _05266_ _05276_ VGND VGND VPWR VPWR _05285_ sky130_fd_sc_hd__a22o_1
X_06089_ net2 VGND VGND VPWR VPWR _04542_ sky130_fd_sc_hd__clkbuf_4
X_09917_ _03426_ _03436_ _03435_ VGND VGND VPWR VPWR _03623_ sky130_fd_sc_hd__a21o_1
XFILLER_0_95_91 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_09848_ _03543_ _03544_ _03545_ VGND VGND VPWR VPWR _03547_ sky130_fd_sc_hd__nand3_1
X_09779_ _03470_ _03471_ VGND VGND VPWR VPWR _03472_ sky130_fd_sc_hd__or2_2
XFILLER_0_95_254 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_0_56_608 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_0_95_287 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
X_10623_ _04373_ _04391_ VGND VGND VPWR VPWR _04393_ sky130_fd_sc_hd__and2_1
XFILLER_0_106_231 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
X_10554_ _03574_ _03489_ _04315_ _04316_ VGND VGND VPWR VPWR _04318_ sky130_fd_sc_hd__nand4_2
XFILLER_0_36_365 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_121_223 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
X_10485_ _04241_ _04242_ VGND VGND VPWR VPWR _04243_ sky130_fd_sc_hd__nor2_1
XFILLER_0_121_245 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
X_11106_ _04915_ _04916_ VGND VGND VPWR VPWR _04917_ sky130_fd_sc_hd__xor2_1
XPHY_EDGE_ROW_87_Left_209 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
X_11037_ _04840_ _04841_ VGND VGND VPWR VPWR _04842_ sky130_fd_sc_hd__nor2_2
XTAP_TAPCELL_ROW_69_1125 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XPHY_EDGE_ROW_96_Left_218 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_0_86_243 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XFILLER_0_46_107 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XTAP_TAPCELL_ROW_15_452 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_27_310 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_0_55_641 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XTAP_TAPCELL_ROW_43_794 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_55_696 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_15_505 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_07130_ _00577_ _00578_ _00555_ VGND VGND VPWR VPWR _00580_ sky130_fd_sc_hd__a21oi_2
XFILLER_0_70_633 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_15_538 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_15_549 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_0_2_421 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
X_07061_ _01552_ net9 _00501_ _00502_ VGND VGND VPWR VPWR _00505_ sky130_fd_sc_hd__o2bb2a_1
XTAP_TAPCELL_ROW_93_1421 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_23_571 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
X_06012_ _03681_ _03692_ VGND VGND VPWR VPWR _03703_ sky130_fd_sc_hd__or2_1
XFILLER_0_50_390 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_49_84 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
X_07963_ _01176_ _01319_ _01328_ VGND VGND VPWR VPWR _01489_ sky130_fd_sc_hd__a21bo_1
X_09702_ _03278_ _03280_ VGND VGND VPWR VPWR _03388_ sky130_fd_sc_hd__nor2_1
X_06914_ _00343_ VGND VGND VPWR VPWR _00344_ sky130_fd_sc_hd__buf_4
XFILLER_0_4_53 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
X_07894_ _01414_ _05655_ _01410_ _01412_ VGND VGND VPWR VPWR _01415_ sky130_fd_sc_hd__a22o_1
X_09633_ _03309_ _03311_ _03289_ VGND VGND VPWR VPWR _03313_ sky130_fd_sc_hd__o21a_1
XFILLER_0_65_61 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_4_97 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
X_06845_ net34 net64 _03004_ _04063_ VGND VGND VPWR VPWR _00271_ sky130_fd_sc_hd__and4_1
XFILLER_0_97_519 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
X_09564_ net20 VGND VGND VPWR VPWR _03237_ sky130_fd_sc_hd__clkbuf_4
X_08515_ _02090_ _02091_ VGND VGND VPWR VPWR _02092_ sky130_fd_sc_hd__xor2_2
X_06776_ _00199_ _00200_ _00201_ VGND VGND VPWR VPWR _00203_ sky130_fd_sc_hd__a21o_1
X_09495_ _03159_ _03160_ _03145_ VGND VGND VPWR VPWR _03162_ sky130_fd_sc_hd__a21o_1
X_05727_ _00526_ _00559_ _00581_ _00548_ VGND VGND VPWR VPWR _00592_ sky130_fd_sc_hd__a22o_1
XFILLER_0_92_202 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XFILLER_0_77_287 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_0_65_427 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
X_08446_ _02014_ _02015_ _01830_ net168 VGND VGND VPWR VPWR _02017_ sky130_fd_sc_hd__a211oi_2
X_08377_ _00798_ _01582_ VGND VGND VPWR VPWR _01942_ sky130_fd_sc_hd__nand2_1
XFILLER_0_61_622 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
X_07328_ _05030_ _05463_ _05552_ _03834_ VGND VGND VPWR VPWR _00796_ sky130_fd_sc_hd__a22o_1
XFILLER_0_46_696 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_0_104_713 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_0_45_184 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
X_07259_ _00718_ _00719_ _00586_ net170 VGND VGND VPWR VPWR _00721_ sky130_fd_sc_hd__a211oi_2
XFILLER_0_5_270 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
X_10270_ _03997_ _04006_ _04007_ VGND VGND VPWR VPWR _04008_ sky130_fd_sc_hd__and3_2
XFILLER_0_14_571 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_0_14_593 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_68_232 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_68_221 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_0_68_265 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XTAP_TAPCELL_ROW_64_1066 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_12_411 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
X_10606_ _02174_ VGND VGND VPWR VPWR _04374_ sky130_fd_sc_hd__clkbuf_4
XFILLER_0_4_719 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_3_207 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XTAP_TAPCELL_ROW_40_764 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_116_1708 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
X_10537_ _04296_ _04297_ _02134_ _01671_ VGND VGND VPWR VPWR _04299_ sky130_fd_sc_hd__and4bb_1
XFILLER_0_24_357 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
X_10468_ _04221_ _04222_ _04207_ _04117_ VGND VGND VPWR VPWR _04224_ sky130_fd_sc_hd__o211a_1
XFILLER_0_20_530 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
X_10399_ _03672_ _04145_ _04148_ VGND VGND VPWR VPWR _04149_ sky130_fd_sc_hd__o21ba_1
XTAP_TAPCELL_ROW_75_1195 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_20_563 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
X_06630_ _00056_ _00057_ VGND VGND VPWR VPWR _00058_ sky130_fd_sc_hd__and2b_1
XTAP_TAPCELL_ROW_48_864 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_87_552 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_06561_ _02677_ _05689_ VGND VGND VPWR VPWR _05690_ sky130_fd_sc_hd__nand2_1
XFILLER_0_35_86 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_87_596 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
X_09280_ _04900_ _02041_ _02756_ _02755_ _01354_ VGND VGND VPWR VPWR _02927_ sky130_fd_sc_hd__a32o_1
X_08300_ _01247_ _01856_ VGND VGND VPWR VPWR _01857_ sky130_fd_sc_hd__nand2_1
X_06492_ _05529_ _05537_ _05621_ VGND VGND VPWR VPWR _05622_ sky130_fd_sc_hd__o21ai_2
XFILLER_0_47_438 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_0_7_513 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
X_08231_ _01780_ _01781_ VGND VGND VPWR VPWR _01783_ sky130_fd_sc_hd__nand2_2
XFILLER_0_47_449 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_117_337 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_0_74_279 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_0_27_140 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
X_08162_ _01703_ _01704_ _01687_ _01688_ VGND VGND VPWR VPWR _01707_ sky130_fd_sc_hd__o211a_1
XFILLER_0_113_510 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
X_08093_ _01448_ _01451_ _01450_ VGND VGND VPWR VPWR _01632_ sky130_fd_sc_hd__a21bo_1
X_07113_ _00558_ _00560_ _00561_ VGND VGND VPWR VPWR _00562_ sky130_fd_sc_hd__a21bo_1
X_07044_ _00493_ _00485_ _00235_ _00450_ VGND VGND VPWR VPWR _00486_ sky130_fd_sc_hd__a22o_1
XFILLER_0_42_165 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XFILLER_0_62_3 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
X_08995_ _02576_ _02615_ VGND VGND VPWR VPWR _02616_ sky130_fd_sc_hd__xnor2_4
XFILLER_0_76_93 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
X_07946_ _01403_ _01404_ _01469_ _01470_ VGND VGND VPWR VPWR _01471_ sky130_fd_sc_hd__and4bb_1
X_07877_ _01228_ _01230_ _01395_ VGND VGND VPWR VPWR _01396_ sky130_fd_sc_hd__a21oi_2
XFILLER_0_97_349 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
X_09616_ _03006_ VGND VGND VPWR VPWR _03294_ sky130_fd_sc_hd__clkbuf_4
X_06828_ _00241_ _00253_ VGND VGND VPWR VPWR _00254_ sky130_fd_sc_hd__xnor2_1
X_09547_ _03216_ _03218_ VGND VGND VPWR VPWR _03219_ sky130_fd_sc_hd__xnor2_4
X_06759_ _00178_ _00185_ VGND VGND VPWR VPWR _00186_ sky130_fd_sc_hd__xor2_2
XFILLER_0_108_315 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XTAP_TAPCELL_ROW_100_1509 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
X_09478_ _03140_ _03141_ _03136_ _03137_ VGND VGND VPWR VPWR _03143_ sky130_fd_sc_hd__a211o_1
XFILLER_0_65_257 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_19_685 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
X_08429_ _01995_ _01996_ _01997_ VGND VGND VPWR VPWR _01998_ sky130_fd_sc_hd__nand3_1
X_11440_ _04873_ _04724_ _05259_ _05262_ VGND VGND VPWR VPWR _05275_ sky130_fd_sc_hd__a211o_1
XFILLER_0_80_238 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
X_11371_ _05199_ _05200_ VGND VGND VPWR VPWR _05203_ sky130_fd_sc_hd__nand2_1
XFILLER_0_34_666 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
X_10322_ _00344_ _00346_ _03006_ _03012_ VGND VGND VPWR VPWR _04065_ sky130_fd_sc_hd__and4_1
XFILLER_0_21_305 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_33_165 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
X_10253_ _03988_ _03989_ VGND VGND VPWR VPWR _03990_ sky130_fd_sc_hd__xnor2_1
XTAP_TAPCELL_ROW_111_1649 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
X_10184_ _03913_ _03914_ VGND VGND VPWR VPWR _03915_ sky130_fd_sc_hd__nand2_1
XTAP_TAPCELL_ROW_45_823 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_84_533 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_29_449 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_0_84_599 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XTAP_TAPCELL_ROW_25_580 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_21_55 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_25_644 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_0_97_15 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XTAP_TAPCELL_ROW_77_1224 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_12_327 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_12_349 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_110_557 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_20_371 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
X_07800_ _01309_ _01310_ _01204_ VGND VGND VPWR VPWR _01312_ sky130_fd_sc_hd__o21ai_1
X_08780_ _02207_ _02209_ _02007_ _02085_ VGND VGND VPWR VPWR _02382_ sky130_fd_sc_hd__a211oi_1
X_07731_ _01233_ _01234_ _01219_ VGND VGND VPWR VPWR _01237_ sky130_fd_sc_hd__o21a_1
X_05992_ _03452_ _03463_ _03474_ VGND VGND VPWR VPWR _03485_ sky130_fd_sc_hd__and3_1
XFILLER_0_46_85 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XTAP_TAPCELL_ROW_88_1364 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_79_349 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
X_07662_ _01093_ _01095_ _01158_ _01159_ VGND VGND VPWR VPWR _01162_ sky130_fd_sc_hd__a2bb2o_1
XFILLER_0_1_21 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
X_09401_ _03056_ _03058_ VGND VGND VPWR VPWR _03060_ sky130_fd_sc_hd__xnor2_2
X_06613_ net9 VGND VGND VPWR VPWR _00041_ sky130_fd_sc_hd__buf_4
X_07593_ _00928_ _00936_ _00935_ VGND VGND VPWR VPWR _01086_ sky130_fd_sc_hd__a21bo_1
X_09332_ _02843_ VGND VGND VPWR VPWR _02984_ sky130_fd_sc_hd__buf_4
X_06544_ _05584_ _05604_ _05605_ VGND VGND VPWR VPWR _05673_ sky130_fd_sc_hd__nor3_2
XFILLER_0_47_213 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_47_235 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_118_657 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_75_566 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
X_09263_ _02734_ _02736_ VGND VGND VPWR VPWR _02910_ sky130_fd_sc_hd__nor2_1
XFILLER_0_63_717 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
X_06475_ _05601_ _05602_ _05603_ VGND VGND VPWR VPWR _05605_ sky130_fd_sc_hd__a21oi_2
XFILLER_0_28_460 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
X_09194_ _02832_ _02833_ VGND VGND VPWR VPWR _02834_ sky130_fd_sc_hd__nor2_2
XFILLER_0_62_249 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
X_08214_ _05552_ _05693_ _00094_ _05463_ VGND VGND VPWR VPWR _01764_ sky130_fd_sc_hd__a22o_1
XFILLER_0_7_343 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_28_471 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_0_7_387 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
X_08145_ _01506_ _01507_ _01520_ _01521_ VGND VGND VPWR VPWR _01688_ sky130_fd_sc_hd__a211o_1
XFILLER_0_102_90 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XFILLER_0_16_699 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_31_614 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XFILLER_0_113_373 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_101_502 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XFILLER_0_31_669 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
X_08076_ _05410_ _01610_ _01611_ _01612_ VGND VGND VPWR VPWR _01613_ sky130_fd_sc_hd__nand4_2
X_07027_ _05628_ _00467_ VGND VGND VPWR VPWR _00468_ sky130_fd_sc_hd__or2b_1
XFILLER_0_30_157 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_0_11_393 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
X_08978_ _05589_ _00750_ _02452_ _02451_ _00610_ VGND VGND VPWR VPWR _02597_ sky130_fd_sc_hd__a32o_1
X_07929_ _01450_ _01451_ _01448_ VGND VGND VPWR VPWR _01453_ sky130_fd_sc_hd__a21o_1
XFILLER_0_98_658 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
X_10940_ _00237_ _03807_ _04735_ VGND VGND VPWR VPWR _04736_ sky130_fd_sc_hd__a21o_1
XTAP_TAPCELL_ROW_3_297 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
X_10871_ _01620_ _03237_ _01853_ _01441_ VGND VGND VPWR VPWR _04662_ sky130_fd_sc_hd__a22o_1
XFILLER_0_38_213 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_0_66_533 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XTAP_TAPCELL_ROW_61_1025 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_81_558 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XFILLER_0_53_249 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
X_11423_ _05033_ _04873_ _05195_ VGND VGND VPWR VPWR _05258_ sky130_fd_sc_hd__a21oi_1
XTAP_TAPCELL_ROW_50_892 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_50_881 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XANTENNA_9 _01620_ VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
X_11354_ _05183_ _05184_ VGND VGND VPWR VPWR _05185_ sky130_fd_sc_hd__nand2_1
XFILLER_0_61_293 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_21_113 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_0_22_669 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
X_11285_ _05046_ _05048_ _05093_ VGND VGND VPWR VPWR _05110_ sky130_fd_sc_hd__and3_1
X_10305_ _04045_ _03944_ VGND VGND VPWR VPWR _04046_ sky130_fd_sc_hd__or2_1
X_10236_ _03811_ _03969_ _03970_ VGND VGND VPWR VPWR _03971_ sky130_fd_sc_hd__nor3_4
XTAP_TAPCELL_ROW_72_1165 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
X_10167_ _03893_ _03894_ _03875_ VGND VGND VPWR VPWR _03896_ sky130_fd_sc_hd__o21ai_2
X_10098_ _03818_ _03819_ VGND VGND VPWR VPWR _03820_ sky130_fd_sc_hd__and2_1
XFILLER_0_107_57 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_89_658 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_88_157 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XTAP_TAPCELL_ROW_58_992 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_58_981 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_69_393 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_0_29_235 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_32_21 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XTAP_TAPCELL_ROW_83_1294 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_72_514 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XTAP_TAPCELL_ROW_20_509 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
X_06260_ _05390_ _05391_ VGND VGND VPWR VPWR _05392_ sky130_fd_sc_hd__nor2_1
XFILLER_0_4_346 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_25_463 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
X_06191_ _05300_ _05323_ VGND VGND VPWR VPWR _05324_ sky130_fd_sc_hd__xnor2_1
XFILLER_0_13_669 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_0_40_433 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
X_09950_ _03387_ _03522_ _03521_ VGND VGND VPWR VPWR _03659_ sky130_fd_sc_hd__a21o_1
X_08901_ _02511_ _02512_ VGND VGND VPWR VPWR _02514_ sky130_fd_sc_hd__and2_2
XFILLER_0_0_541 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
X_09881_ _02640_ _02641_ _02351_ _01977_ VGND VGND VPWR VPWR _03584_ sky130_fd_sc_hd__nand4_1
XFILLER_0_57_62 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_57_51 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
X_08832_ _02434_ _02435_ _02428_ VGND VGND VPWR VPWR _02438_ sky130_fd_sc_hd__a21o_1
X_05975_ _01497_ _03288_ VGND VGND VPWR VPWR _03299_ sky130_fd_sc_hd__and2_1
X_08763_ _00843_ _01978_ net56 net57 VGND VGND VPWR VPWR _02364_ sky130_fd_sc_hd__and4_1
XFILLER_0_79_113 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XTAP_TAPCELL_ROW_28_609 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
X_07714_ _01216_ _01217_ VGND VGND VPWR VPWR _01218_ sky130_fd_sc_hd__xor2_4
X_08694_ _00187_ _00089_ _01379_ _00236_ VGND VGND VPWR VPWR _02288_ sky130_fd_sc_hd__nand4_1
XTAP_TAPCELL_ROW_0_245 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_95_617 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XFILLER_0_67_308 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XTAP_TAPCELL_ROW_0_256 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_0_267 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
X_07645_ _05310_ _00086_ _01141_ _01142_ VGND VGND VPWR VPWR _01143_ sky130_fd_sc_hd__nand4_2
X_07576_ _04726_ _00485_ _00349_ _04878_ VGND VGND VPWR VPWR _01067_ sky130_fd_sc_hd__a22o_1
XFILLER_0_48_533 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
X_09315_ _00087_ _00421_ _01060_ VGND VGND VPWR VPWR _02966_ sky130_fd_sc_hd__and3_1
XFILLER_0_63_503 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
X_06527_ _05655_ VGND VGND VPWR VPWR _05656_ sky130_fd_sc_hd__buf_4
XFILLER_0_35_205 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_0_90_300 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_63_547 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_0_63_525 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
X_09246_ _02714_ _02713_ VGND VGND VPWR VPWR _02891_ sky130_fd_sc_hd__and2b_1
X_06458_ _05585_ _05586_ _05587_ VGND VGND VPWR VPWR _05588_ sky130_fd_sc_hd__a21bo_1
XFILLER_0_48_599 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_16_441 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_35_249 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_105_159 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_90_399 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_90_377 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
X_09177_ _02110_ _01603_ _02320_ _02108_ VGND VGND VPWR VPWR _02815_ sky130_fd_sc_hd__a22o_1
X_06389_ _05439_ net150 _05518_ _05519_ VGND VGND VPWR VPWR _05520_ sky130_fd_sc_hd__o211ai_2
X_08128_ _01524_ _01526_ VGND VGND VPWR VPWR _01669_ sky130_fd_sc_hd__and2b_1
XFILLER_0_120_129 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_0_114_693 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_0_31_477 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
X_08059_ _01418_ _01419_ VGND VGND VPWR VPWR _01594_ sky130_fd_sc_hd__or2_1
X_11070_ _04874_ _04876_ VGND VGND VPWR VPWR _04877_ sky130_fd_sc_hd__and2_1
XFILLER_0_101_343 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
X_10021_ _03592_ _03595_ _03734_ _03735_ VGND VGND VPWR VPWR _03737_ sky130_fd_sc_hd__a211oi_4
XFILLER_0_101_387 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_0_101_376 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XTAP_TAPCELL_ROW_8_367 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_8_356 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
Xoutput79 net79 VGND VGND VPWR VPWR product[22] sky130_fd_sc_hd__clkbuf_4
Xoutput68 net68 VGND VGND VPWR VPWR product[12] sky130_fd_sc_hd__clkbuf_4
XFILLER_0_98_411 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_10923_ _04717_ _04718_ VGND VGND VPWR VPWR _04719_ sky130_fd_sc_hd__nor2_1
XFILLER_0_98_477 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XTAP_TAPCELL_ROW_55_951 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XPHY_EDGE_ROW_19_Right_19 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
X_10854_ _00237_ _00762_ _02864_ _02866_ VGND VGND VPWR VPWR _04643_ sky130_fd_sc_hd__nand4_2
XFILLER_0_66_363 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_94_694 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
X_10785_ _04469_ _04471_ _04470_ VGND VGND VPWR VPWR _04568_ sky130_fd_sc_hd__a21bo_1
XFILLER_0_81_322 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_66_385 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_0_26_227 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XFILLER_0_26_238 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_54_558 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_81_399 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_0_112_619 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
X_11406_ _05239_ VGND VGND VPWR VPWR _05240_ sky130_fd_sc_hd__inv_2
XFILLER_0_105_671 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
X_11337_ _04732_ _05033_ _05164_ VGND VGND VPWR VPWR _05166_ sky130_fd_sc_hd__nand3_1
XFILLER_0_1_349 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_22_477 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XPHY_EDGE_ROW_28_Right_28 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_0_10_639 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
X_11268_ _05088_ _05090_ VGND VGND VPWR VPWR _05092_ sky130_fd_sc_hd__nor2_1
XFILLER_0_94_27 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
X_11199_ _04949_ _04955_ _05015_ VGND VGND VPWR VPWR _05017_ sky130_fd_sc_hd__nor3_1
X_10219_ _01605_ _00609_ _01060_ VGND VGND VPWR VPWR _03952_ sky130_fd_sc_hd__and3_1
X_05760_ _00930_ _00941_ VGND VGND VPWR VPWR _00952_ sky130_fd_sc_hd__and2b_1
XTAP_TAPCELL_ROW_85_1323 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XPHY_EDGE_ROW_37_Right_37 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_0_77_617 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_43_31 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_76_127 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_0_69_190 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
X_07430_ _00905_ _00906_ VGND VGND VPWR VPWR _00907_ sky130_fd_sc_hd__nor2_1
XFILLER_0_9_449 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
X_07361_ _01607_ net43 net45 _00297_ VGND VGND VPWR VPWR _00833_ sky130_fd_sc_hd__a22o_1
XFILLER_0_43_97 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_45_503 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
X_09100_ _02405_ _02559_ _02730_ VGND VGND VPWR VPWR _02731_ sky130_fd_sc_hd__a21boi_4
X_06312_ _05382_ _05362_ _05443_ VGND VGND VPWR VPWR _05444_ sky130_fd_sc_hd__a21oi_1
XTAP_TAPCELL_ROW_33_678 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
X_07292_ _01760_ _00754_ _00746_ _00756_ VGND VGND VPWR VPWR _00757_ sky130_fd_sc_hd__o2bb2a_1
X_09031_ _02636_ _02653_ _02654_ VGND VGND VPWR VPWR _02656_ sky130_fd_sc_hd__and3_1
XFILLER_0_115_457 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XFILLER_0_72_377 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_4_121 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
X_06243_ _05374_ _05375_ VGND VGND VPWR VPWR net68 sky130_fd_sc_hd__xnor2_1
XPHY_EDGE_ROW_46_Right_46 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XPHY_EDGE_ROW_107_Left_229 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_0_4_165 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
X_06174_ _04520_ VGND VGND VPWR VPWR _05307_ sky130_fd_sc_hd__clkbuf_8
XTAP_TAPCELL_ROW_96_1463 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_7_53 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_0_111_641 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_0_13_499 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_0_111_685 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
X_09933_ _03637_ _03639_ _03501_ _03622_ VGND VGND VPWR VPWR _03641_ sky130_fd_sc_hd__a211oi_2
XFILLER_0_0_382 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
X_09864_ _02645_ _02281_ _03563_ _03564_ VGND VGND VPWR VPWR _03565_ sky130_fd_sc_hd__a22o_1
XTAP_TAPCELL_ROW_5_326 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
X_08815_ _00515_ _02045_ VGND VGND VPWR VPWR _02419_ sky130_fd_sc_hd__nand2_1
XPHY_EDGE_ROW_116_Left_238 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
X_09795_ _00893_ VGND VGND VPWR VPWR _03490_ sky130_fd_sc_hd__buf_4
XPHY_EDGE_ROW_55_Right_55 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
X_08746_ _01284_ VGND VGND VPWR VPWR _02345_ sky130_fd_sc_hd__buf_4
X_05958_ _00581_ _00679_ _01771_ _02219_ VGND VGND VPWR VPWR _03113_ sky130_fd_sc_hd__and4_1
X_08677_ _02266_ _02267_ _02067_ _02069_ VGND VGND VPWR VPWR _02269_ sky130_fd_sc_hd__o211ai_1
X_05889_ _02339_ _02350_ VGND VGND VPWR VPWR _02361_ sky130_fd_sc_hd__and2b_1
XTAP_TAPCELL_ROW_52_910 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
X_07628_ _01121_ _01122_ _01112_ VGND VGND VPWR VPWR _01124_ sky130_fd_sc_hd__a21o_1
XTAP_TAPCELL_ROW_105_1570 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_48_363 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
X_07559_ _01046_ _01047_ VGND VGND VPWR VPWR _01048_ sky130_fd_sc_hd__nand2_1
XFILLER_0_36_525 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
X_10570_ _04332_ _04333_ _04294_ VGND VGND VPWR VPWR _04335_ sky130_fd_sc_hd__a21o_1
XFILLER_0_118_251 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XPHY_EDGE_ROW_64_Right_64 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_0_63_333 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_0_24_709 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_36_569 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_106_435 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_91_697 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
X_09229_ _02703_ _02704_ _02706_ VGND VGND VPWR VPWR _02872_ sky130_fd_sc_hd__a21bo_1
XFILLER_0_51_528 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_121_449 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_31_252 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_0_102_663 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_31_274 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
X_11122_ _04932_ _04934_ VGND VGND VPWR VPWR _04935_ sky130_fd_sc_hd__and2_1
X_11053_ _04798_ _04799_ _04858_ VGND VGND VPWR VPWR _04860_ sky130_fd_sc_hd__and3_1
X_10004_ _03707_ _03717_ VGND VGND VPWR VPWR _03718_ sky130_fd_sc_hd__xnor2_2
XPHY_EDGE_ROW_73_Right_73 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_0_59_617 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
X_10906_ _04614_ _04616_ _04698_ _04699_ VGND VGND VPWR VPWR _04700_ sky130_fd_sc_hd__o211a_1
XFILLER_0_80_29 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_0_58_116 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XTAP_TAPCELL_ROW_67_1097 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_39_330 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
X_10837_ _04525_ _04623_ _04624_ VGND VGND VPWR VPWR _04625_ sky130_fd_sc_hd__and3b_1
XPHY_EDGE_ROW_82_Right_82 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_0_54_322 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_0_27_525 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
X_10768_ _04544_ _04549_ VGND VGND VPWR VPWR _04550_ sky130_fd_sc_hd__and2_2
XTAP_TAPCELL_ROW_80_1264 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_54_333 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_0_15_709 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_0_27_547 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XTAP_TAPCELL_ROW_30_637 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_89_27 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
X_10699_ _04467_ _04468_ _04472_ _04473_ VGND VGND VPWR VPWR _04474_ sky130_fd_sc_hd__o211a_1
XTAP_TAPCELL_ROW_10_383 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_1_113 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_2_625 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_2_669 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XPHY_EDGE_ROW_91_Right_91 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
X_06930_ _00244_ _00246_ VGND VGND VPWR VPWR _00361_ sky130_fd_sc_hd__or2_2
XFILLER_0_38_64 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
X_06861_ _02721_ _03649_ _05342_ net37 VGND VGND VPWR VPWR _00287_ sky130_fd_sc_hd__and4_1
X_08600_ net57 VGND VGND VPWR VPWR _02185_ sky130_fd_sc_hd__clkbuf_4
X_09580_ _03252_ _03253_ VGND VGND VPWR VPWR _03254_ sky130_fd_sc_hd__xor2_4
X_06792_ _00133_ _00134_ _00217_ _00218_ VGND VGND VPWR VPWR _00219_ sky130_fd_sc_hd__o211ai_4
XTAP_TAPCELL_ROW_38_737 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
X_05812_ _00624_ _00832_ _00537_ _01508_ VGND VGND VPWR VPWR _01519_ sky130_fd_sc_hd__nand4_4
X_08531_ _00139_ VGND VGND VPWR VPWR _02110_ sky130_fd_sc_hd__clkbuf_4
X_05743_ _00417_ _00755_ VGND VGND VPWR VPWR _00766_ sky130_fd_sc_hd__nor2_1
XFILLER_0_77_447 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
X_08462_ _01859_ _01860_ VGND VGND VPWR VPWR _02034_ sky130_fd_sc_hd__or2b_1
XFILLER_0_54_85 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_92_406 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
X_07413_ _00870_ _00872_ VGND VGND VPWR VPWR _00889_ sky130_fd_sc_hd__nand2_2
XTAP_TAPCELL_ROW_18_483 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_58_672 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
X_08393_ _01955_ _01957_ _01947_ VGND VGND VPWR VPWR _01959_ sky130_fd_sc_hd__a21o_1
XFILLER_0_9_279 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_18_569 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_07344_ _00811_ _00812_ _00794_ VGND VGND VPWR VPWR _00814_ sky130_fd_sc_hd__a21oi_2
XFILLER_0_115_221 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_0_92_3 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_73_697 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
X_07275_ _00737_ VGND VGND VPWR VPWR _00738_ sky130_fd_sc_hd__clkbuf_2
XFILLER_0_33_517 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
X_09014_ _02472_ _02474_ VGND VGND VPWR VPWR _02637_ sky130_fd_sc_hd__nand2_1
X_06226_ _05355_ _05356_ _05334_ VGND VGND VPWR VPWR _05359_ sky130_fd_sc_hd__a21oi_1
XFILLER_0_13_252 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
X_06157_ _05245_ _05255_ _04161_ _04465_ VGND VGND VPWR VPWR _05276_ sky130_fd_sc_hd__o211ai_4
XFILLER_0_0_9 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
X_06088_ _04520_ VGND VGND VPWR VPWR _04531_ sky130_fd_sc_hd__buf_4
X_09916_ _03264_ _03267_ _03501_ _03502_ VGND VGND VPWR VPWR _03622_ sky130_fd_sc_hd__a211oi_2
X_09847_ _03543_ _03544_ _03545_ VGND VGND VPWR VPWR _03546_ sky130_fd_sc_hd__a21o_1
X_09778_ _03468_ _03469_ _00283_ _01671_ VGND VGND VPWR VPWR _03471_ sky130_fd_sc_hd__and4bb_1
XFILLER_0_96_701 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
X_08729_ _05656_ _02325_ VGND VGND VPWR VPWR _02326_ sky130_fd_sc_hd__nand2_1
XFILLER_0_68_403 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
X_10622_ _04373_ _04391_ VGND VGND VPWR VPWR _04392_ sky130_fd_sc_hd__nor2_1
XFILLER_0_64_642 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
X_10553_ _02321_ _02947_ _04315_ _04316_ VGND VGND VPWR VPWR _04317_ sky130_fd_sc_hd__a22o_1
XFILLER_0_36_377 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XFILLER_0_106_243 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_10484_ _04239_ _04240_ _04151_ _04152_ VGND VGND VPWR VPWR _04242_ sky130_fd_sc_hd__o211a_1
XFILLER_0_20_701 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_32_561 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_11105_ _03827_ _02227_ VGND VGND VPWR VPWR _04916_ sky130_fd_sc_hd__nand2_1
X_11036_ _04828_ _04829_ _04839_ VGND VGND VPWR VPWR _04841_ sky130_fd_sc_hd__a21oi_2
XTAP_TAPCELL_ROW_69_1126 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_99_561 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_59_447 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_115_57 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XTAP_TAPCELL_ROW_15_453 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_7_717 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XTAP_TAPCELL_ROW_43_795 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_55_664 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XFILLER_0_54_141 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XFILLER_0_82_483 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_40_65 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
X_07060_ _00501_ _00502_ _01552_ net9 VGND VGND VPWR VPWR _00503_ sky130_fd_sc_hd__and4bb_1
X_06011_ _00450_ _02764_ _03660_ _03671_ VGND VGND VPWR VPWR _03692_ sky130_fd_sc_hd__o2bb2a_1
XTAP_TAPCELL_ROW_93_1422 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_2_477 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_0_49_96 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
X_09701_ _04748_ _02230_ _03252_ _03385_ VGND VGND VPWR VPWR _03387_ sky130_fd_sc_hd__a31o_4
X_07962_ _01487_ VGND VGND VPWR VPWR _01488_ sky130_fd_sc_hd__inv_2
X_06913_ net10 VGND VGND VPWR VPWR _00343_ sky130_fd_sc_hd__clkbuf_4
X_07893_ _05423_ VGND VGND VPWR VPWR _01414_ sky130_fd_sc_hd__buf_4
XFILLER_0_4_65 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
X_09632_ _03289_ _03309_ _03311_ VGND VGND VPWR VPWR _03312_ sky130_fd_sc_hd__nor3_2
XFILLER_0_65_73 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_06844_ _04922_ _00269_ VGND VGND VPWR VPWR _00270_ sky130_fd_sc_hd__nand2_1
XFILLER_0_78_701 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
X_09563_ _03100_ _03119_ _03120_ VGND VGND VPWR VPWR _03236_ sky130_fd_sc_hd__or3_1
X_08514_ _05574_ _01903_ VGND VGND VPWR VPWR _02091_ sky130_fd_sc_hd__nand2_1
X_06775_ _00199_ _00200_ _00201_ VGND VGND VPWR VPWR _00202_ sky130_fd_sc_hd__nand3_1
X_09494_ _03145_ _03159_ _03160_ VGND VGND VPWR VPWR _03161_ sky130_fd_sc_hd__nand3_2
X_05726_ net58 VGND VGND VPWR VPWR _00581_ sky130_fd_sc_hd__buf_2
XTAP_TAPCELL_ROW_102_1540 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
X_08445_ _01830_ _01846_ _02014_ _02015_ VGND VGND VPWR VPWR _02016_ sky130_fd_sc_hd__o211a_2
X_08376_ _01785_ _01792_ _01791_ VGND VGND VPWR VPWR _01941_ sky130_fd_sc_hd__a21o_1
X_07327_ _04998_ _05030_ _05552_ VGND VGND VPWR VPWR _00795_ sky130_fd_sc_hd__and3_1
XFILLER_0_116_541 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_0_61_667 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
X_07258_ _00586_ net171 _00718_ _00719_ VGND VGND VPWR VPWR _00720_ sky130_fd_sc_hd__o211a_2
XFILLER_0_103_246 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
X_07189_ _00641_ _00642_ _00629_ VGND VGND VPWR VPWR _00644_ sky130_fd_sc_hd__o21ai_1
X_06209_ net36 VGND VGND VPWR VPWR _05342_ sky130_fd_sc_hd__buf_2
XFILLER_0_103_279 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XTAP_TAPCELL_ROW_113_1680 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_96_520 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_0_68_244 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_96_597 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_0_83_225 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_68_277 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XTAP_TAPCELL_ROW_64_1056 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_64_1067 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_37_642 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_10605_ _04365_ _04372_ VGND VGND VPWR VPWR _04373_ sky130_fd_sc_hd__xnor2_1
XFILLER_0_52_601 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XTAP_TAPCELL_ROW_12_412 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_24_303 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_0_36_141 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_0_101_15 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_51_122 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XFILLER_0_36_185 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XTAP_TAPCELL_ROW_40_765 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_116_1709 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_107_574 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
X_10536_ _02134_ _01856_ _04296_ _04297_ VGND VGND VPWR VPWR _04298_ sky130_fd_sc_hd__o2bb2a_1
XFILLER_0_24_369 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XPHY_EDGE_ROW_108_Right_108 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
X_10467_ _04207_ _04117_ _04221_ _04222_ VGND VGND VPWR VPWR _04223_ sky130_fd_sc_hd__a211oi_2
XFILLER_0_51_166 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
X_10398_ _03919_ _03920_ _04033_ _04146_ _04147_ VGND VGND VPWR VPWR _04148_ sky130_fd_sc_hd__o311ai_4
XTAP_TAPCELL_ROW_75_1196 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_19_55 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_20_597 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_0_19_77 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
X_11019_ _04808_ _04821_ VGND VGND VPWR VPWR _04822_ sky130_fd_sc_hd__xor2_2
XTAP_TAPCELL_ROW_48_865 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
X_06560_ _05341_ VGND VGND VPWR VPWR _05689_ sky130_fd_sc_hd__buf_4
XFILLER_0_87_575 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
X_06491_ _05619_ _05620_ VGND VGND VPWR VPWR _05621_ sky130_fd_sc_hd__xnor2_1
XFILLER_0_74_225 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_08230_ _01778_ _01779_ _01756_ _01757_ VGND VGND VPWR VPWR _01781_ sky130_fd_sc_hd__a211o_1
XFILLER_0_7_558 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XFILLER_0_28_653 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XFILLER_0_70_431 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_0_55_472 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
X_08161_ _01687_ _01688_ _01703_ _01704_ VGND VGND VPWR VPWR _01706_ sky130_fd_sc_hd__a211oi_1
XFILLER_0_27_174 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XFILLER_0_43_645 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XFILLER_0_15_358 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
X_08092_ _01627_ _01628_ _01626_ VGND VGND VPWR VPWR _01631_ sky130_fd_sc_hd__a21o_1
X_07112_ _01607_ _00423_ _00197_ _00963_ VGND VGND VPWR VPWR _00561_ sky130_fd_sc_hd__a22o_1
X_07043_ net10 VGND VGND VPWR VPWR _00485_ sky130_fd_sc_hd__clkbuf_4
XFILLER_0_43_689 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_113_577 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_101_717 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_0_11_531 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_0_100_249 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_0_11_575 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
X_08994_ _02594_ _02614_ VGND VGND VPWR VPWR _02615_ sky130_fd_sc_hd__xnor2_4
XFILLER_0_55_3 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
X_07945_ _01467_ _01468_ _01300_ _01405_ VGND VGND VPWR VPWR _01470_ sky130_fd_sc_hd__a211o_1
X_09615_ _02174_ _03291_ _03292_ VGND VGND VPWR VPWR _03293_ sky130_fd_sc_hd__a21bo_1
X_07876_ _01386_ _01394_ VGND VGND VPWR VPWR _01395_ sky130_fd_sc_hd__xnor2_1
X_06827_ _00251_ _00252_ VGND VGND VPWR VPWR _00253_ sky130_fd_sc_hd__xnor2_1
X_09546_ _02964_ _03055_ _03217_ VGND VGND VPWR VPWR _03218_ sky130_fd_sc_hd__a21oi_2
X_06758_ _00179_ _00184_ VGND VGND VPWR VPWR _00185_ sky130_fd_sc_hd__xnor2_2
XFILLER_0_93_501 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
X_09477_ _03136_ _03137_ _03140_ _03141_ VGND VGND VPWR VPWR _03142_ sky130_fd_sc_hd__o211a_1
X_05709_ net33 VGND VGND VPWR VPWR _00395_ sky130_fd_sc_hd__clkbuf_4
XFILLER_0_108_305 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_0_65_225 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
X_06689_ _00014_ _00031_ _00115_ _00116_ VGND VGND VPWR VPWR _00117_ sky130_fd_sc_hd__o211a_1
X_08428_ _01802_ _01812_ _01811_ VGND VGND VPWR VPWR _01997_ sky130_fd_sc_hd__a21bo_1
XFILLER_0_65_269 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_0_18_152 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_46_461 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
X_08359_ _01414_ _00143_ _01919_ _01920_ VGND VGND VPWR VPWR _01922_ sky130_fd_sc_hd__nand4_2
XFILLER_0_18_185 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_19_697 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
X_11370_ _05199_ _05200_ VGND VGND VPWR VPWR _05201_ sky130_fd_sc_hd__or2_1
XFILLER_0_34_678 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_10321_ _04061_ _04062_ VGND VGND VPWR VPWR _04064_ sky130_fd_sc_hd__and2_1
X_10252_ _01221_ _03247_ VGND VGND VPWR VPWR _03989_ sky130_fd_sc_hd__nand2_1
X_10183_ _03908_ _03909_ _03912_ VGND VGND VPWR VPWR _03914_ sky130_fd_sc_hd__a21o_1
XFILLER_0_88_317 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_0_69_531 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XTAP_TAPCELL_ROW_45_824 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_96_383 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_56_203 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_0_84_545 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_84_589 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_0_56_269 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XTAP_TAPCELL_ROW_25_570 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_25_656 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_97_27 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
X_10519_ _00344_ _00346_ _03297_ _03690_ VGND VGND VPWR VPWR _04279_ sky130_fd_sc_hd__nand4_1
XTAP_TAPCELL_ROW_77_1225 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_52_475 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_24_155 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_0_701 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XFILLER_0_110_525 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_0_20_361 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_0_110_569 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_41_9 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
X_07730_ _01219_ _01233_ _01234_ VGND VGND VPWR VPWR _01235_ sky130_fd_sc_hd__nor3_1
X_05991_ _02546_ _02600_ _02535_ VGND VGND VPWR VPWR _03474_ sky130_fd_sc_hd__a21bo_1
XTAP_TAPCELL_ROW_88_1365 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
X_07661_ _01093_ _01095_ _01158_ _01159_ VGND VGND VPWR VPWR _01161_ sky130_fd_sc_hd__or4bb_2
XFILLER_0_94_309 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
X_09400_ _02792_ _02898_ _03057_ VGND VGND VPWR VPWR _03058_ sky130_fd_sc_hd__a21oi_2
X_06612_ _00395_ _00034_ _00037_ _00039_ VGND VGND VPWR VPWR _00040_ sky130_fd_sc_hd__and4_1
XFILLER_0_1_33 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
X_07592_ _01081_ _01082_ _01075_ VGND VGND VPWR VPWR _01085_ sky130_fd_sc_hd__a21o_1
X_09331_ _02816_ _02818_ VGND VGND VPWR VPWR _02983_ sky130_fd_sc_hd__nand2_1
X_06543_ _05669_ _05670_ _05565_ _05650_ VGND VGND VPWR VPWR _05672_ sky130_fd_sc_hd__o211a_1
XFILLER_0_75_545 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_0_117_113 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
X_09262_ _02744_ _02908_ VGND VGND VPWR VPWR _02909_ sky130_fd_sc_hd__xnor2_4
XFILLER_0_7_333 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
X_06474_ _05601_ _05602_ _05603_ VGND VGND VPWR VPWR _05604_ sky130_fd_sc_hd__and3_2
XFILLER_0_35_409 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_118_669 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_90_548 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
X_09193_ _02829_ _02831_ _02793_ VGND VGND VPWR VPWR _02833_ sky130_fd_sc_hd__a21oi_1
X_08213_ _05463_ _00387_ _05693_ VGND VGND VPWR VPWR _01763_ sky130_fd_sc_hd__and3_1
XFILLER_0_7_355 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_15_111 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_16_667 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
X_08144_ _01520_ VGND VGND VPWR VPWR _01687_ sky130_fd_sc_hd__inv_2
XTAP_TAPCELL_ROW_99_1494 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_43_464 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_43_475 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_0_3_561 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
X_08075_ _01771_ _02732_ _00565_ _00695_ VGND VGND VPWR VPWR _01612_ sky130_fd_sc_hd__nand4_2
XFILLER_0_113_385 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
X_07026_ _00126_ _00466_ _00030_ VGND VGND VPWR VPWR _00467_ sky130_fd_sc_hd__and3b_1
XFILLER_0_101_569 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
X_08977_ _02431_ _02433_ VGND VGND VPWR VPWR _02596_ sky130_fd_sc_hd__nand2_1
X_07928_ _01448_ _01450_ _01451_ VGND VGND VPWR VPWR _01452_ sky130_fd_sc_hd__nand3_1
XFILLER_0_98_637 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
X_07859_ _03736_ _00354_ _01373_ _01374_ VGND VGND VPWR VPWR _01376_ sky130_fd_sc_hd__o2bb2a_1
XFILLER_0_97_147 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
X_10870_ _01441_ _01620_ _01853_ VGND VGND VPWR VPWR _04660_ sky130_fd_sc_hd__and3_1
XTAP_TAPCELL_ROW_3_298 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_97_169 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_85_309 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
X_09529_ _03191_ _03197_ _03198_ VGND VGND VPWR VPWR _03199_ sky130_fd_sc_hd__nand3_1
XFILLER_0_39_715 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_0_109_603 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XFILLER_0_78_394 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_78_383 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_0_38_247 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_0_93_364 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_93_353 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XTAP_TAPCELL_ROW_61_1026 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_121_1790 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_22_540 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
X_11422_ _04800_ _04724_ _05237_ _05236_ VGND VGND VPWR VPWR _05257_ sky130_fd_sc_hd__a31oi_1
XTAP_TAPCELL_ROW_50_893 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_50_882 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_34_442 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XFILLER_0_34_475 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
X_11353_ _05155_ _05133_ _05182_ VGND VGND VPWR VPWR _05184_ sky130_fd_sc_hd__nand3_1
X_11284_ _05096_ _05063_ VGND VGND VPWR VPWR _05109_ sky130_fd_sc_hd__and2b_1
XFILLER_0_104_385 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
X_10304_ _03941_ VGND VGND VPWR VPWR _04045_ sky130_fd_sc_hd__inv_2
X_10235_ _03950_ _03951_ _03968_ VGND VGND VPWR VPWR _03970_ sky130_fd_sc_hd__o21ba_1
XTAP_TAPCELL_ROW_72_1166 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
X_10166_ _03875_ _03893_ _03894_ VGND VGND VPWR VPWR _03895_ sky130_fd_sc_hd__or3_2
X_10097_ _03433_ _02281_ _03816_ _03817_ VGND VGND VPWR VPWR _03819_ sky130_fd_sc_hd__nand4_2
XFILLER_0_89_604 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_0_107_69 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XTAP_TAPCELL_ROW_58_993 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_58_982 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_76_309 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
X_10999_ _03178_ VGND VGND VPWR VPWR _04800_ sky130_fd_sc_hd__clkbuf_4
XFILLER_0_57_534 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XTAP_TAPCELL_ROW_83_1295 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_115_617 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_113_3 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
X_06190_ _05303_ _05322_ VGND VGND VPWR VPWR _05323_ sky130_fd_sc_hd__xnor2_1
XFILLER_0_4_358 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_0_40_401 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_40_412 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_0_531 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
X_09880_ _02110_ _01800_ _01977_ _02108_ VGND VGND VPWR VPWR _03582_ sky130_fd_sc_hd__a22o_1
X_08900_ _02509_ _02510_ _02334_ _02336_ VGND VGND VPWR VPWR _02512_ sky130_fd_sc_hd__o211ai_1
XFILLER_0_21_670 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
X_08831_ _02428_ _02434_ _02435_ VGND VGND VPWR VPWR _02437_ sky130_fd_sc_hd__nand3_1
XFILLER_0_57_74 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XPHY_EDGE_ROW_29_Left_151 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
X_05974_ net62 VGND VGND VPWR VPWR _03288_ sky130_fd_sc_hd__clkbuf_4
X_08762_ _01497_ _01987_ _02185_ _00657_ VGND VGND VPWR VPWR _02363_ sky130_fd_sc_hd__a22oi_1
X_08693_ _00089_ _00343_ _00345_ _05686_ VGND VGND VPWR VPWR _02287_ sky130_fd_sc_hd__a22o_1
X_07713_ _01066_ _01068_ VGND VGND VPWR VPWR _01217_ sky130_fd_sc_hd__nand2_2
XFILLER_0_18_3 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
X_07644_ _04063_ _05695_ net40 _03004_ VGND VGND VPWR VPWR _01142_ sky130_fd_sc_hd__a22o_1
XFILLER_0_88_681 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XTAP_TAPCELL_ROW_0_246 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_0_257 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_0_268 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
X_07575_ _05327_ _04726_ _00150_ _00349_ VGND VGND VPWR VPWR _01066_ sky130_fd_sc_hd__nand4_2
X_09314_ _02822_ _02823_ _02824_ VGND VGND VPWR VPWR _02965_ sky130_fd_sc_hd__and3_1
X_06526_ net6 VGND VGND VPWR VPWR _05655_ sky130_fd_sc_hd__clkbuf_4
XFILLER_0_8_620 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XPHY_EDGE_ROW_38_Left_160 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
X_09245_ _02888_ _02889_ VGND VGND VPWR VPWR _02890_ sky130_fd_sc_hd__nand2_2
XFILLER_0_63_537 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
X_06457_ _00330_ net35 _05342_ _02054_ VGND VGND VPWR VPWR _05587_ sky130_fd_sc_hd__a22o_1
XFILLER_0_48_589 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_0_118_477 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_09176_ _00798_ _02321_ _02669_ _02668_ _02813_ VGND VGND VPWR VPWR _02814_ sky130_fd_sc_hd__a32o_1
XFILLER_0_16_475 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
X_06388_ _05482_ _05483_ _05516_ _05517_ VGND VGND VPWR VPWR _05519_ sky130_fd_sc_hd__a2bb2o_1
X_08127_ _01531_ _01532_ _01652_ _01653_ VGND VGND VPWR VPWR _01668_ sky130_fd_sc_hd__nor4_1
X_08058_ _01589_ _01592_ VGND VGND VPWR VPWR _01593_ sky130_fd_sc_hd__xor2_2
XFILLER_0_101_333 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
X_07009_ _00404_ _00405_ _00446_ _00447_ VGND VGND VPWR VPWR _00448_ sky130_fd_sc_hd__or4_2
XFILLER_0_3_391 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
X_10020_ _03732_ _03733_ _03700_ _03701_ VGND VGND VPWR VPWR _03735_ sky130_fd_sc_hd__o211a_1
Xoutput69 net69 VGND VGND VPWR VPWR product[13] sky130_fd_sc_hd__clkbuf_4
XTAP_TAPCELL_ROW_8_368 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_8_357 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
X_10922_ _04714_ _04715_ VGND VGND VPWR VPWR _04718_ sky130_fd_sc_hd__and2_1
XFILLER_0_98_434 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_98_489 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_0_79_670 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XFILLER_0_58_309 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XTAP_TAPCELL_ROW_55_952 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
X_10853_ _02626_ _02862_ _02866_ _00237_ VGND VGND VPWR VPWR _04642_ sky130_fd_sc_hd__a22o_1
X_10784_ _04562_ _04564_ _04565_ VGND VGND VPWR VPWR _04567_ sky130_fd_sc_hd__or3_1
XFILLER_0_109_444 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_0_93_161 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_0_81_334 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
X_11405_ _05237_ _05238_ VGND VGND VPWR VPWR _05239_ sky130_fd_sc_hd__xor2_1
XFILLER_0_78_29 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
X_11336_ _04732_ _05033_ _05164_ VGND VGND VPWR VPWR _05165_ sky130_fd_sc_hd__a21o_1
X_11267_ _05088_ _05090_ VGND VGND VPWR VPWR _05091_ sky130_fd_sc_hd__and2_1
X_10218_ _03947_ _03948_ _03949_ VGND VGND VPWR VPWR _03951_ sky130_fd_sc_hd__a21oi_2
X_11198_ _04949_ _04955_ _05015_ VGND VGND VPWR VPWR _05016_ sky130_fd_sc_hd__o21a_1
X_10149_ _03707_ _03716_ _03715_ VGND VGND VPWR VPWR _03876_ sky130_fd_sc_hd__a21o_1
XFILLER_0_27_55 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XTAP_TAPCELL_ROW_85_1324 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_43_54 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XFILLER_0_85_673 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_57_342 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
X_07360_ _00963_ _01607_ net43 VGND VGND VPWR VPWR _00831_ sky130_fd_sc_hd__and3_1
X_06311_ _05441_ _05442_ VGND VGND VPWR VPWR _05443_ sky130_fd_sc_hd__or2_1
XTAP_TAPCELL_ROW_33_679 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
X_07291_ _00749_ VGND VGND VPWR VPWR _00756_ sky130_fd_sc_hd__inv_2
X_09030_ _02650_ _02651_ _02652_ VGND VGND VPWR VPWR _02654_ sky130_fd_sc_hd__a21o_1
XFILLER_0_4_133 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
X_06242_ _05297_ _05299_ _05296_ VGND VGND VPWR VPWR _05375_ sky130_fd_sc_hd__o21bai_2
X_06173_ _00668_ _00450_ _05304_ _05305_ VGND VGND VPWR VPWR _05306_ sky130_fd_sc_hd__and4_1
XTAP_TAPCELL_ROW_96_1464 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_4_177 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_40_253 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_110_141 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
X_09932_ _03501_ _03622_ _03637_ _03639_ VGND VGND VPWR VPWR _03640_ sky130_fd_sc_hd__o211a_1
XFILLER_0_111_697 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
X_09863_ _01943_ _02492_ _00495_ _03324_ VGND VGND VPWR VPWR _03564_ sky130_fd_sc_hd__nand4_4
XTAP_TAPCELL_ROW_5_327 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
X_09794_ _01187_ VGND VGND VPWR VPWR _03489_ sky130_fd_sc_hd__buf_4
X_08814_ _02416_ _02417_ VGND VGND VPWR VPWR _02418_ sky130_fd_sc_hd__xnor2_1
XFILLER_0_84_83 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
X_08745_ _02166_ _02168_ VGND VGND VPWR VPWR _02344_ sky130_fd_sc_hd__nand2_2
X_05957_ _01236_ _03091_ VGND VGND VPWR VPWR _03102_ sky130_fd_sc_hd__nand2_1
X_08676_ _02067_ _02069_ _02266_ _02267_ VGND VGND VPWR VPWR _02268_ sky130_fd_sc_hd__a211oi_1
X_05888_ _02317_ _02328_ _01727_ net166 VGND VGND VPWR VPWR _02350_ sky130_fd_sc_hd__a211o_1
XTAP_TAPCELL_ROW_52_911 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
X_07627_ _01112_ _01121_ _01122_ VGND VGND VPWR VPWR _01123_ sky130_fd_sc_hd__nand3_2
XTAP_TAPCELL_ROW_105_1571 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
X_07558_ _00912_ _00916_ _01045_ VGND VGND VPWR VPWR _01047_ sky130_fd_sc_hd__or3_1
XFILLER_0_91_621 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_91_610 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_0_63_301 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
X_06509_ _00384_ _05541_ _05637_ _01760_ VGND VGND VPWR VPWR _05638_ sky130_fd_sc_hd__a22o_1
XFILLER_0_48_397 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
X_07489_ _01651_ _00195_ _00833_ _00831_ _00830_ VGND VGND VPWR VPWR _00972_ sky130_fd_sc_hd__a32o_1
XFILLER_0_118_285 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_0_106_447 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_90_153 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_63_389 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_0_63_367 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
X_09228_ _02693_ _02694_ VGND VGND VPWR VPWR _02871_ sky130_fd_sc_hd__nand2_1
XFILLER_0_90_197 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
X_09159_ _00087_ _00609_ _00748_ _00187_ VGND VGND VPWR VPWR _02795_ sky130_fd_sc_hd__a22o_1
X_11121_ _04930_ _04931_ VGND VGND VPWR VPWR _04934_ sky130_fd_sc_hd__nand2_1
XFILLER_0_102_631 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_102_675 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
X_11052_ _04798_ _04799_ _04858_ VGND VGND VPWR VPWR _04859_ sky130_fd_sc_hd__a21oi_1
X_10003_ _03715_ _03716_ VGND VGND VPWR VPWR _03717_ sky130_fd_sc_hd__or2b_1
XFILLER_0_98_231 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_0_59_629 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
X_10905_ _04696_ _04697_ _04577_ VGND VGND VPWR VPWR _04699_ sky130_fd_sc_hd__a21o_1
X_10836_ _04621_ _04622_ _04579_ VGND VGND VPWR VPWR _04624_ sky130_fd_sc_hd__o21ai_1
XTAP_TAPCELL_ROW_67_1098 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_109_230 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_67_673 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_13_57 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
X_10767_ _04148_ _04541_ _04545_ net129 _04548_ VGND VGND VPWR VPWR _04549_ sky130_fd_sc_hd__a221oi_4
XTAP_TAPCELL_ROW_80_1265 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_54_345 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_27_559 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XTAP_TAPCELL_ROW_30_638 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_89_39 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_10698_ _04469_ _04470_ _04471_ VGND VGND VPWR VPWR _04473_ sky130_fd_sc_hd__nand3_1
XFILLER_0_42_507 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XTAP_TAPCELL_ROW_10_384 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_1_125 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_2_637 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_0_22_253 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
X_11319_ _05109_ _05110_ _05146_ VGND VGND VPWR VPWR _05147_ sky130_fd_sc_hd__o21a_1
XFILLER_0_1_169 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XTAP_TAPCELL_ROW_91_1394 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
X_06860_ _05410_ _05689_ VGND VGND VPWR VPWR _00286_ sky130_fd_sc_hd__nand2_1
X_05811_ net61 VGND VGND VPWR VPWR _01508_ sky130_fd_sc_hd__clkbuf_4
X_06791_ _00215_ _00216_ _00157_ VGND VGND VPWR VPWR _00218_ sky130_fd_sc_hd__a21o_1
XTAP_TAPCELL_ROW_38_738 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_89_242 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
X_08530_ _05539_ VGND VGND VPWR VPWR _02108_ sky130_fd_sc_hd__clkbuf_4
X_05742_ _00319_ _00384_ _00406_ _00340_ VGND VGND VPWR VPWR _00755_ sky130_fd_sc_hd__a22oi_1
X_08461_ _01887_ _01889_ VGND VGND VPWR VPWR _02033_ sky130_fd_sc_hd__nor2_1
XFILLER_0_9_225 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
X_07412_ _00882_ _00887_ VGND VGND VPWR VPWR _00888_ sky130_fd_sc_hd__nor2_4
XTAP_TAPCELL_ROW_18_484 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_92_429 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_70_52 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_0_64_109 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_0_58_684 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
X_08392_ _01947_ _01955_ _01957_ VGND VGND VPWR VPWR _01958_ sky130_fd_sc_hd__nand3_1
XFILLER_0_18_504 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XFILLER_0_18_515 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_116_701 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
X_07343_ _00794_ _00811_ _00812_ VGND VGND VPWR VPWR _00813_ sky130_fd_sc_hd__and3_2
XFILLER_0_115_233 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_07274_ _00617_ _00736_ VGND VGND VPWR VPWR _00737_ sky130_fd_sc_hd__and2_1
XFILLER_0_85_3 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_72_197 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_09013_ _02625_ _02635_ VGND VGND VPWR VPWR _02636_ sky130_fd_sc_hd__xor2_1
XFILLER_0_60_326 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_26_570 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
X_06225_ _05357_ VGND VGND VPWR VPWR _05358_ sky130_fd_sc_hd__inv_2
XFILLER_0_115_288 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
X_06156_ _04161_ _04465_ _05245_ _05255_ VGND VGND VPWR VPWR _05266_ sky130_fd_sc_hd__a211o_2
X_06087_ net32 VGND VGND VPWR VPWR _04520_ sky130_fd_sc_hd__clkbuf_4
X_09915_ _03619_ _03620_ VGND VGND VPWR VPWR _03621_ sky130_fd_sc_hd__xor2_2
X_09846_ _00269_ _02529_ VGND VGND VPWR VPWR _03545_ sky130_fd_sc_hd__and2_1
XFILLER_0_0_191 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XTAP_TAPCELL_ROW_107_1600 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
X_09777_ _00283_ _01671_ _03468_ _03469_ VGND VGND VPWR VPWR _03470_ sky130_fd_sc_hd__o2bb2a_1
X_06989_ _00424_ _00425_ VGND VGND VPWR VPWR _00426_ sky130_fd_sc_hd__and2b_1
XFILLER_0_96_713 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
X_08728_ _01943_ VGND VGND VPWR VPWR _02325_ sky130_fd_sc_hd__buf_4
X_08659_ _02235_ _02237_ _02247_ VGND VGND VPWR VPWR _02249_ sky130_fd_sc_hd__a21oi_1
XFILLER_0_49_651 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_0_55_109 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
X_10621_ _04380_ _04389_ VGND VGND VPWR VPWR _04391_ sky130_fd_sc_hd__xnor2_1
X_10552_ _02837_ _02667_ _03490_ _01041_ VGND VGND VPWR VPWR _04316_ sky130_fd_sc_hd__nand4_2
XFILLER_0_91_473 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_63_186 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XFILLER_0_51_337 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_121_225 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_121_203 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XTAP_TAPCELL_ROW_118_1740 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
X_10483_ _04151_ _04152_ _04239_ _04240_ VGND VGND VPWR VPWR _04241_ sky130_fd_sc_hd__a211oi_1
XFILLER_0_106_277 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_20_713 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
X_11104_ _04912_ _04914_ VGND VGND VPWR VPWR _04915_ sky130_fd_sc_hd__xnor2_1
X_11035_ _04828_ _04829_ _04839_ VGND VGND VPWR VPWR _04840_ sky130_fd_sc_hd__and3_1
XTAP_TAPCELL_ROW_69_1127 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_99_573 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_115_69 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_86_289 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
X_10819_ _04600_ _04603_ _04604_ VGND VGND VPWR VPWR _04605_ sky130_fd_sc_hd__nand3_2
XFILLER_0_55_654 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XTAP_TAPCELL_ROW_15_454 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_27_345 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XTAP_TAPCELL_ROW_43_796 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_82_473 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_0_27_367 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_0_54_197 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_0_54_175 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_0_27_389 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_0_2_412 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_06010_ _03660_ _03671_ _00450_ _03080_ VGND VGND VPWR VPWR _03681_ sky130_fd_sc_hd__and4bb_1
XTAP_TAPCELL_ROW_93_1423 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_71_9 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_11_713 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_10_201 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
X_07961_ _01028_ _01175_ _01320_ _01485_ VGND VGND VPWR VPWR _01487_ sky130_fd_sc_hd__and4bb_1
X_09700_ _03249_ _03251_ VGND VGND VPWR VPWR _03385_ sky130_fd_sc_hd__and2b_1
X_06912_ _00260_ _00261_ _00278_ _00279_ VGND VGND VPWR VPWR _00342_ sky130_fd_sc_hd__o211ai_2
X_07892_ _00187_ _05655_ _01410_ _01412_ VGND VGND VPWR VPWR _01413_ sky130_fd_sc_hd__nand4_2
X_09631_ _03307_ _03308_ _03290_ VGND VGND VPWR VPWR _03311_ sky130_fd_sc_hd__a21oi_1
X_06843_ net3 VGND VGND VPWR VPWR _00269_ sky130_fd_sc_hd__buf_4
XFILLER_0_4_77 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
X_09562_ _03119_ VGND VGND VPWR VPWR _03235_ sky130_fd_sc_hd__inv_2
XFILLER_0_78_713 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
X_06774_ _00093_ _00096_ _00095_ VGND VGND VPWR VPWR _00201_ sky130_fd_sc_hd__a21bo_1
X_08513_ _01898_ _02088_ _02089_ VGND VGND VPWR VPWR _02090_ sky130_fd_sc_hd__a21bo_1
X_05725_ _00526_ _00548_ _00559_ VGND VGND VPWR VPWR _00570_ sky130_fd_sc_hd__and3_1
XFILLER_0_81_51 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
X_09493_ _03155_ _03156_ _03158_ VGND VGND VPWR VPWR _03160_ sky130_fd_sc_hd__a21o_1
X_08444_ _01894_ _01895_ _02012_ _02013_ VGND VGND VPWR VPWR _02015_ sky130_fd_sc_hd__o22ai_2
XTAP_TAPCELL_ROW_102_1541 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_45_120 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
X_08375_ _01774_ _01776_ VGND VGND VPWR VPWR _01940_ sky130_fd_sc_hd__nand2_1
XFILLER_0_46_643 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_61_602 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_07326_ _00675_ _00683_ _00682_ VGND VGND VPWR VPWR _00794_ sky130_fd_sc_hd__a21o_1
XFILLER_0_46_676 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_60_101 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_45_164 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_0_60_145 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
X_07257_ _00648_ _00649_ _00716_ _00717_ VGND VGND VPWR VPWR _00719_ sky130_fd_sc_hd__a2bb2o_1
XFILLER_0_103_258 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_103_225 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
X_07188_ _00629_ _00641_ _00642_ VGND VGND VPWR VPWR _00643_ sky130_fd_sc_hd__or3_1
XFILLER_0_14_584 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
X_06208_ net35 VGND VGND VPWR VPWR _05341_ sky130_fd_sc_hd__clkbuf_4
X_06139_ _05052_ _05062_ _05073_ VGND VGND VPWR VPWR _05084_ sky130_fd_sc_hd__nand3_1
XTAP_TAPCELL_ROW_113_1670 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
X_09829_ _03524_ _03526_ VGND VGND VPWR VPWR _03527_ sky130_fd_sc_hd__xnor2_2
XFILLER_0_69_713 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_96_587 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_68_289 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XTAP_TAPCELL_ROW_64_1057 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_56_429 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_83_237 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XTAP_TAPCELL_ROW_64_1068 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
X_10604_ _04370_ _04371_ VGND VGND VPWR VPWR _04372_ sky130_fd_sc_hd__xor2_1
XTAP_TAPCELL_ROW_12_413 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_24_315 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XTAP_TAPCELL_ROW_40_766 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_107_586 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_0_101_27 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
X_10535_ _02104_ _00987_ _03237_ _01853_ VGND VGND VPWR VPWR _04297_ sky130_fd_sc_hd__and4_1
XFILLER_0_51_145 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_36_197 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
X_10466_ _04219_ _04220_ _04111_ _04113_ VGND VGND VPWR VPWR _04222_ sky130_fd_sc_hd__o211a_1
XFILLER_0_20_543 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_32_392 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
X_10397_ _03915_ _03916_ _04033_ VGND VGND VPWR VPWR _04147_ sky130_fd_sc_hd__or3_1
XTAP_TAPCELL_ROW_75_1197 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_20_587 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
X_11018_ _04819_ _04820_ VGND VGND VPWR VPWR _04821_ sky130_fd_sc_hd__and2_1
XFILLER_0_35_55 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XTAP_TAPCELL_ROW_48_866 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
X_06490_ _05448_ _05529_ _05526_ VGND VGND VPWR VPWR _05620_ sky130_fd_sc_hd__o21ba_1
XFILLER_0_74_248 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_28_665 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
X_08160_ _01701_ _01702_ _01515_ _01689_ VGND VGND VPWR VPWR _01704_ sky130_fd_sc_hd__o211a_1
XFILLER_0_27_164 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_0_28_698 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
X_07111_ _00963_ _01607_ _00423_ VGND VGND VPWR VPWR _00560_ sky130_fd_sc_hd__and3_1
XFILLER_0_70_443 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XFILLER_0_15_337 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
X_08091_ _01626_ _01627_ _01628_ VGND VGND VPWR VPWR _01630_ sky130_fd_sc_hd__nand3_1
XFILLER_0_43_668 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_0_113_545 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_70_465 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
X_07042_ _00483_ VGND VGND VPWR VPWR _00484_ sky130_fd_sc_hd__inv_2
XFILLER_0_113_589 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_0_76_40 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_08993_ _02612_ _02613_ VGND VGND VPWR VPWR _02614_ sky130_fd_sc_hd__xnor2_4
XFILLER_0_11_587 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XPHY_EDGE_ROW_10_Left_132 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
X_07944_ _01300_ net156 _01467_ _01468_ VGND VGND VPWR VPWR _01469_ sky130_fd_sc_hd__o211ai_4
XFILLER_0_48_3 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
X_07875_ _01387_ _01393_ VGND VGND VPWR VPWR _01394_ sky130_fd_sc_hd__xor2_1
X_09614_ _05553_ _02516_ _02345_ _05464_ VGND VGND VPWR VPWR _03292_ sky130_fd_sc_hd__a22o_1
X_06826_ _00137_ _00242_ _00144_ _00146_ _00136_ VGND VGND VPWR VPWR _00252_ sky130_fd_sc_hd__a32o_2
X_09545_ _03052_ _03054_ VGND VGND VPWR VPWR _03217_ sky130_fd_sc_hd__nor2_2
X_06757_ _00180_ _00183_ VGND VGND VPWR VPWR _00184_ sky130_fd_sc_hd__xnor2_2
XFILLER_0_78_587 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
X_09476_ _02645_ _00762_ _03138_ _03139_ VGND VGND VPWR VPWR _03141_ sky130_fd_sc_hd__nand4_1
X_05708_ _00373_ VGND VGND VPWR VPWR _00384_ sky130_fd_sc_hd__clkbuf_4
X_06688_ _00113_ _00114_ _00053_ VGND VGND VPWR VPWR _00116_ sky130_fd_sc_hd__a21o_1
XFILLER_0_93_546 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_65_237 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
X_08427_ _01993_ _01994_ _01984_ VGND VGND VPWR VPWR _01996_ sky130_fd_sc_hd__a21o_1
XFILLER_0_93_568 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_0_73_281 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_08358_ _01414_ _00143_ _01919_ _01920_ VGND VGND VPWR VPWR _01921_ sky130_fd_sc_hd__a22o_1
XFILLER_0_18_164 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_104_501 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
X_08289_ _01710_ _01712_ VGND VGND VPWR VPWR _01845_ sky130_fd_sc_hd__nor2_1
X_07309_ _04889_ _00143_ _00773_ _00774_ VGND VGND VPWR VPWR _00775_ sky130_fd_sc_hd__nand4_1
XFILLER_0_33_123 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_116_394 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_104_545 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
X_10320_ _02838_ _00753_ _04059_ _04060_ VGND VGND VPWR VPWR _04062_ sky130_fd_sc_hd__nand4_2
X_10251_ _03985_ _03986_ VGND VGND VPWR VPWR _03988_ sky130_fd_sc_hd__xnor2_1
XFILLER_0_104_589 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_61_498 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
X_10182_ _03908_ _03909_ _03912_ VGND VGND VPWR VPWR _03913_ sky130_fd_sc_hd__nand3_1
XTAP_TAPCELL_ROW_45_825 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_29_429 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_84_557 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_112_15 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XTAP_TAPCELL_ROW_25_571 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_52_421 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_114_309 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_21_57 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_21_79 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_25_668 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
X_10518_ _00350_ _02161_ _03690_ _00348_ VGND VGND VPWR VPWR _04278_ sky130_fd_sc_hd__a22o_1
XTAP_TAPCELL_ROW_77_1226 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_24_178 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XFILLER_0_33_690 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
X_10449_ _04200_ _04202_ VGND VGND VPWR VPWR _04203_ sky130_fd_sc_hd__xor2_1
X_05990_ _03430_ _03441_ _03277_ VGND VGND VPWR VPWR _03463_ sky130_fd_sc_hd__a21o_1
XTAP_TAPCELL_ROW_88_1366 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_79_318 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
X_07660_ _01156_ _01157_ _01008_ _01096_ VGND VGND VPWR VPWR _01159_ sky130_fd_sc_hd__o211ai_1
X_06611_ _02666_ _05540_ _00038_ _00362_ VGND VGND VPWR VPWR _00039_ sky130_fd_sc_hd__a22o_1
XFILLER_0_1_45 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_07591_ _01075_ _01081_ _01082_ VGND VGND VPWR VPWR _01084_ sky130_fd_sc_hd__nand3_1
X_09330_ _02970_ _02980_ VGND VGND VPWR VPWR _02981_ sky130_fd_sc_hd__xnor2_2
XFILLER_0_62_42 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
X_06542_ _05565_ _05650_ _05669_ _05670_ VGND VGND VPWR VPWR _05671_ sky130_fd_sc_hd__a211oi_1
XFILLER_0_48_716 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
X_09261_ _02745_ _02906_ VGND VGND VPWR VPWR _02908_ sky130_fd_sc_hd__xnor2_4
XFILLER_0_117_125 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_08212_ _00094_ VGND VGND VPWR VPWR _01762_ sky130_fd_sc_hd__clkbuf_4
X_06473_ _05499_ _05508_ _05507_ VGND VGND VPWR VPWR _05603_ sky130_fd_sc_hd__a21bo_1
XFILLER_0_28_440 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
X_09192_ _02793_ _02829_ _02831_ VGND VGND VPWR VPWR _02832_ sky130_fd_sc_hd__and3_1
XFILLER_0_28_484 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_0_117_169 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_0_55_281 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XFILLER_0_7_367 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
X_08143_ _01684_ _01685_ VGND VGND VPWR VPWR _01686_ sky130_fd_sc_hd__or2_1
XTAP_TAPCELL_ROW_99_1495 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_16_679 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_31_627 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
X_08074_ _02732_ _00565_ _00695_ _02721_ VGND VGND VPWR VPWR _01611_ sky130_fd_sc_hd__a22o_1
XFILLER_0_70_284 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XFILLER_0_3_573 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
X_07025_ _00227_ _00335_ VGND VGND VPWR VPWR _00466_ sky130_fd_sc_hd__and2_1
XFILLER_0_31_649 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XTAP_TAPCELL_ROW_110_1640 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
X_08976_ _02455_ _02465_ _02464_ VGND VGND VPWR VPWR _02595_ sky130_fd_sc_hd__a21oi_1
X_07927_ _00646_ net51 net52 _00624_ VGND VGND VPWR VPWR _01451_ sky130_fd_sc_hd__a22o_1
X_07858_ _01373_ _01374_ _05659_ net13 VGND VGND VPWR VPWR _01375_ sky130_fd_sc_hd__and4bb_1
X_06809_ net11 VGND VGND VPWR VPWR _00235_ sky130_fd_sc_hd__clkbuf_4
XTAP_TAPCELL_ROW_3_299 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
X_07789_ _01126_ _01129_ _01298_ _01299_ VGND VGND VPWR VPWR _01300_ sky130_fd_sc_hd__a211oi_4
XFILLER_0_78_373 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
X_09528_ _03195_ _03196_ _03192_ _03017_ VGND VGND VPWR VPWR _03198_ sky130_fd_sc_hd__a211o_1
XFILLER_0_109_615 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XTAP_TAPCELL_ROW_121_1780 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_109_637 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
X_09459_ _03119_ _03120_ _03100_ VGND VGND VPWR VPWR _03122_ sky130_fd_sc_hd__o21a_1
XTAP_TAPCELL_ROW_61_1027 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_121_1791 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_108_147 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_93_376 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XTAP_TAPCELL_ROW_22_541 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
X_11421_ _05248_ _05247_ VGND VGND VPWR VPWR _05256_ sky130_fd_sc_hd__or2b_1
XTAP_TAPCELL_ROW_50_883 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_34_421 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
X_11352_ _05155_ _05133_ _05182_ VGND VGND VPWR VPWR _05183_ sky130_fd_sc_hd__a21o_1
X_10303_ _05388_ _05467_ _02862_ _02865_ VGND VGND VPWR VPWR _04044_ sky130_fd_sc_hd__and4_1
XFILLER_0_21_104 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_11283_ _05101_ _05108_ VGND VGND VPWR VPWR net116 sky130_fd_sc_hd__xnor2_4
XFILLER_0_104_397 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
X_10234_ _03950_ _03951_ _03968_ VGND VGND VPWR VPWR _03969_ sky130_fd_sc_hd__nor3b_4
X_10165_ _03891_ _03892_ _03772_ _03774_ VGND VGND VPWR VPWR _03894_ sky130_fd_sc_hd__a211oi_2
XTAP_TAPCELL_ROW_72_1167 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_72_1156 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
X_10096_ _03433_ _02281_ _03816_ _03817_ VGND VGND VPWR VPWR _03818_ sky130_fd_sc_hd__a22o_1
XTAP_TAPCELL_ROW_58_983 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_57_513 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
X_10998_ _03574_ _03675_ _04752_ VGND VGND VPWR VPWR _04799_ sky130_fd_sc_hd__nand3_1
XFILLER_0_8_109 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XTAP_TAPCELL_ROW_83_1296 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_45_719 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_115_629 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_0_37_281 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_106_3 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_52_251 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_25_487 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_110_323 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_110_301 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
X_08830_ _02432_ _02433_ _02429_ VGND VGND VPWR VPWR _02435_ sky130_fd_sc_hd__a21o_1
XFILLER_0_0_587 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
X_05973_ _03244_ _03266_ VGND VGND VPWR VPWR _03277_ sky130_fd_sc_hd__xnor2_2
X_08761_ _02359_ _02360_ VGND VGND VPWR VPWR _02362_ sky130_fd_sc_hd__nor2_2
X_08692_ _00408_ _00623_ _02093_ _02094_ VGND VGND VPWR VPWR _02286_ sky130_fd_sc_hd__and4_1
X_07712_ _01213_ _01215_ VGND VGND VPWR VPWR _01216_ sky130_fd_sc_hd__and2b_2
X_07643_ _04520_ _04063_ _05695_ _05696_ VGND VGND VPWR VPWR _01141_ sky130_fd_sc_hd__nand4_2
XTAP_TAPCELL_ROW_0_247 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_0_258 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_88_693 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
X_09313_ _02918_ _02963_ VGND VGND VPWR VPWR _02964_ sky130_fd_sc_hd__xnor2_2
X_07574_ _01059_ _01064_ VGND VGND VPWR VPWR _01065_ sky130_fd_sc_hd__xnor2_2
XFILLER_0_48_546 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
X_06525_ _05652_ _05653_ VGND VGND VPWR VPWR _05654_ sky130_fd_sc_hd__and2_1
XFILLER_0_63_505 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_118_434 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_75_376 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
X_09244_ _02860_ _02861_ _02886_ _02887_ VGND VGND VPWR VPWR _02889_ sky130_fd_sc_hd__a22o_1
XFILLER_0_8_632 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
X_06456_ _02054_ _03201_ net35 VGND VGND VPWR VPWR _05586_ sky130_fd_sc_hd__and3_1
X_09175_ _02812_ VGND VGND VPWR VPWR _02813_ sky130_fd_sc_hd__buf_4
XFILLER_0_16_421 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_08126_ _01528_ _01531_ VGND VGND VPWR VPWR _01667_ sky130_fd_sc_hd__nor2_1
X_06387_ _05482_ _05483_ _05516_ _05517_ VGND VGND VPWR VPWR _05518_ sky130_fd_sc_hd__or4bb_4
XFILLER_0_120_109 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_43_295 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_0_101_312 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XPHY_EDGE_ROW_1_Right_1 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
X_08057_ _00987_ _01590_ _01591_ VGND VGND VPWR VPWR _01592_ sky130_fd_sc_hd__a21bo_1
XFILLER_0_12_671 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
X_07008_ _00444_ _00445_ _00313_ _00407_ VGND VGND VPWR VPWR _00447_ sky130_fd_sc_hd__o211a_1
XTAP_TAPCELL_ROW_8_358 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
X_08959_ _02450_ _02486_ _02485_ VGND VGND VPWR VPWR _02576_ sky130_fd_sc_hd__a21bo_4
X_10921_ _04714_ _04715_ VGND VGND VPWR VPWR _04717_ sky130_fd_sc_hd__nor2_1
XTAP_TAPCELL_ROW_27_600 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_55_953 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
X_10852_ _04481_ _04616_ _04617_ VGND VGND VPWR VPWR _04641_ sky130_fd_sc_hd__nor3_1
XFILLER_0_85_118 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_39_535 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
X_10783_ _04562_ _04564_ _04565_ VGND VGND VPWR VPWR _04566_ sky130_fd_sc_hd__o21ai_1
XFILLER_0_93_151 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_81_302 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_93_184 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_62_560 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
X_11404_ _04800_ _03675_ VGND VGND VPWR VPWR _05238_ sky130_fd_sc_hd__nand2_1
XFILLER_0_105_673 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
X_11335_ _05162_ _05163_ VGND VGND VPWR VPWR _05164_ sky130_fd_sc_hd__xnor2_1
XFILLER_0_104_183 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
X_11266_ _04957_ _05089_ _05043_ VGND VGND VPWR VPWR _05090_ sky130_fd_sc_hd__a21o_1
X_10217_ _03947_ _03948_ _03949_ VGND VGND VPWR VPWR _03950_ sky130_fd_sc_hd__and3_2
X_11197_ _05013_ _05014_ VGND VGND VPWR VPWR _05015_ sky130_fd_sc_hd__nor2_1
X_10148_ _03873_ _03874_ VGND VGND VPWR VPWR _03875_ sky130_fd_sc_hd__xor2_2
X_10079_ _03743_ _03599_ _03778_ _03779_ VGND VGND VPWR VPWR _03799_ sky130_fd_sc_hd__o211a_1
XTAP_TAPCELL_ROW_85_1325 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_76_118 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_0_69_181 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XFILLER_0_85_641 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_18_719 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_85_685 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
X_07290_ _00753_ VGND VGND VPWR VPWR _00754_ sky130_fd_sc_hd__buf_4
X_06310_ _05403_ _05404_ _05439_ _05440_ VGND VGND VPWR VPWR _05442_ sky130_fd_sc_hd__o22a_1
XTAP_TAPCELL_ROW_33_669 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_45_505 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
X_06241_ _05372_ _05373_ VGND VGND VPWR VPWR _05374_ sky130_fd_sc_hd__or2b_1
XFILLER_0_41_700 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_87_7 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_13_435 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
X_06172_ _04063_ VGND VGND VPWR VPWR _05305_ sky130_fd_sc_hd__buf_4
XTAP_TAPCELL_ROW_96_1465 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_4_189 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_0_40_221 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_09931_ _03635_ _03636_ _03497_ _03499_ VGND VGND VPWR VPWR _03639_ sky130_fd_sc_hd__o211ai_2
XFILLER_0_68_63 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_40_265 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_0_21_490 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_110_197 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
X_09862_ _02492_ _03323_ _03324_ _01943_ VGND VGND VPWR VPWR _03563_ sky130_fd_sc_hd__a22o_1
XTAP_TAPCELL_ROW_5_328 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
X_09793_ _02302_ _02281_ _03325_ _03322_ _00496_ VGND VGND VPWR VPWR _03488_ sky130_fd_sc_hd__a32o_1
X_08813_ _00515_ _01856_ _02239_ _02238_ _01354_ VGND VGND VPWR VPWR _02417_ sky130_fd_sc_hd__a32o_1
X_08744_ _02341_ _02342_ VGND VGND VPWR VPWR _02343_ sky130_fd_sc_hd__nor2_4
XFILLER_0_30_3 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
X_05956_ _03080_ VGND VGND VPWR VPWR _03091_ sky130_fd_sc_hd__buf_4
X_08675_ _02264_ _02265_ _02254_ VGND VGND VPWR VPWR _02267_ sky130_fd_sc_hd__a21boi_1
X_05887_ _01727_ net166 _02317_ _02328_ VGND VGND VPWR VPWR _02339_ sky130_fd_sc_hd__o211a_1
XFILLER_0_95_449 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XFILLER_0_95_438 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XTAP_TAPCELL_ROW_52_912 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
X_07626_ _01118_ _01119_ _01120_ VGND VGND VPWR VPWR _01122_ sky130_fd_sc_hd__a21o_1
XTAP_TAPCELL_ROW_105_1572 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
X_07557_ _00912_ _00916_ _01045_ VGND VGND VPWR VPWR _01046_ sky130_fd_sc_hd__o21ai_4
XFILLER_0_48_321 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_118_231 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
X_06508_ _05636_ VGND VGND VPWR VPWR _05637_ sky130_fd_sc_hd__buf_4
XFILLER_0_48_365 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_118_253 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
X_07488_ _00820_ _00823_ VGND VGND VPWR VPWR _00971_ sky130_fd_sc_hd__nand2_1
XFILLER_0_90_165 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
X_09227_ _02867_ _02869_ VGND VGND VPWR VPWR _02870_ sky130_fd_sc_hd__nor2_1
XFILLER_0_8_484 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_06439_ _05548_ _05549_ _05568_ VGND VGND VPWR VPWR _05569_ sky130_fd_sc_hd__o21a_1
X_09158_ _00187_ _00087_ _01060_ VGND VGND VPWR VPWR _02794_ sky130_fd_sc_hd__and3_1
XFILLER_0_44_582 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_0_121_429 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_71_390 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
X_09089_ _02716_ _02718_ VGND VGND VPWR VPWR _02719_ sky130_fd_sc_hd__xor2_4
X_08109_ _01572_ _01573_ _01647_ _01648_ VGND VGND VPWR VPWR _01649_ sky130_fd_sc_hd__and4bb_2
XPHY_EDGE_ROW_2_Left_124 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_0_31_221 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
X_11120_ _04930_ _04931_ VGND VGND VPWR VPWR _04932_ sky130_fd_sc_hd__or2_1
XFILLER_0_102_643 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_31_287 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_102_687 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
X_11051_ _04855_ _04856_ VGND VGND VPWR VPWR _04858_ sky130_fd_sc_hd__or2_1
X_10002_ _03712_ _03713_ _03708_ _03709_ VGND VGND VPWR VPWR _03716_ sky130_fd_sc_hd__a211o_1
XFILLER_0_98_265 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
X_10904_ _04577_ _04696_ _04697_ VGND VGND VPWR VPWR _04698_ sky130_fd_sc_hd__nand3_1
X_10835_ _04579_ _04621_ _04622_ VGND VGND VPWR VPWR _04623_ sky130_fd_sc_hd__or3_1
XFILLER_0_104_27 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XTAP_TAPCELL_ROW_67_1099 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_67_685 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
X_10766_ _04354_ _04546_ _04547_ _04450_ VGND VGND VPWR VPWR _04548_ sky130_fd_sc_hd__o211ai_4
XFILLER_0_109_242 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XFILLER_0_81_121 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XTAP_TAPCELL_ROW_80_1266 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_13_69 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
X_10697_ _04469_ _04470_ _04471_ VGND VGND VPWR VPWR _04472_ sky130_fd_sc_hd__a21o_1
XTAP_TAPCELL_ROW_30_639 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_42_519 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_82_699 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XPHY_EDGE_ROW_57_Left_179 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XTAP_TAPCELL_ROW_10_385 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_105_492 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_10_405 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_0_1_137 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_22_265 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_11318_ _05112_ _05145_ VGND VGND VPWR VPWR _05146_ sky130_fd_sc_hd__xnor2_1
X_11249_ _05067_ _05068_ _05069_ VGND VGND VPWR VPWR _05071_ sky130_fd_sc_hd__or3b_1
XTAP_TAPCELL_ROW_91_1395 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
X_05810_ net23 VGND VGND VPWR VPWR _01497_ sky130_fd_sc_hd__buf_4
XPHY_EDGE_ROW_66_Left_188 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
X_06790_ _00157_ _00215_ _00216_ VGND VGND VPWR VPWR _00217_ sky130_fd_sc_hd__nand3_4
XFILLER_0_89_265 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
X_05741_ _00613_ _00734_ VGND VGND VPWR VPWR _00744_ sky130_fd_sc_hd__nand2_1
XTAP_TAPCELL_ROW_38_739 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
X_08460_ _01894_ _01895_ _02012_ _02013_ VGND VGND VPWR VPWR _02031_ sky130_fd_sc_hd__nor4_1
XFILLER_0_77_449 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_58_641 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
X_08391_ _01952_ _01953_ _01954_ VGND VGND VPWR VPWR _01957_ sky130_fd_sc_hd__a21o_1
X_07411_ _00471_ _00881_ _00884_ _00885_ _00877_ VGND VGND VPWR VPWR _00887_ sky130_fd_sc_hd__o2111ai_4
XTAP_TAPCELL_ROW_18_485 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_92_419 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
X_07342_ _00808_ _00809_ _00801_ VGND VGND VPWR VPWR _00812_ sky130_fd_sc_hd__a21o_1
XFILLER_0_116_713 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XPHY_EDGE_ROW_75_Left_197 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_0_60_305 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
X_07273_ _00626_ _00627_ VGND VGND VPWR VPWR _00736_ sky130_fd_sc_hd__and2b_1
XFILLER_0_115_245 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
X_09012_ _02632_ _02634_ VGND VGND VPWR VPWR _02635_ sky130_fd_sc_hd__and2b_1
XFILLER_0_60_338 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_06224_ _05334_ _05355_ _05356_ VGND VGND VPWR VPWR _05357_ sky130_fd_sc_hd__nand3_2
XFILLER_0_115_278 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XFILLER_0_78_3 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
X_06155_ _05223_ _05234_ _04476_ VGND VGND VPWR VPWR _05255_ sky130_fd_sc_hd__o21a_1
XFILLER_0_111_462 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_41_596 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
X_06086_ _03594_ _03714_ VGND VGND VPWR VPWR _04509_ sky130_fd_sc_hd__nand2_1
XFILLER_0_111_484 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_09914_ _00076_ _02052_ VGND VGND VPWR VPWR _03620_ sky130_fd_sc_hd__nand2_1
X_09845_ _03026_ _04085_ _02868_ _02185_ VGND VGND VPWR VPWR _03544_ sky130_fd_sc_hd__nand4_1
XTAP_TAPCELL_ROW_107_1601 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
X_09776_ _05689_ _05585_ _01674_ _01675_ VGND VGND VPWR VPWR _03469_ sky130_fd_sc_hd__and4_1
X_06988_ _00330_ _05696_ _00423_ _02054_ VGND VGND VPWR VPWR _00425_ sky130_fd_sc_hd__a22o_1
X_08727_ _02321_ _02322_ _02323_ VGND VGND VPWR VPWR _02324_ sky130_fd_sc_hd__a21bo_1
X_05939_ _01858_ _02372_ _02885_ _02896_ VGND VGND VPWR VPWR _02907_ sky130_fd_sc_hd__or4_1
X_08658_ _02235_ _02237_ _02247_ VGND VGND VPWR VPWR _02248_ sky130_fd_sc_hd__and3_1
XFILLER_0_68_427 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
X_07609_ _01101_ _01102_ VGND VGND VPWR VPWR _01103_ sky130_fd_sc_hd__nor2_1
X_08589_ net51 VGND VGND VPWR VPWR _02173_ sky130_fd_sc_hd__clkbuf_8
X_10620_ _04387_ _04388_ VGND VGND VPWR VPWR _04389_ sky130_fd_sc_hd__or2b_1
XFILLER_0_76_493 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_10551_ _02667_ _02943_ _03491_ _02837_ VGND VGND VPWR VPWR _04315_ sky130_fd_sc_hd__a22o_1
XFILLER_0_36_357 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
X_10482_ _04236_ _04237_ _04131_ _04133_ VGND VGND VPWR VPWR _04240_ sky130_fd_sc_hd__o211a_1
XFILLER_0_64_699 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_121_215 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XTAP_TAPCELL_ROW_118_1741 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_106_289 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_0_106_267 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_0_51_349 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_32_541 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XFILLER_0_32_596 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_0_102_473 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
X_11103_ _04837_ _04838_ _04913_ VGND VGND VPWR VPWR _04914_ sky130_fd_sc_hd__o21ai_1
X_11034_ _04837_ _04838_ VGND VGND VPWR VPWR _04839_ sky130_fd_sc_hd__xnor2_1
XFILLER_0_99_552 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XTAP_TAPCELL_ROW_69_1128 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_115_15 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_99_585 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_59_416 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_0_59_449 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_74_419 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XTAP_TAPCELL_ROW_15_444 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
X_10818_ _02840_ _03489_ _04601_ _04602_ VGND VGND VPWR VPWR _04604_ sky130_fd_sc_hd__nand4_2
XFILLER_0_54_121 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XTAP_TAPCELL_ROW_15_455 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
X_10749_ _04434_ _04436_ _04527_ _04528_ VGND VGND VPWR VPWR _04529_ sky130_fd_sc_hd__a211oi_2
XFILLER_0_27_357 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XTAP_TAPCELL_ROW_43_797 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_112_248 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XTAP_TAPCELL_ROW_93_1424 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_10_224 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_49_43 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
X_07960_ _01327_ _01485_ VGND VGND VPWR VPWR net84 sky130_fd_sc_hd__xnor2_1
X_06911_ _00241_ _00253_ _00339_ VGND VGND VPWR VPWR _00341_ sky130_fd_sc_hd__a21oi_1
X_07891_ _05463_ _00387_ _05502_ _00189_ VGND VGND VPWR VPWR _01412_ sky130_fd_sc_hd__nand4_2
X_09630_ _03290_ _03307_ _03308_ VGND VGND VPWR VPWR _03309_ sky130_fd_sc_hd__and3_2
X_06842_ _00266_ _00267_ VGND VGND VPWR VPWR _00268_ sky130_fd_sc_hd__and2_1
X_09561_ _03126_ _03127_ _03213_ _03214_ VGND VGND VPWR VPWR _03234_ sky130_fd_sc_hd__nand4b_2
X_06773_ _00196_ _00198_ _00194_ VGND VGND VPWR VPWR _00200_ sky130_fd_sc_hd__a21o_1
X_08512_ _00533_ _00494_ _00612_ _00392_ VGND VGND VPWR VPWR _02089_ sky130_fd_sc_hd__a22o_1
X_05724_ net59 VGND VGND VPWR VPWR _00559_ sky130_fd_sc_hd__buf_2
X_09492_ _03155_ _03156_ _03158_ VGND VGND VPWR VPWR _03159_ sky130_fd_sc_hd__nand3_2
XTAP_TAPCELL_ROW_102_1531 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_93_717 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_0_81_96 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_77_279 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
X_08443_ _01894_ _01895_ _02012_ _02013_ VGND VGND VPWR VPWR _02014_ sky130_fd_sc_hd__or4_1
XTAP_TAPCELL_ROW_102_1542 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XPHY_EDGE_ROW_83_Left_205 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_0_18_335 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
X_08374_ _01783_ _01821_ _01822_ VGND VGND VPWR VPWR _01939_ sky130_fd_sc_hd__nor3_1
XFILLER_0_45_110 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XFILLER_0_73_441 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
X_07325_ _00660_ _00667_ VGND VGND VPWR VPWR _00793_ sky130_fd_sc_hd__or2_1
XFILLER_0_46_666 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
X_07256_ _00648_ _00649_ _00716_ _00717_ VGND VGND VPWR VPWR _00718_ sky130_fd_sc_hd__or4bb_4
XFILLER_0_45_176 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_116_598 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_103_204 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
X_06207_ _01497_ _03856_ VGND VGND VPWR VPWR _05340_ sky130_fd_sc_hd__and2_1
XFILLER_0_121_91 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_60_157 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
X_07187_ _00506_ _00630_ _00640_ VGND VGND VPWR VPWR _00642_ sky130_fd_sc_hd__and3_1
X_06138_ _03823_ _03867_ _03845_ VGND VGND VPWR VPWR _05073_ sky130_fd_sc_hd__a21bo_1
XFILLER_0_41_393 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
X_06069_ _04303_ _04270_ _04281_ VGND VGND VPWR VPWR _04325_ sky130_fd_sc_hd__nand3_1
XTAP_TAPCELL_ROW_113_1671 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XPHY_EDGE_ROW_92_Left_214 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
X_09828_ _03231_ _03377_ _03525_ VGND VGND VPWR VPWR _03526_ sky130_fd_sc_hd__o21bai_2
X_09759_ _03447_ _03448_ _03439_ VGND VGND VPWR VPWR _03450_ sky130_fd_sc_hd__a21o_1
XFILLER_0_56_419 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_83_249 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XTAP_TAPCELL_ROW_64_1058 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_49_471 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
X_10603_ _00042_ _03178_ _04258_ _04257_ _03027_ VGND VGND VPWR VPWR _04371_ sky130_fd_sc_hd__a32o_1
XTAP_TAPCELL_ROW_12_414 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_64_474 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XFILLER_0_51_113 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XTAP_TAPCELL_ROW_40_756 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_40_767 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
X_10534_ _02492_ _01353_ _01500_ _01943_ VGND VGND VPWR VPWR _04296_ sky130_fd_sc_hd__a22oi_1
XFILLER_0_10_15 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
X_10465_ _04111_ _04113_ _04219_ _04220_ VGND VGND VPWR VPWR _04221_ sky130_fd_sc_hd__a211oi_4
XFILLER_0_51_157 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
X_10396_ _04034_ VGND VGND VPWR VPWR _04146_ sky130_fd_sc_hd__inv_2
XFILLER_0_20_555 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XTAP_TAPCELL_ROW_75_1198 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_19_57 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
X_11017_ _04817_ _04818_ _04809_ VGND VGND VPWR VPWR _04820_ sky130_fd_sc_hd__a21o_1
XTAP_TAPCELL_ROW_48_856 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_48_867 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_99_393 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XFILLER_0_35_78 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_75_717 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_0_74_205 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_59_257 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_47_419 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_51_22 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_7_505 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_28_677 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XFILLER_0_43_603 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_82_260 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XFILLER_0_51_99 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
X_07110_ _00197_ VGND VGND VPWR VPWR _00558_ sky130_fd_sc_hd__clkbuf_4
XFILLER_0_43_625 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
X_08090_ _00843_ net52 net53 _02447_ VGND VGND VPWR VPWR _01628_ sky130_fd_sc_hd__a22o_1
XFILLER_0_42_135 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_0_113_557 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_0_113_535 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_0_70_488 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
X_07041_ net58 net55 net10 net11 VGND VGND VPWR VPWR _00483_ sky130_fd_sc_hd__and4_1
XFILLER_0_30_319 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XFILLER_0_23_393 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_0_2_298 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
X_08992_ _02439_ _02441_ VGND VGND VPWR VPWR _02613_ sky130_fd_sc_hd__nor2_2
XFILLER_0_76_85 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_07943_ _01428_ _01429_ _01465_ _01466_ VGND VGND VPWR VPWR _01468_ sky130_fd_sc_hd__o22ai_4
X_07874_ _01391_ _01392_ VGND VGND VPWR VPWR _01393_ sky130_fd_sc_hd__nor2_1
X_09613_ _05464_ _05553_ _02516_ VGND VGND VPWR VPWR _03291_ sky130_fd_sc_hd__and3_1
X_06825_ _00243_ _00250_ VGND VGND VPWR VPWR _00251_ sky130_fd_sc_hd__xnor2_1
X_09544_ _03128_ _03215_ VGND VGND VPWR VPWR _03216_ sky130_fd_sc_hd__xnor2_4
X_06756_ _00181_ _00182_ VGND VGND VPWR VPWR _00183_ sky130_fd_sc_hd__and2b_1
X_09475_ _02134_ _00488_ _03138_ _03139_ VGND VGND VPWR VPWR _03140_ sky130_fd_sc_hd__a22o_1
X_05707_ _00362_ VGND VGND VPWR VPWR _00373_ sky130_fd_sc_hd__clkbuf_4
X_06687_ _00053_ _00113_ _00114_ VGND VGND VPWR VPWR _00115_ sky130_fd_sc_hd__nand3_1
XFILLER_0_38_419 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
X_08426_ _01984_ _01993_ _01994_ VGND VGND VPWR VPWR _01995_ sky130_fd_sc_hd__nand3_1
XFILLER_0_93_558 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XFILLER_0_81_709 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_0_65_249 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
Xwire129 _03670_ VGND VGND VPWR VPWR net129 sky130_fd_sc_hd__clkbuf_2
XFILLER_0_73_271 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_08357_ _00089_ _00189_ _00138_ _05636_ VGND VGND VPWR VPWR _01920_ sky130_fd_sc_hd__nand4_2
XFILLER_0_46_474 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XFILLER_0_116_373 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_104_513 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_61_422 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
X_08288_ _01667_ _01834_ _01835_ VGND VGND VPWR VPWR _01844_ sky130_fd_sc_hd__nor3_1
X_07308_ _03332_ _05539_ _00139_ _03288_ VGND VGND VPWR VPWR _00774_ sky130_fd_sc_hd__a22o_1
XFILLER_0_46_496 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XTAP_TAPCELL_ROW_115_1700 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_61_488 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
X_07239_ _00696_ _00697_ _00694_ VGND VGND VPWR VPWR _00699_ sky130_fd_sc_hd__a21o_1
XFILLER_0_33_157 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_104_568 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_104_557 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
X_10250_ _03862_ _03864_ VGND VGND VPWR VPWR _03986_ sky130_fd_sc_hd__or2_1
XFILLER_0_14_393 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_10181_ _03753_ _03755_ _03910_ VGND VGND VPWR VPWR _03912_ sky130_fd_sc_hd__a21o_1
XTAP_TAPCELL_ROW_45_826 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_25_572 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_112_27 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_52_433 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_0_4_508 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_21_69 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
X_10517_ _00762_ _03341_ _04175_ _04176_ VGND VGND VPWR VPWR _04277_ sky130_fd_sc_hd__and4_1
XTAP_TAPCELL_ROW_77_1227 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_52_477 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_0_40_639 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
X_10448_ _02113_ _01849_ _04094_ _04201_ VGND VGND VPWR VPWR _04202_ sky130_fd_sc_hd__a31o_1
X_10379_ _04124_ _04125_ _04087_ VGND VGND VPWR VPWR _04127_ sky130_fd_sc_hd__a21o_1
XTAP_TAPCELL_ROW_88_1367 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_88_1356 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
X_07590_ _01079_ _01080_ _01076_ VGND VGND VPWR VPWR _01082_ sky130_fd_sc_hd__a21o_1
X_06610_ _05635_ VGND VGND VPWR VPWR _00038_ sky130_fd_sc_hd__buf_4
XFILLER_0_1_57 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
X_06541_ _05667_ _05668_ _05651_ VGND VGND VPWR VPWR _05670_ sky130_fd_sc_hd__a21oi_1
XFILLER_0_48_706 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_0_87_374 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
X_09260_ _02903_ _02905_ VGND VGND VPWR VPWR _02906_ sky130_fd_sc_hd__xor2_4
X_06472_ _05599_ _05600_ _05591_ VGND VGND VPWR VPWR _05602_ sky130_fd_sc_hd__a21o_1
XFILLER_0_63_709 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_08211_ _05557_ _01759_ VGND VGND VPWR VPWR _01761_ sky130_fd_sc_hd__nand2_1
XFILLER_0_7_313 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XFILLER_0_90_517 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
X_09191_ _02827_ _02828_ _02683_ _02685_ VGND VGND VPWR VPWR _02831_ sky130_fd_sc_hd__o211ai_2
XFILLER_0_62_219 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_43_400 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_15_113 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
X_08142_ _01670_ _01682_ VGND VGND VPWR VPWR _01685_ sky130_fd_sc_hd__and2_1
XFILLER_0_113_321 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_102_82 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XFILLER_0_102_71 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XTAP_TAPCELL_ROW_99_1496 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_31_617 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
X_08073_ _00430_ VGND VGND VPWR VPWR _01610_ sky130_fd_sc_hd__buf_4
XFILLER_0_101_505 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
X_07024_ _00463_ _00464_ VGND VGND VPWR VPWR _00465_ sky130_fd_sc_hd__xnor2_4
XFILLER_0_60_3 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_0_3_585 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_23_190 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_30_149 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_11_385 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XTAP_TAPCELL_ROW_110_1641 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
X_08975_ _02592_ _02593_ VGND VGND VPWR VPWR _02594_ sky130_fd_sc_hd__xor2_4
X_07926_ _00526_ _00548_ _01284_ _01449_ VGND VGND VPWR VPWR _01450_ sky130_fd_sc_hd__nand4_1
X_07857_ _02458_ net64 net10 net11 VGND VGND VPWR VPWR _01374_ sky130_fd_sc_hd__and4_1
X_06808_ _00158_ _00174_ _00175_ VGND VGND VPWR VPWR _00234_ sky130_fd_sc_hd__nand3_1
X_07788_ _01296_ _01297_ _01275_ VGND VGND VPWR VPWR _01299_ sky130_fd_sc_hd__a21oi_2
X_09527_ _03192_ _03017_ _03195_ _03196_ VGND VGND VPWR VPWR _03197_ sky130_fd_sc_hd__o211ai_2
X_06739_ _04737_ _05311_ VGND VGND VPWR VPWR _00166_ sky130_fd_sc_hd__nand2_1
XTAP_TAPCELL_ROW_121_1770 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
X_09458_ _03100_ _03119_ _03120_ VGND VGND VPWR VPWR _03121_ sky130_fd_sc_hd__nor3_1
XTAP_TAPCELL_ROW_61_1028 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_121_1792 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_121_1781 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_93_388 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_0_81_539 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
X_09389_ _03024_ _03025_ _03043_ _03044_ VGND VGND VPWR VPWR _03046_ sky130_fd_sc_hd__o22a_1
X_08409_ _01114_ VGND VGND VPWR VPWR _01976_ sky130_fd_sc_hd__buf_4
XTAP_TAPCELL_ROW_22_531 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_22_542 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
X_11420_ _05253_ _05254_ VGND VGND VPWR VPWR net121 sky130_fd_sc_hd__nor2_1
XFILLER_0_117_660 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_108_159 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XTAP_TAPCELL_ROW_50_884 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
X_11351_ _05178_ _05180_ VGND VGND VPWR VPWR _05182_ sky130_fd_sc_hd__xnor2_1
X_10302_ _05468_ _04040_ _04042_ _05388_ VGND VGND VPWR VPWR _04043_ sky130_fd_sc_hd__a22oi_4
X_11282_ _05103_ _05107_ VGND VGND VPWR VPWR _05108_ sky130_fd_sc_hd__and2_2
XFILLER_0_104_365 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
X_10233_ _03957_ _03967_ VGND VGND VPWR VPWR _03968_ sky130_fd_sc_hd__xnor2_2
X_10164_ _03772_ _03774_ _03891_ _03892_ VGND VGND VPWR VPWR _03893_ sky130_fd_sc_hd__o211a_2
XFILLER_0_100_560 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XTAP_TAPCELL_ROW_72_1168 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_72_1157 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
X_10095_ _02141_ _02837_ _03323_ _03324_ VGND VGND VPWR VPWR _03817_ sky130_fd_sc_hd__nand4_4
XTAP_TAPCELL_ROW_58_984 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_69_341 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
X_10997_ _04749_ _04751_ VGND VGND VPWR VPWR _04798_ sky130_fd_sc_hd__or2b_1
XFILLER_0_84_300 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_29_205 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_96_193 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_0_84_333 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XTAP_TAPCELL_ROW_83_1297 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_29_249 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_37_271 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_0_37_293 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_13_606 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_0_13_617 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_25_499 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_110_335 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_0_533 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_110_368 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_57_21 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
X_05972_ _03255_ _02677_ VGND VGND VPWR VPWR _03266_ sky130_fd_sc_hd__nand2_1
X_08760_ _01050_ _02161_ _02357_ _02358_ VGND VGND VPWR VPWR _02360_ sky130_fd_sc_hd__o2bb2a_1
X_08691_ _00084_ _01414_ _00348_ _00350_ VGND VGND VPWR VPWR _02285_ sky130_fd_sc_hd__and4_1
X_07711_ _05486_ _00354_ _01211_ _01212_ VGND VGND VPWR VPWR _01215_ sky130_fd_sc_hd__a22o_1
X_07642_ _01135_ _01139_ VGND VGND VPWR VPWR _01140_ sky130_fd_sc_hd__xor2_2
XTAP_TAPCELL_ROW_0_248 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_0_259 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
X_09312_ _02919_ _02962_ VGND VGND VPWR VPWR _02963_ sky130_fd_sc_hd__xor2_2
X_07573_ _01062_ _01063_ VGND VGND VPWR VPWR _01064_ sky130_fd_sc_hd__nand2_1
XFILLER_0_87_193 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_75_333 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
X_06524_ _03605_ _00504_ _05464_ _05553_ VGND VGND VPWR VPWR _05653_ sky130_fd_sc_hd__nand4_2
XFILLER_0_48_558 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_75_388 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
X_09243_ _02860_ _02861_ _02886_ _02887_ VGND VGND VPWR VPWR _02888_ sky130_fd_sc_hd__nand4_2
X_06455_ _05342_ VGND VGND VPWR VPWR _05585_ sky130_fd_sc_hd__buf_4
XFILLER_0_35_219 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_0_113_81 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_106_608 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_09174_ _01109_ VGND VGND VPWR VPWR _02812_ sky130_fd_sc_hd__buf_4
X_06386_ _05514_ _05515_ _05435_ _05437_ VGND VGND VPWR VPWR _05517_ sky130_fd_sc_hd__a211o_1
XFILLER_0_71_561 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_8_699 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
X_08125_ _01491_ _01665_ _01663_ VGND VGND VPWR VPWR _01666_ sky130_fd_sc_hd__o21ai_4
XFILLER_0_16_477 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_71_583 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_0_71_572 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_101_302 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XFILLER_0_31_447 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
X_08056_ _04542_ _00197_ _00301_ _04520_ VGND VGND VPWR VPWR _01591_ sky130_fd_sc_hd__a22o_1
XFILLER_0_101_324 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_0_12_683 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
X_07007_ _00313_ _00407_ _00444_ _00445_ VGND VGND VPWR VPWR _00446_ sky130_fd_sc_hd__a211oi_4
XFILLER_0_11_182 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XTAP_TAPCELL_ROW_8_359 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
X_08958_ _02426_ _02445_ _02574_ VGND VGND VPWR VPWR _02575_ sky130_fd_sc_hd__o21ba_2
X_08889_ _05307_ _05305_ _01278_ _01798_ VGND VGND VPWR VPWR _02500_ sky130_fd_sc_hd__nand4_1
X_07909_ _01270_ _01271_ VGND VGND VPWR VPWR _01431_ sky130_fd_sc_hd__or2_2
X_10920_ _04630_ _04632_ VGND VGND VPWR VPWR _04715_ sky130_fd_sc_hd__nor2_1
XTAP_TAPCELL_ROW_27_601 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
X_10851_ _04637_ _04639_ VGND VGND VPWR VPWR net108 sky130_fd_sc_hd__xnor2_4
XTAP_TAPCELL_ROW_55_954 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_93_130 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
X_10782_ _00623_ _03171_ VGND VGND VPWR VPWR _04565_ sky130_fd_sc_hd__nand2_1
XFILLER_0_66_355 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_81_314 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_93_196 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
X_11403_ _05235_ _05236_ VGND VGND VPWR VPWR _05237_ sky130_fd_sc_hd__nor2_1
XFILLER_0_50_701 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_105_641 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_22_403 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_34_263 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_0_105_685 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
X_11334_ _05119_ _05122_ _05120_ VGND VGND VPWR VPWR _05163_ sky130_fd_sc_hd__o21ba_1
XFILLER_0_34_296 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_104_195 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
X_11265_ _05018_ VGND VGND VPWR VPWR _05089_ sky130_fd_sc_hd__inv_2
X_10216_ _03835_ _03842_ _03841_ VGND VGND VPWR VPWR _03949_ sky130_fd_sc_hd__a21bo_1
XFILLER_0_120_699 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_118_15 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
X_11196_ _05011_ _05012_ VGND VGND VPWR VPWR _05014_ sky130_fd_sc_hd__nor2_1
X_10147_ _00409_ _02052_ VGND VGND VPWR VPWR _03874_ sky130_fd_sc_hd__nand2_1
X_10078_ _03673_ _03798_ VGND VGND VPWR VPWR net100 sky130_fd_sc_hd__xnor2_2
XTAP_TAPCELL_ROW_85_1326 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_57_300 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_97_491 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_85_653 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_57_355 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_0_43_89 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XFILLER_0_85_697 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_17_208 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_0_45_517 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
X_06240_ _05294_ _05371_ VGND VGND VPWR VPWR _05373_ sky130_fd_sc_hd__nand2_1
XFILLER_0_45_539 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_115_449 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_53_561 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XFILLER_0_25_241 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XFILLER_0_25_263 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
X_06171_ _03004_ VGND VGND VPWR VPWR _05304_ sky130_fd_sc_hd__clkbuf_8
XTAP_TAPCELL_ROW_96_1466 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_13_447 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_40_244 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_111_633 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
X_09930_ _03497_ _03499_ _03635_ _03636_ VGND VGND VPWR VPWR _03637_ sky130_fd_sc_hd__a211o_2
XPHY_EDGE_ROW_15_Right_15 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_0_110_187 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
X_09861_ _03286_ _03409_ _03410_ VGND VGND VPWR VPWR _03562_ sky130_fd_sc_hd__and3_1
XFILLER_0_0_374 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
X_09792_ _03261_ _03263_ VGND VGND VPWR VPWR _03487_ sky130_fd_sc_hd__nand2_1
X_08812_ _02413_ _02415_ VGND VGND VPWR VPWR _02416_ sky130_fd_sc_hd__xnor2_1
XTAP_TAPCELL_ROW_5_329 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
X_08743_ _02338_ _02340_ _02148_ _02150_ VGND VGND VPWR VPWR _02342_ sky130_fd_sc_hd__o211a_1
X_05955_ net31 VGND VGND VPWR VPWR _03080_ sky130_fd_sc_hd__clkbuf_4
XFILLER_0_84_85 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_0_23_3 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
X_08674_ _02254_ _02264_ _02265_ VGND VGND VPWR VPWR _02266_ sky130_fd_sc_hd__and3b_1
X_05886_ _02164_ _02175_ _02306_ VGND VGND VPWR VPWR _02328_ sky130_fd_sc_hd__o21ai_1
XFILLER_0_95_417 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_76_620 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_07625_ _01118_ _01119_ _01120_ VGND VGND VPWR VPWR _01121_ sky130_fd_sc_hd__nand3_1
XPHY_EDGE_ROW_24_Right_24 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XTAP_TAPCELL_ROW_105_1573 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_88_491 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
X_07556_ _01043_ _01044_ VGND VGND VPWR VPWR _01045_ sky130_fd_sc_hd__nor2_1
XTAP_TAPCELL_ROW_52_913 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_48_333 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XFILLER_0_75_152 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
X_06507_ _05635_ VGND VGND VPWR VPWR _05636_ sky130_fd_sc_hd__buf_4
XFILLER_0_48_377 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_118_265 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_118_243 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_09226_ _00340_ _01050_ _02868_ _02865_ VGND VGND VPWR VPWR _02869_ sky130_fd_sc_hd__and4_1
X_07487_ _00828_ _00849_ _00850_ VGND VGND VPWR VPWR _00970_ sky130_fd_sc_hd__nand3_2
XFILLER_0_106_427 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
X_06438_ _05559_ _05567_ VGND VGND VPWR VPWR _05568_ sky130_fd_sc_hd__xor2_2
XFILLER_0_32_701 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
X_09157_ _02650_ _02651_ _02652_ _02656_ VGND VGND VPWR VPWR _02793_ sky130_fd_sc_hd__a31o_1
XFILLER_0_16_263 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
X_06369_ _01978_ _05345_ VGND VGND VPWR VPWR _05500_ sky130_fd_sc_hd__and2_1
XFILLER_0_121_419 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
X_09088_ _02514_ _02545_ _02717_ VGND VGND VPWR VPWR _02718_ sky130_fd_sc_hd__a21oi_2
X_08108_ _01645_ _01646_ _01465_ _01575_ VGND VGND VPWR VPWR _01648_ sky130_fd_sc_hd__a211o_1
XFILLER_0_102_622 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
X_08039_ _01534_ _01535_ _01570_ _01571_ VGND VGND VPWR VPWR _01572_ sky130_fd_sc_hd__a211oi_4
XPHY_EDGE_ROW_33_Right_33 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_0_31_299 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
X_11050_ _04783_ _04785_ _04854_ VGND VGND VPWR VPWR _04856_ sky130_fd_sc_hd__and3_1
XFILLER_0_102_699 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
X_10001_ _03708_ _03709_ _03712_ _03713_ VGND VGND VPWR VPWR _03715_ sky130_fd_sc_hd__o211a_1
XPHY_EDGE_ROW_42_Right_42 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
X_10903_ _04693_ _04695_ _04675_ VGND VGND VPWR VPWR _04697_ sky130_fd_sc_hd__o21ai_1
XPHY_EDGE_ROW_103_Left_225 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_0_86_417 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
X_10834_ _04619_ _04620_ _04580_ VGND VGND VPWR VPWR _04622_ sky130_fd_sc_hd__a21oi_1
XFILLER_0_13_15 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_94_450 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XFILLER_0_66_141 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
X_10765_ _04453_ _04449_ VGND VGND VPWR VPWR _04547_ sky130_fd_sc_hd__nand2_1
XTAP_TAPCELL_ROW_80_1267 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_80_1256 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_67_697 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_66_174 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
X_10696_ _00623_ _02178_ VGND VGND VPWR VPWR _04471_ sky130_fd_sc_hd__and2_1
XFILLER_0_82_667 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_81_133 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_120_27 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XPHY_EDGE_ROW_51_Right_51 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_0_112_419 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XPHY_EDGE_ROW_112_Left_234 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XTAP_TAPCELL_ROW_10_386 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_1_105 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
X_11317_ _05142_ _05144_ VGND VGND VPWR VPWR _05145_ sky130_fd_sc_hd__xnor2_1
XFILLER_0_1_149 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_22_288 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_0_22_299 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
X_11248_ _05067_ _05068_ _05069_ VGND VGND VPWR VPWR _05070_ sky130_fd_sc_hd__o21bai_1
X_11179_ _04928_ _04932_ _04994_ VGND VGND VPWR VPWR _04996_ sky130_fd_sc_hd__and3_1
XTAP_TAPCELL_ROW_91_1396 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XPHY_EDGE_ROW_60_Right_60 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XPHY_EDGE_ROW_121_Left_243 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
X_05740_ _00701_ _00723_ VGND VGND VPWR VPWR _00734_ sky130_fd_sc_hd__or2_1
XFILLER_0_54_33 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_49_119 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_08390_ _01952_ _01953_ _01954_ VGND VGND VPWR VPWR _01955_ sky130_fd_sc_hd__nand3_1
X_07410_ _00729_ _00873_ _00879_ _00728_ VGND VGND VPWR VPWR _00885_ sky130_fd_sc_hd__a211o_1
XTAP_TAPCELL_ROW_18_486 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
X_07341_ _00801_ _00808_ _00809_ VGND VGND VPWR VPWR _00811_ sky130_fd_sc_hd__nand3_2
XFILLER_0_45_325 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
X_07272_ _00514_ _00517_ _00605_ VGND VGND VPWR VPWR _00735_ sky130_fd_sc_hd__o21ba_1
XFILLER_0_5_400 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_0_45_358 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
X_09011_ _02629_ _02630_ _02631_ VGND VGND VPWR VPWR _02634_ sky130_fd_sc_hd__a21o_1
XFILLER_0_60_317 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_0_14_701 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
X_06223_ _05352_ _05353_ _05354_ VGND VGND VPWR VPWR _05356_ sky130_fd_sc_hd__a21o_1
XFILLER_0_53_391 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
X_06154_ _04476_ _05223_ _05234_ VGND VGND VPWR VPWR _05245_ sky130_fd_sc_hd__nor3_2
XPHY_EDGE_ROW_103_Right_103 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_0_13_244 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_41_586 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
X_06085_ _03638_ _03703_ VGND VGND VPWR VPWR _04498_ sky130_fd_sc_hd__or2_1
XFILLER_0_111_474 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
X_09913_ _03615_ _03618_ VGND VGND VPWR VPWR _03619_ sky130_fd_sc_hd__xor2_2
X_09844_ _04552_ _02705_ _02185_ _04531_ VGND VGND VPWR VPWR _03543_ sky130_fd_sc_hd__a22o_1
X_09775_ _00084_ _01353_ _03238_ _00408_ VGND VGND VPWR VPWR _03468_ sky130_fd_sc_hd__a22oi_1
X_06987_ _02054_ _03201_ _05696_ _00423_ VGND VGND VPWR VPWR _00424_ sky130_fd_sc_hd__and4_1
XTAP_TAPCELL_ROW_107_1602 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
X_08726_ _02136_ _00987_ _01610_ _05319_ VGND VGND VPWR VPWR _02323_ sky130_fd_sc_hd__a22o_1
X_05938_ _02863_ _02874_ _02339_ _02414_ VGND VGND VPWR VPWR _02896_ sky130_fd_sc_hd__a211oi_2
X_08657_ _02245_ _02246_ VGND VGND VPWR VPWR _02247_ sky130_fd_sc_hd__xor2_1
XFILLER_0_68_439 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
X_05869_ _02032_ _02043_ _02120_ VGND VGND VPWR VPWR _02142_ sky130_fd_sc_hd__a21o_1
XFILLER_0_95_225 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
X_07608_ _05410_ _00686_ _01099_ _01100_ VGND VGND VPWR VPWR _01102_ sky130_fd_sc_hd__o2bb2a_1
X_08588_ _02159_ _02171_ VGND VGND VPWR VPWR _02172_ sky130_fd_sc_hd__xor2_2
XFILLER_0_48_141 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_0_49_697 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
X_07539_ _01025_ _01026_ VGND VGND VPWR VPWR _01027_ sky130_fd_sc_hd__and2_1
XFILLER_0_48_163 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
X_10550_ _03827_ _02281_ _04168_ _04167_ _03294_ VGND VGND VPWR VPWR _04313_ sky130_fd_sc_hd__a32o_1
XFILLER_0_91_442 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_0_36_347 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
X_10481_ _04131_ _04133_ _04236_ _04237_ VGND VGND VPWR VPWR _04239_ sky130_fd_sc_hd__a211oi_1
X_09209_ _02351_ VGND VGND VPWR VPWR _02850_ sky130_fd_sc_hd__buf_4
XFILLER_0_51_306 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XTAP_TAPCELL_ROW_118_1742 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_118_1731 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_32_520 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
X_11102_ _04834_ _04836_ VGND VGND VPWR VPWR _04913_ sky130_fd_sc_hd__or2b_1
X_11033_ _03827_ _01849_ VGND VGND VPWR VPWR _04838_ sky130_fd_sc_hd__nand2_1
XTAP_TAPCELL_ROW_69_1129 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_115_27 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_59_428 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_0_86_236 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
X_10817_ _02984_ _02947_ _04601_ _04602_ VGND VGND VPWR VPWR _04603_ sky130_fd_sc_hd__a22o_1
XFILLER_0_7_709 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XTAP_TAPCELL_ROW_15_445 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_39_163 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
X_10748_ _04525_ _04526_ _04438_ VGND VGND VPWR VPWR _04528_ sky130_fd_sc_hd__a21oi_1
XFILLER_0_70_604 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XTAP_TAPCELL_ROW_43_798 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
X_10679_ _04345_ _04346_ _04349_ VGND VGND VPWR VPWR _04453_ sky130_fd_sc_hd__and3_1
XFILLER_0_113_717 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_0_2_403 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_35_391 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XTAP_TAPCELL_ROW_93_1425 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_50_350 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_2_425 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_2_436 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XFILLER_0_49_55 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_10_236 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_120_293 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
X_06910_ _00251_ _00252_ VGND VGND VPWR VPWR _00339_ sky130_fd_sc_hd__and2b_1
X_07890_ net5 _05502_ _05593_ _05318_ VGND VGND VPWR VPWR _01410_ sky130_fd_sc_hd__a22o_1
X_06841_ _03791_ _05467_ _00264_ _00265_ VGND VGND VPWR VPWR _00267_ sky130_fd_sc_hd__a22o_1
X_09560_ _03123_ _03126_ VGND VGND VPWR VPWR _03232_ sky130_fd_sc_hd__nor2_1
X_06772_ _00194_ _00196_ _00198_ VGND VGND VPWR VPWR _00199_ sky130_fd_sc_hd__nand3_1
X_09491_ _02983_ _02991_ _02990_ VGND VGND VPWR VPWR _03158_ sky130_fd_sc_hd__a21bo_1
X_08511_ _00533_ _00392_ _00612_ VGND VGND VPWR VPWR _02088_ sky130_fd_sc_hd__and3_1
X_05723_ _00537_ VGND VGND VPWR VPWR _00548_ sky130_fd_sc_hd__buf_4
XFILLER_0_77_225 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
X_08442_ _02009_ _02010_ _01896_ _01828_ VGND VGND VPWR VPWR _02013_ sky130_fd_sc_hd__a211oi_2
XTAP_TAPCELL_ROW_102_1543 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_102_1532 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
X_08373_ _01936_ _01937_ VGND VGND VPWR VPWR _01938_ sky130_fd_sc_hd__nand2_1
XFILLER_0_85_291 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_0_73_431 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
X_07324_ _00665_ _00666_ VGND VGND VPWR VPWR _00792_ sky130_fd_sc_hd__nand2_1
XFILLER_0_46_645 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_0_116_533 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_90_3 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_61_615 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
X_07255_ _00714_ _00715_ _00582_ _00650_ VGND VGND VPWR VPWR _00717_ sky130_fd_sc_hd__a211o_1
X_06206_ _05335_ _05338_ VGND VGND VPWR VPWR _05339_ sky130_fd_sc_hd__xnor2_2
XFILLER_0_103_216 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_5_296 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
X_07186_ _00506_ _00630_ _00640_ VGND VGND VPWR VPWR _00641_ sky130_fd_sc_hd__a21oi_4
X_06137_ _05019_ _05041_ _04987_ VGND VGND VPWR VPWR _05062_ sky130_fd_sc_hd__a21o_1
X_06068_ _04270_ _04281_ _04303_ VGND VGND VPWR VPWR _04314_ sky130_fd_sc_hd__a21o_1
XTAP_TAPCELL_ROW_113_1672 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_1_491 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
X_09827_ _03373_ _03375_ VGND VGND VPWR VPWR _03525_ sky130_fd_sc_hd__and2b_1
X_09758_ _03439_ _03447_ _03448_ VGND VGND VPWR VPWR _03449_ sky130_fd_sc_hd__nand3_1
XFILLER_0_68_203 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
X_08709_ _02298_ _02301_ _02303_ VGND VGND VPWR VPWR _02304_ sky130_fd_sc_hd__nand3_1
X_09689_ _03216_ _03218_ VGND VGND VPWR VPWR _03374_ sky130_fd_sc_hd__or2_1
XFILLER_0_96_589 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XTAP_TAPCELL_ROW_64_1059 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_49_483 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
X_10602_ _04366_ _04369_ VGND VGND VPWR VPWR _04370_ sky130_fd_sc_hd__nor2_1
XFILLER_0_107_511 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_76_291 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XTAP_TAPCELL_ROW_12_415 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_36_122 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
X_10533_ _04185_ _04184_ VGND VGND VPWR VPWR _04295_ sky130_fd_sc_hd__or2b_1
XFILLER_0_36_177 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XTAP_TAPCELL_ROW_40_757 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_40_768 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_10_27 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_107_599 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
X_10464_ _04217_ _04218_ _04208_ VGND VGND VPWR VPWR _04220_ sky130_fd_sc_hd__a21oi_2
X_10395_ _04144_ VGND VGND VPWR VPWR _04145_ sky130_fd_sc_hd__inv_2
XTAP_TAPCELL_ROW_75_1199 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_20_589 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_11016_ _04809_ _04817_ _04818_ VGND VGND VPWR VPWR _04819_ sky130_fd_sc_hd__nand3_1
XFILLER_0_87_501 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_0_35_35 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XTAP_TAPCELL_ROW_48_857 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_48_868 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_59_236 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_27_111 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_15_317 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_27_155 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XFILLER_0_43_615 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_113_503 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_27_188 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_43_637 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_07040_ _00381_ _00382_ _00402_ _00403_ VGND VGND VPWR VPWR _00481_ sky130_fd_sc_hd__o211ai_2
XFILLER_0_101_709 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_51_692 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_0_100_208 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
X_08991_ _02609_ _02610_ VGND VGND VPWR VPWR _02612_ sky130_fd_sc_hd__or2b_2
X_07942_ _01428_ _01429_ _01465_ _01466_ VGND VGND VPWR VPWR _01467_ sky130_fd_sc_hd__or4_2
X_07873_ _00533_ _00033_ _01388_ _01390_ VGND VGND VPWR VPWR _01392_ sky130_fd_sc_hd__o2bb2a_1
X_09612_ _03197_ _03199_ VGND VGND VPWR VPWR _03290_ sky130_fd_sc_hd__nand2_1
X_06824_ _00248_ _00249_ VGND VGND VPWR VPWR _00250_ sky130_fd_sc_hd__and2_1
X_09543_ _03213_ _03214_ VGND VGND VPWR VPWR _03215_ sky130_fd_sc_hd__nand2_2
X_06755_ _03124_ _05341_ _05343_ _04802_ VGND VGND VPWR VPWR _00182_ sky130_fd_sc_hd__a22o_1
XFILLER_0_78_589 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
X_09474_ _00558_ _00343_ _00987_ _00345_ VGND VGND VPWR VPWR _03139_ sky130_fd_sc_hd__nand4_1
X_05706_ _00351_ VGND VGND VPWR VPWR _00362_ sky130_fd_sc_hd__buf_2
X_06686_ _00111_ _00112_ _00010_ _00012_ VGND VGND VPWR VPWR _00114_ sky130_fd_sc_hd__o211ai_2
XFILLER_0_93_526 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
X_08425_ _01990_ _01991_ _01992_ VGND VGND VPWR VPWR _01994_ sky130_fd_sc_hd__a21o_1
X_08356_ _00189_ _00138_ _05636_ _00086_ VGND VGND VPWR VPWR _01919_ sky130_fd_sc_hd__a22o_1
XFILLER_0_46_431 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_61_401 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_18_177 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_07307_ _04726_ _05676_ _00138_ _05636_ VGND VGND VPWR VPWR _00773_ sky130_fd_sc_hd__nand4_2
X_08287_ _01666_ _01843_ VGND VGND VPWR VPWR net86 sky130_fd_sc_hd__xnor2_4
XFILLER_0_116_385 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XTAP_TAPCELL_ROW_115_1701 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
X_07238_ _00694_ _00696_ _00697_ VGND VGND VPWR VPWR _00698_ sky130_fd_sc_hd__nand3_1
XFILLER_0_33_169 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
X_07169_ _02666_ _00354_ _00620_ _00621_ VGND VGND VPWR VPWR _00622_ sky130_fd_sc_hd__and4_1
XFILLER_0_14_361 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
X_10180_ _00283_ _02228_ _03756_ VGND VGND VPWR VPWR _03910_ sky130_fd_sc_hd__and3_1
XFILLER_0_88_309 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XTAP_TAPCELL_ROW_45_827 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_96_397 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_0_56_239 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XTAP_TAPCELL_ROW_25_573 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_21_15 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_25_615 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_25_626 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_25_648 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
X_10516_ _00152_ _00237_ _03440_ _04275_ VGND VGND VPWR VPWR _04276_ sky130_fd_sc_hd__and4_1
XTAP_TAPCELL_ROW_77_1228 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_12_309 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
X_10447_ _04092_ _04093_ VGND VGND VPWR VPWR _04201_ sky130_fd_sc_hd__and2b_1
XFILLER_0_110_506 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
X_10378_ _04087_ _04124_ _04125_ VGND VGND VPWR VPWR _04126_ sky130_fd_sc_hd__nand3_2
XFILLER_0_103_591 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XFILLER_0_20_353 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XTAP_TAPCELL_ROW_88_1357 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_99_180 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XTAP_TAPCELL_ROW_88_1368 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_87_331 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_0_87_320 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_1_69 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
X_06540_ _05651_ _05667_ _05668_ VGND VGND VPWR VPWR _05669_ sky130_fd_sc_hd__and3_1
XFILLER_0_87_386 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_62_66 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
X_06471_ _05591_ _05599_ _05600_ VGND VGND VPWR VPWR _05601_ sky130_fd_sc_hd__nand3_1
XFILLER_0_117_105 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_0_75_559 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_62_99 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
X_08210_ _00421_ VGND VGND VPWR VPWR _01759_ sky130_fd_sc_hd__clkbuf_4
X_09190_ _02683_ _02685_ _02827_ _02828_ VGND VGND VPWR VPWR _02829_ sky130_fd_sc_hd__a211o_1
XFILLER_0_7_325 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_16_604 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_28_475 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_55_294 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_15_103 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_08141_ _01670_ _01682_ VGND VGND VPWR VPWR _01684_ sky130_fd_sc_hd__nor2_1
XFILLER_0_15_169 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_0_31_607 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
X_08072_ _01443_ _01445_ _01651_ _01109_ VGND VGND VPWR VPWR _01609_ sky130_fd_sc_hd__and4b_1
XTAP_TAPCELL_ROW_99_1497 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
X_07023_ _00223_ _00333_ _00331_ VGND VGND VPWR VPWR _00464_ sky130_fd_sc_hd__a21o_1
XFILLER_0_11_81 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_113_399 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_101_539 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_0_101_517 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_3_597 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_11_364 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XTAP_TAPCELL_ROW_110_1631 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
X_08974_ _00515_ _02227_ VGND VGND VPWR VPWR _02593_ sky130_fd_sc_hd__nand2_2
XTAP_TAPCELL_ROW_110_1642 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XPHY_EDGE_ROW_89_Right_89 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
X_07925_ net52 VGND VGND VPWR VPWR _01449_ sky130_fd_sc_hd__clkbuf_4
X_07856_ _03343_ _00485_ _00235_ _03376_ VGND VGND VPWR VPWR _01373_ sky130_fd_sc_hd__a22oi_1
XFILLER_0_97_139 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_06807_ _01356_ _00152_ _00149_ VGND VGND VPWR VPWR _00233_ sky130_fd_sc_hd__and3_2
X_07787_ _01275_ _01296_ _01297_ VGND VGND VPWR VPWR _01298_ sky130_fd_sc_hd__and3_1
X_09526_ _05311_ _02174_ _03193_ _03194_ VGND VGND VPWR VPWR _03196_ sky130_fd_sc_hd__nand4_4
X_06738_ _00163_ _00164_ VGND VGND VPWR VPWR _00165_ sky130_fd_sc_hd__and2_2
X_09457_ _03117_ _03118_ _02954_ _03101_ VGND VGND VPWR VPWR _03120_ sky130_fd_sc_hd__a211oi_2
XTAP_TAPCELL_ROW_121_1771 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_109_617 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XPHY_EDGE_ROW_98_Right_98 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XTAP_TAPCELL_ROW_61_1029 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
X_06669_ _00093_ _00095_ _00096_ VGND VGND VPWR VPWR _00097_ sky130_fd_sc_hd__nand3_1
X_08408_ _01966_ _01974_ VGND VGND VPWR VPWR _01975_ sky130_fd_sc_hd__xnor2_1
XTAP_TAPCELL_ROW_121_1793 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_121_1782 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_108_138 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
X_09388_ _03024_ _03025_ _03043_ _03044_ VGND VGND VPWR VPWR _03045_ sky130_fd_sc_hd__nor4_1
XTAP_TAPCELL_ROW_22_532 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_22_543 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
X_08339_ _00392_ _00494_ _01060_ _05676_ VGND VGND VPWR VPWR _01900_ sky130_fd_sc_hd__a22o_1
XTAP_TAPCELL_ROW_50_885 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_19_486 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
X_11350_ _05140_ _05179_ VGND VGND VPWR VPWR _05180_ sky130_fd_sc_hd__or2_1
XFILLER_0_61_242 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_61_231 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
X_10301_ _03027_ VGND VGND VPWR VPWR _04042_ sky130_fd_sc_hd__clkbuf_4
XFILLER_0_61_264 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_21_117 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
X_11281_ _04870_ _04999_ _05102_ _05104_ _05105_ VGND VGND VPWR VPWR _05107_ sky130_fd_sc_hd__o311a_1
XFILLER_0_104_377 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
X_10232_ _03964_ _03966_ VGND VGND VPWR VPWR _03967_ sky130_fd_sc_hd__or2b_1
X_10163_ _03888_ _03890_ _03767_ _03770_ VGND VGND VPWR VPWR _03892_ sky130_fd_sc_hd__o211ai_2
XTAP_TAPCELL_ROW_72_1158 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
X_10094_ _02837_ _00747_ _00914_ _02320_ VGND VGND VPWR VPWR _03816_ sky130_fd_sc_hd__a22o_1
XTAP_TAPCELL_ROW_58_985 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_69_331 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XTAP_TAPCELL_ROW_2_290 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
X_10996_ _04796_ _04797_ VGND VGND VPWR VPWR net111 sky130_fd_sc_hd__xnor2_4
XFILLER_0_97_673 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_96_172 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_0_69_397 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_84_323 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_57_559 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XTAP_TAPCELL_ROW_83_1298 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_72_529 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_0_25_445 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_0_40_459 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_110_347 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_21_673 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_20_194 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XFILLER_0_57_55 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
X_05971_ _01486_ VGND VGND VPWR VPWR _03255_ sky130_fd_sc_hd__buf_4
X_07710_ _05486_ net13 _01211_ _01212_ VGND VGND VPWR VPWR _01213_ sky130_fd_sc_hd__and4_1
X_08690_ _02280_ _02282_ VGND VGND VPWR VPWR _02283_ sky130_fd_sc_hd__xor2_2
XFILLER_0_73_43 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
X_07641_ _00187_ _01136_ _01137_ VGND VGND VPWR VPWR _01139_ sky130_fd_sc_hd__a21bo_1
XFILLER_0_25_7 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
X_07572_ _03605_ _00494_ _00612_ _00668_ VGND VGND VPWR VPWR _01063_ sky130_fd_sc_hd__a22o_1
XTAP_TAPCELL_ROW_0_249 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
X_09311_ _02936_ _02960_ VGND VGND VPWR VPWR _02962_ sky130_fd_sc_hd__xnor2_2
XFILLER_0_75_301 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
X_06523_ _03605_ _05551_ _05553_ _00908_ VGND VGND VPWR VPWR _05652_ sky130_fd_sc_hd__a22o_1
XFILLER_0_118_403 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_8_601 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
X_09242_ _02882_ _02883_ _02884_ VGND VGND VPWR VPWR _02887_ sky130_fd_sc_hd__o21bai_1
XFILLER_0_63_518 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_0_8_645 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_7_111 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
X_06454_ _05575_ _05583_ VGND VGND VPWR VPWR _05584_ sky130_fd_sc_hd__xnor2_2
XFILLER_0_118_458 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_90_326 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
X_09173_ _02642_ _02647_ VGND VGND VPWR VPWR _02811_ sky130_fd_sc_hd__nand2_1
X_06385_ _05435_ _05437_ _05514_ _05515_ VGND VGND VPWR VPWR _05516_ sky130_fd_sc_hd__o211ai_4
XFILLER_0_113_93 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_105_108 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
X_08124_ _01491_ _01665_ VGND VGND VPWR VPWR net85 sky130_fd_sc_hd__xor2_1
XFILLER_0_16_456 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_43_253 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_98_40 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_0_16_489 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_43_275 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_0_98_95 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_3_361 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
X_08055_ _04520_ _04063_ _00197_ VGND VGND VPWR VPWR _01590_ sky130_fd_sc_hd__and3_1
X_07006_ _00442_ _00443_ _00420_ VGND VGND VPWR VPWR _00445_ sky130_fd_sc_hd__a21oi_2
XFILLER_0_12_695 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
X_08957_ _02443_ _02444_ VGND VGND VPWR VPWR _02574_ sky130_fd_sc_hd__nor2_1
X_08888_ _04074_ _01278_ _01798_ _03015_ VGND VGND VPWR VPWR _02499_ sky130_fd_sc_hd__a22o_1
X_07908_ _01275_ _01296_ _01297_ VGND VGND VPWR VPWR _01430_ sky130_fd_sc_hd__nand3_2
X_07839_ _01353_ VGND VGND VPWR VPWR _01354_ sky130_fd_sc_hd__buf_2
XTAP_TAPCELL_ROW_27_602 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
X_10850_ _04540_ _04638_ _04538_ VGND VGND VPWR VPWR _04639_ sky130_fd_sc_hd__a21oi_2
XFILLER_0_79_640 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XTAP_TAPCELL_ROW_55_944 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_79_673 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XTAP_TAPCELL_ROW_55_955 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_94_632 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_10781_ _01379_ _00236_ _02705_ _02185_ VGND VGND VPWR VPWR _04564_ sky130_fd_sc_hd__and4_2
X_09509_ _03583_ _03172_ _03174_ _03176_ VGND VGND VPWR VPWR _03177_ sky130_fd_sc_hd__a22o_1
XFILLER_0_78_194 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XFILLER_0_54_529 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XPHY_EDGE_ROW_117_Right_117 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_0_109_469 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
X_11402_ _05229_ _05203_ _05233_ VGND VGND VPWR VPWR _05236_ sky130_fd_sc_hd__a21oi_1
XFILLER_0_19_294 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_34_220 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_104_130 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_50_713 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_0_105_697 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
X_11333_ _05160_ _05161_ VGND VGND VPWR VPWR _05162_ sky130_fd_sc_hd__xor2_1
XFILLER_0_120_645 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
X_11264_ _05079_ _05087_ VGND VGND VPWR VPWR _05088_ sky130_fd_sc_hd__xor2_1
X_10215_ _03945_ _03946_ _03938_ VGND VGND VPWR VPWR _03948_ sky130_fd_sc_hd__a21o_1
XFILLER_0_30_470 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_0_30_492 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
X_11195_ _05011_ _05012_ VGND VGND VPWR VPWR _05013_ sky130_fd_sc_hd__and2_1
XFILLER_0_118_27 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
X_10146_ _03870_ _03872_ VGND VGND VPWR VPWR _03873_ sky130_fd_sc_hd__xor2_2
XFILLER_0_100_391 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
X_10077_ _03796_ _03797_ VGND VGND VPWR VPWR _03798_ sky130_fd_sc_hd__and2b_1
XTAP_TAPCELL_ROW_85_1327 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_43_46 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_10979_ _04776_ _04777_ _04693_ _04739_ VGND VGND VPWR VPWR _04779_ sky130_fd_sc_hd__a211o_1
XFILLER_0_43_57 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_85_665 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_0_84_197 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_0_57_389 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_0_45_529 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_0_108_480 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_72_348 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_25_253 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_25_275 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
X_06170_ _04759_ _05301_ _04835_ _05302_ VGND VGND VPWR VPWR _05303_ sky130_fd_sc_hd__a31oi_2
XTAP_TAPCELL_ROW_96_1467 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_96_1456 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_7_13 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XFILLER_0_68_21 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XFILLER_0_7_57 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
X_09860_ _03453_ _03455_ VGND VGND VPWR VPWR _03560_ sky130_fd_sc_hd__and2_1
XTAP_TAPCELL_ROW_5_319 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
X_09791_ _03328_ _03337_ _03336_ VGND VGND VPWR VPWR _03486_ sky130_fd_sc_hd__a21o_1
X_08811_ _03616_ _01680_ VGND VGND VPWR VPWR _02415_ sky130_fd_sc_hd__nand2_1
X_08742_ _02148_ _02150_ _02338_ _02340_ VGND VGND VPWR VPWR _02341_ sky130_fd_sc_hd__a211oi_4
X_05954_ _02568_ _02589_ VGND VGND VPWR VPWR _03070_ sky130_fd_sc_hd__nor2_1
X_08673_ _02261_ _02263_ _02255_ VGND VGND VPWR VPWR _02265_ sky130_fd_sc_hd__a21o_1
X_05885_ _02164_ _02175_ _02306_ VGND VGND VPWR VPWR _02317_ sky130_fd_sc_hd__or3_1
X_07624_ _00990_ _00993_ _00992_ VGND VGND VPWR VPWR _01120_ sky130_fd_sc_hd__a21bo_1
XFILLER_0_95_429 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XTAP_TAPCELL_ROW_105_1574 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_76_643 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
X_07555_ _01247_ _00395_ _00895_ _01041_ VGND VGND VPWR VPWR _01044_ sky130_fd_sc_hd__and4_2
XTAP_TAPCELL_ROW_52_914 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_75_164 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_0_75_131 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
X_07486_ _00966_ _00967_ _00808_ _00811_ VGND VGND VPWR VPWR _00969_ sky130_fd_sc_hd__o211a_1
X_06506_ net8 VGND VGND VPWR VPWR _05635_ sky130_fd_sc_hd__clkbuf_4
XFILLER_0_91_635 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XFILLER_0_63_337 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
X_09225_ _01987_ VGND VGND VPWR VPWR _02868_ sky130_fd_sc_hd__buf_4
XFILLER_0_8_464 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
X_06437_ _05565_ _05566_ VGND VGND VPWR VPWR _05567_ sky130_fd_sc_hd__nand2_1
XTAP_TAPCELL_ROW_32_660 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_48_389 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_118_277 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_106_417 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_0_16_242 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
X_09156_ _02750_ _02791_ VGND VGND VPWR VPWR _02792_ sky130_fd_sc_hd__xnor2_4
XFILLER_0_16_275 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
X_06368_ _05496_ _05498_ VGND VGND VPWR VPWR _05499_ sky130_fd_sc_hd__xor2_2
XFILLER_0_32_713 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
X_09087_ _02544_ _02542_ VGND VGND VPWR VPWR _02717_ sky130_fd_sc_hd__and2b_1
X_08107_ _01465_ net155 _01645_ _01646_ VGND VGND VPWR VPWR _01647_ sky130_fd_sc_hd__o211ai_4
XFILLER_0_31_212 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
X_06299_ _05427_ _05428_ _05429_ VGND VGND VPWR VPWR _05431_ sky130_fd_sc_hd__a21o_1
XFILLER_0_114_494 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_101_111 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_4_681 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
X_08038_ net163 _01569_ _01426_ _01536_ VGND VGND VPWR VPWR _01571_ sky130_fd_sc_hd__o211a_1
XFILLER_0_101_177 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
X_10000_ _00762_ _01606_ _03710_ _03711_ VGND VGND VPWR VPWR _03713_ sky130_fd_sc_hd__nand4_1
X_09989_ _03554_ _03555_ _03557_ VGND VGND VPWR VPWR _03701_ sky130_fd_sc_hd__or3_2
X_10902_ _04675_ _04693_ _04695_ VGND VGND VPWR VPWR _04696_ sky130_fd_sc_hd__or3_2
X_10833_ _04580_ _04619_ _04620_ VGND VGND VPWR VPWR _04621_ sky130_fd_sc_hd__and3_1
X_10764_ _04350_ _04451_ VGND VGND VPWR VPWR _04546_ sky130_fd_sc_hd__nand2_1
XFILLER_0_104_29 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_82_613 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_13_27 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XTAP_TAPCELL_ROW_80_1268 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_80_1257 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
X_10695_ _00348_ _00350_ _03171_ _02862_ VGND VGND VPWR VPWR _04470_ sky130_fd_sc_hd__nand4_1
XFILLER_0_82_679 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_81_156 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_0_81_145 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_35_551 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_0_112_409 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XFILLER_0_50_543 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_22_234 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
X_11316_ _05091_ _05143_ VGND VGND VPWR VPWR _05144_ sky130_fd_sc_hd__nor2_1
XFILLER_0_105_472 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XTAP_TAPCELL_ROW_10_387 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_120_464 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XFILLER_0_50_587 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
X_11247_ _04374_ _05022_ _05025_ _05024_ _04732_ VGND VGND VPWR VPWR _05069_ sky130_fd_sc_hd__a32o_1
X_11178_ _04928_ _04932_ _04994_ VGND VGND VPWR VPWR _04995_ sky130_fd_sc_hd__a21oi_1
XTAP_TAPCELL_ROW_91_1397 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
X_10129_ _03851_ _03852_ _03815_ _03732_ VGND VGND VPWR VPWR _03854_ sky130_fd_sc_hd__a211o_1
XFILLER_0_89_223 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_58_621 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_70_33 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XTAP_TAPCELL_ROW_18_487 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
X_07340_ _00806_ _00807_ _00803_ _00663_ VGND VGND VPWR VPWR _00809_ sky130_fd_sc_hd__a211o_1
XFILLER_0_70_77 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_58_698 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XFILLER_0_45_304 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_72_145 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_09010_ _02629_ _02630_ _02631_ VGND VGND VPWR VPWR _02632_ sky130_fd_sc_hd__and3_1
X_07271_ _00731_ _00733_ VGND VGND VPWR VPWR net79 sky130_fd_sc_hd__xor2_4
XFILLER_0_5_445 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_0_13_201 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_14_713 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_0_26_562 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_26_584 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
X_06222_ _05352_ _05353_ _05354_ VGND VGND VPWR VPWR _05355_ sky130_fd_sc_hd__nand3_4
XFILLER_0_79_31 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
X_06153_ _05202_ _05213_ _04009_ _04487_ VGND VGND VPWR VPWR _05234_ sky130_fd_sc_hd__a211oi_2
XFILLER_0_110_83 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
X_06084_ _04009_ _04020_ _04129_ VGND VGND VPWR VPWR _04487_ sky130_fd_sc_hd__nor3_1
X_09912_ _00076_ _02236_ _03475_ _03617_ VGND VGND VPWR VPWR _03618_ sky130_fd_sc_hd__a31o_1
XFILLER_0_1_673 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
X_09843_ _03540_ _03541_ VGND VGND VPWR VPWR _03542_ sky130_fd_sc_hd__and2_1
XFILLER_0_119_81 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_95_85 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
X_09774_ _03254_ _03273_ _03274_ VGND VGND VPWR VPWR _03467_ sky130_fd_sc_hd__or3_2
X_06986_ net41 VGND VGND VPWR VPWR _00423_ sky130_fd_sc_hd__buf_2
XTAP_TAPCELL_ROW_107_1603 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
X_08725_ _05319_ _05387_ _00987_ VGND VGND VPWR VPWR _02322_ sky130_fd_sc_hd__and3_1
X_05937_ _02339_ _02414_ _02863_ _02874_ VGND VGND VPWR VPWR _02885_ sky130_fd_sc_hd__o211a_1
X_08656_ _00472_ _02045_ VGND VGND VPWR VPWR _02246_ sky130_fd_sc_hd__nand2_1
X_05868_ _02032_ _02043_ _02120_ VGND VGND VPWR VPWR _02131_ sky130_fd_sc_hd__nand3_1
XTAP_TAPCELL_ROW_37_730 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
X_07607_ _01099_ _01100_ _02764_ _00686_ VGND VGND VPWR VPWR _01101_ sky130_fd_sc_hd__and4bb_1
X_08587_ _02169_ _02170_ VGND VGND VPWR VPWR _02171_ sky130_fd_sc_hd__and2b_1
XTAP_TAPCELL_ROW_66_1090 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
X_05799_ _01367_ _01302_ VGND VGND VPWR VPWR _01378_ sky130_fd_sc_hd__xnor2_1
XFILLER_0_49_676 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
X_07538_ net132 _01024_ _00867_ _00890_ VGND VGND VPWR VPWR _01026_ sky130_fd_sc_hd__o211ai_1
XFILLER_0_76_473 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_0_36_326 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_0_17_540 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
X_07469_ _05341_ _05345_ _05550_ _00387_ VGND VGND VPWR VPWR _00950_ sky130_fd_sc_hd__and4_1
XFILLER_0_48_197 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
X_10480_ _04234_ _04235_ _04124_ _04126_ VGND VGND VPWR VPWR _04237_ sky130_fd_sc_hd__o211a_1
X_09208_ _04585_ _02351_ _02847_ _02848_ VGND VGND VPWR VPWR _02849_ sky130_fd_sc_hd__nand4_4
XFILLER_0_51_318 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_17_584 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XTAP_TAPCELL_ROW_118_1743 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_118_1732 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_72_690 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_09139_ _05689_ _02060_ _01040_ _00533_ VGND VGND VPWR VPWR _02773_ sky130_fd_sc_hd__a22o_1
XFILLER_0_121_239 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_0_102_431 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_11101_ _04909_ _04910_ VGND VGND VPWR VPWR _04912_ sky130_fd_sc_hd__or2_1
XFILLER_0_5_3 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
X_11032_ _04834_ _04836_ VGND VGND VPWR VPWR _04837_ sky130_fd_sc_hd__xor2_1
XTAP_TAPCELL_ROW_69_1119 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_99_598 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_0_86_204 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_24_15 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_115_39 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
X_10816_ _03006_ _03490_ _03012_ _03491_ VGND VGND VPWR VPWR _04602_ sky130_fd_sc_hd__nand4_2
XFILLER_0_67_495 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XTAP_TAPCELL_ROW_15_446 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
X_10747_ _04438_ _04525_ _04526_ VGND VGND VPWR VPWR _04527_ sky130_fd_sc_hd__and3_1
XFILLER_0_55_646 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XTAP_TAPCELL_ROW_43_799 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
X_10678_ _04350_ VGND VGND VPWR VPWR _04452_ sky130_fd_sc_hd__inv_2
XFILLER_0_70_616 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XFILLER_0_42_307 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XTAP_TAPCELL_ROW_93_1426 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_120_250 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XFILLER_0_10_248 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
X_06840_ _03791_ _05655_ _00264_ _00265_ VGND VGND VPWR VPWR _00266_ sky130_fd_sc_hd__nand4_2
XFILLER_0_65_55 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
X_06771_ _00548_ _00094_ _00197_ _00526_ VGND VGND VPWR VPWR _00198_ sky130_fd_sc_hd__a22o_1
X_09490_ _03153_ _03154_ _03147_ VGND VGND VPWR VPWR _03156_ sky130_fd_sc_hd__a21o_1
XFILLER_0_77_204 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
X_05722_ net12 VGND VGND VPWR VPWR _00537_ sky130_fd_sc_hd__buf_4
X_08510_ _01926_ _01927_ _01928_ _01931_ VGND VGND VPWR VPWR _02086_ sky130_fd_sc_hd__a31o_1
X_08441_ _01896_ _01828_ _02009_ _02010_ VGND VGND VPWR VPWR _02012_ sky130_fd_sc_hd__o211a_2
XFILLER_0_46_602 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XTAP_TAPCELL_ROW_102_1533 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_58_484 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_0_58_473 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_0_18_315 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
X_08372_ _01933_ _01934_ _01897_ _01748_ VGND VGND VPWR VPWR _01937_ sky130_fd_sc_hd__a211o_1
XFILLER_0_46_613 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
X_07323_ _00672_ _00673_ _00711_ _00713_ VGND VGND VPWR VPWR _00791_ sky130_fd_sc_hd__nor4_1
XFILLER_0_18_348 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_45_145 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_73_465 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
X_07254_ _00582_ net159 _00714_ _00715_ VGND VGND VPWR VPWR _00716_ sky130_fd_sc_hd__o211ai_4
XFILLER_0_116_589 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_0_83_3 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XFILLER_0_54_690 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_14_510 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
X_06205_ _05336_ _05337_ VGND VGND VPWR VPWR _05338_ sky130_fd_sc_hd__and2b_1
XFILLER_0_14_554 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
X_07185_ _00631_ _00639_ VGND VGND VPWR VPWR _00640_ sky130_fd_sc_hd__xnor2_2
X_06136_ _04987_ _05019_ _05041_ VGND VGND VPWR VPWR _05052_ sky130_fd_sc_hd__nand3_1
X_06067_ _02907_ _04292_ VGND VGND VPWR VPWR _04303_ sky130_fd_sc_hd__or2_1
XTAP_TAPCELL_ROW_113_1673 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
X_09826_ _03387_ _03523_ VGND VGND VPWR VPWR _03524_ sky130_fd_sc_hd__xor2_4
X_09757_ _03445_ _03446_ _03442_ VGND VGND VPWR VPWR _03448_ sky130_fd_sc_hd__a21o_1
X_06969_ _00381_ _00382_ _00402_ _00403_ VGND VGND VPWR VPWR _00404_ sky130_fd_sc_hd__o211a_1
X_08708_ _02302_ _00034_ _02299_ _02300_ VGND VGND VPWR VPWR _02303_ sky130_fd_sc_hd__nand4_2
XFILLER_0_96_524 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
X_09688_ _03371_ _03372_ VGND VGND VPWR VPWR _03373_ sky130_fd_sc_hd__nand2_4
XFILLER_0_84_719 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
X_08639_ _02051_ VGND VGND VPWR VPWR _02227_ sky130_fd_sc_hd__buf_4
XFILLER_0_76_270 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_0_37_613 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
X_10601_ _00042_ _03027_ _04367_ VGND VGND VPWR VPWR _04369_ sky130_fd_sc_hd__and3_1
XFILLER_0_64_421 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XTAP_TAPCELL_ROW_12_416 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
X_10532_ _04223_ _04225_ VGND VGND VPWR VPWR _04294_ sky130_fd_sc_hd__or2b_1
XFILLER_0_9_592 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_9_581 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_0_24_307 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XTAP_TAPCELL_ROW_40_758 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_51_137 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_17_381 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_10463_ _04208_ _04217_ _04218_ VGND VGND VPWR VPWR _04219_ sky130_fd_sc_hd__and3_2
X_10394_ _03663_ _03798_ _04036_ _04035_ VGND VGND VPWR VPWR _04144_ sky130_fd_sc_hd__and4b_2
XFILLER_0_102_250 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XPHY_EDGE_ROW_8_Left_130 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_0_19_15 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_20_579 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_11015_ _04815_ _04816_ _04811_ VGND VGND VPWR VPWR _04818_ sky130_fd_sc_hd__a21o_1
XTAP_TAPCELL_ROW_48_858 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_35_69 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XFILLER_0_55_410 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XFILLER_0_67_281 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_0_82_240 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_70_435 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_70_413 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_0_42_126 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XFILLER_0_113_515 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_11_502 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XFILLER_0_11_546 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_11_535 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
X_08990_ _02607_ _02608_ _02434_ _02437_ VGND VGND VPWR VPWR _02610_ sky130_fd_sc_hd__o211ai_1
X_07941_ _01463_ _01464_ _01296_ _01430_ VGND VGND VPWR VPWR _01466_ sky130_fd_sc_hd__o211a_1
X_07872_ _01388_ _01390_ _00533_ _00033_ VGND VGND VPWR VPWR _01391_ sky130_fd_sc_hd__and4bb_1
X_09611_ _03286_ _03287_ VGND VGND VPWR VPWR _03289_ sky130_fd_sc_hd__or2_1
X_06823_ _00246_ _00247_ _00161_ _00163_ VGND VGND VPWR VPWR _00249_ sky130_fd_sc_hd__o211ai_2
XFILLER_0_92_42 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_0_78_502 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
X_09542_ _03210_ _03211_ _03047_ _03050_ VGND VGND VPWR VPWR _03214_ sky130_fd_sc_hd__o211ai_2
X_06754_ _04802_ _03124_ _05341_ _05345_ VGND VGND VPWR VPWR _00181_ sky130_fd_sc_hd__and4_1
XFILLER_0_78_546 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_78_524 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_05705_ net44 VGND VGND VPWR VPWR _00351_ sky130_fd_sc_hd__buf_2
XFILLER_0_93_505 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_78_568 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_0_66_719 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
X_09473_ _00150_ _00688_ _00349_ _00558_ VGND VGND VPWR VPWR _03138_ sky130_fd_sc_hd__a22o_1
X_06685_ _00010_ _00012_ _00111_ _00112_ VGND VGND VPWR VPWR _00113_ sky130_fd_sc_hd__a211o_1
X_08424_ _01990_ _01991_ _01992_ VGND VGND VPWR VPWR _01993_ sky130_fd_sc_hd__nand3_1
X_08355_ _05655_ _00546_ _01764_ _01763_ _01762_ VGND VGND VPWR VPWR _01918_ sky130_fd_sc_hd__a32o_1
X_07306_ _05419_ _05655_ _00656_ _00655_ VGND VGND VPWR VPWR _00772_ sky130_fd_sc_hd__a31o_1
XFILLER_0_46_465 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XFILLER_0_116_342 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_61_435 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
X_08286_ _01660_ _01842_ VGND VGND VPWR VPWR _01843_ sky130_fd_sc_hd__xnor2_4
XTAP_TAPCELL_ROW_115_1702 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_104_526 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
X_07237_ _00646_ net46 _00695_ _00624_ VGND VGND VPWR VPWR _00697_ sky130_fd_sc_hd__a22o_1
XFILLER_0_33_148 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
X_07168_ _01486_ _00485_ _00235_ _00493_ VGND VGND VPWR VPWR _00621_ sky130_fd_sc_hd__a22o_1
X_06119_ _04694_ _04857_ VGND VGND VPWR VPWR _04868_ sky130_fd_sc_hd__xnor2_1
X_07099_ _00189_ VGND VGND VPWR VPWR _00546_ sky130_fd_sc_hd__clkbuf_4
X_09809_ _03269_ _03484_ _03503_ _03504_ VGND VGND VPWR VPWR _03505_ sky130_fd_sc_hd__o211a_1
XTAP_TAPCELL_ROW_45_828 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_84_527 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_0_49_281 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XTAP_TAPCELL_ROW_25_574 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_112_29 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_21_27 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_37_476 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_107_353 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_92_593 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_10515_ _02161_ VGND VGND VPWR VPWR _04275_ sky130_fd_sc_hd__buf_2
XTAP_TAPCELL_ROW_77_1229 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_52_457 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_40_619 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
X_10446_ _04198_ _04199_ VGND VGND VPWR VPWR _04200_ sky130_fd_sc_hd__xnor2_1
X_10377_ _04122_ _04123_ _03971_ _03973_ VGND VGND VPWR VPWR _04125_ sky130_fd_sc_hd__a211o_1
XFILLER_0_20_365 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_0_46_35 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XTAP_TAPCELL_ROW_88_1358 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_99_192 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_0_75_505 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_62_78 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
X_06470_ _05596_ _05597_ _05598_ VGND VGND VPWR VPWR _05600_ sky130_fd_sc_hd__a21o_1
XFILLER_0_75_549 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
X_08140_ _01679_ _01681_ VGND VGND VPWR VPWR _01682_ sky130_fd_sc_hd__or2_2
XFILLER_0_7_337 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_0_16_616 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XFILLER_0_15_126 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_70_232 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_0_43_446 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XFILLER_0_43_457 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
X_08071_ _03572_ _01604_ _01436_ _01435_ _01606_ VGND VGND VPWR VPWR _01608_ sky130_fd_sc_hd__a32o_1
XFILLER_0_113_334 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XTAP_TAPCELL_ROW_99_1498 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_11_93 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
X_07022_ _00460_ _00462_ VGND VGND VPWR VPWR _00463_ sky130_fd_sc_hd__and2_2
XFILLER_0_24_671 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_101_529 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XFILLER_0_23_181 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_0_87_64 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XTAP_TAPCELL_ROW_110_1632 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
X_08973_ _02590_ _02591_ VGND VGND VPWR VPWR _02592_ sky130_fd_sc_hd__nor2_2
XTAP_TAPCELL_ROW_110_1643 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
X_07924_ _00428_ _01114_ VGND VGND VPWR VPWR _01448_ sky130_fd_sc_hd__and2_1
XFILLER_0_46_3 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_0_97_107 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
X_07855_ _01370_ _01371_ VGND VGND VPWR VPWR _01372_ sky130_fd_sc_hd__and2_1
X_06806_ _00147_ _00148_ VGND VGND VPWR VPWR _00232_ sky130_fd_sc_hd__nor2_2
X_07786_ _01293_ _01294_ _01295_ VGND VGND VPWR VPWR _01297_ sky130_fd_sc_hd__a21o_1
X_09525_ _04585_ _02695_ _03193_ _03194_ VGND VGND VPWR VPWR _03195_ sky130_fd_sc_hd__a22o_1
X_06737_ _03616_ _05656_ _00161_ _00162_ VGND VGND VPWR VPWR _00164_ sky130_fd_sc_hd__a22o_1
XFILLER_0_39_719 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_78_387 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
X_09456_ _02954_ _03101_ _03117_ _03118_ VGND VGND VPWR VPWR _03119_ sky130_fd_sc_hd__o211a_2
X_06668_ _03321_ _05693_ _00094_ _00799_ VGND VGND VPWR VPWR _00096_ sky130_fd_sc_hd__a22o_1
XFILLER_0_93_335 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_66_549 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XTAP_TAPCELL_ROW_61_1019 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
X_08407_ _01972_ _01973_ VGND VGND VPWR VPWR _01974_ sky130_fd_sc_hd__or2b_1
XTAP_TAPCELL_ROW_121_1783 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_121_1772 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
X_09387_ _03041_ _03042_ _02882_ VGND VGND VPWR VPWR _03044_ sky130_fd_sc_hd__a21oi_1
X_06599_ _00024_ _00025_ VGND VGND VPWR VPWR _00028_ sky130_fd_sc_hd__and2_1
XTAP_TAPCELL_ROW_22_533 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
X_08338_ _04922_ _00392_ _00612_ VGND VGND VPWR VPWR _01899_ sky130_fd_sc_hd__and3_1
XTAP_TAPCELL_ROW_50_886 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_117_673 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XPHY_EDGE_ROW_89_Left_211 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_0_61_254 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
X_08269_ _01821_ _01822_ _01783_ VGND VGND VPWR VPWR _01824_ sky130_fd_sc_hd__o21ai_2
X_11280_ _05060_ _05057_ _05058_ VGND VGND VPWR VPWR _05105_ sky130_fd_sc_hd__o21ba_1
X_10300_ _03807_ VGND VGND VPWR VPWR _04040_ sky130_fd_sc_hd__clkbuf_4
XFILLER_0_61_276 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
X_10231_ _03962_ _03963_ _03958_ _03959_ VGND VGND VPWR VPWR _03966_ sky130_fd_sc_hd__a211o_1
X_10162_ _03767_ _03770_ _03888_ _03890_ VGND VGND VPWR VPWR _03891_ sky130_fd_sc_hd__a211o_1
XTAP_TAPCELL_ROW_72_1159 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
X_10093_ _03730_ VGND VGND VPWR VPWR _03815_ sky130_fd_sc_hd__inv_2
XPHY_EDGE_ROW_98_Left_220 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_0_97_630 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XTAP_TAPCELL_ROW_58_986 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_16_27 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XTAP_TAPCELL_ROW_2_291 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
X_10995_ _04719_ _04722_ _04717_ VGND VGND VPWR VPWR _04797_ sky130_fd_sc_hd__a21oi_2
XFILLER_0_97_685 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_96_162 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_0_69_376 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_57_516 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XFILLER_0_57_505 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XTAP_TAPCELL_ROW_83_1299 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_72_508 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_0_114_109 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_52_243 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_107_183 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
X_10429_ _04179_ _04180_ VGND VGND VPWR VPWR _04181_ sky130_fd_sc_hd__or2_1
XFILLER_0_20_162 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_0_21_685 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
X_05970_ _03212_ _03233_ VGND VGND VPWR VPWR _03244_ sky130_fd_sc_hd__and2b_1
XFILLER_0_57_89 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_0_32_9 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
X_07640_ _05550_ _05423_ _00387_ _05343_ VGND VGND VPWR VPWR _01137_ sky130_fd_sc_hd__a22o_1
XFILLER_0_88_641 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
X_07571_ _03605_ _00908_ _00609_ _01060_ VGND VGND VPWR VPWR _01062_ sky130_fd_sc_hd__nand4_1
X_09310_ _02958_ _02959_ VGND VGND VPWR VPWR _02960_ sky130_fd_sc_hd__nor2_1
X_06522_ _05575_ _05582_ _05581_ VGND VGND VPWR VPWR _05651_ sky130_fd_sc_hd__a21o_1
XFILLER_0_87_184 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_118_415 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
X_09241_ _02882_ _02883_ _02884_ VGND VGND VPWR VPWR _02886_ sky130_fd_sc_hd__or3b_2
XFILLER_0_28_251 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
X_06453_ _05581_ _05582_ VGND VGND VPWR VPWR _05583_ sky130_fd_sc_hd__and2b_1
X_09172_ _02799_ _02809_ VGND VGND VPWR VPWR _02810_ sky130_fd_sc_hd__xor2_2
XFILLER_0_8_657 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
X_06384_ _05512_ _05513_ _05493_ VGND VGND VPWR VPWR _05515_ sky130_fd_sc_hd__o21ai_2
XFILLER_0_7_167 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
X_08123_ _01663_ _01664_ VGND VGND VPWR VPWR _01665_ sky130_fd_sc_hd__nand2_2
XFILLER_0_114_643 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
X_08054_ _00269_ _01588_ VGND VGND VPWR VPWR _01589_ sky130_fd_sc_hd__nand2_1
XFILLER_0_98_85 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
X_07005_ _00420_ _00442_ _00443_ VGND VGND VPWR VPWR _00444_ sky130_fd_sc_hd__and3_1
XFILLER_0_31_449 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_0_11_173 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
X_08956_ _02571_ _02572_ VGND VGND VPWR VPWR _02573_ sky130_fd_sc_hd__or2_4
X_08887_ net3 _01109_ VGND VGND VPWR VPWR _02498_ sky130_fd_sc_hd__and2_1
X_07907_ _01426_ _01427_ _01406_ _01407_ VGND VGND VPWR VPWR _01429_ sky130_fd_sc_hd__a211oi_4
XFILLER_0_98_449 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
X_07838_ net20 VGND VGND VPWR VPWR _01353_ sky130_fd_sc_hd__clkbuf_4
XTAP_TAPCELL_ROW_27_603 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
X_09508_ _01782_ _03175_ VGND VGND VPWR VPWR _03176_ sky130_fd_sc_hd__nand2_1
XFILLER_0_79_685 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XTAP_TAPCELL_ROW_55_945 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
X_07769_ net48 VGND VGND VPWR VPWR _01278_ sky130_fd_sc_hd__clkbuf_4
X_10780_ _02459_ _02868_ _02865_ _00151_ VGND VGND VPWR VPWR _04562_ sky130_fd_sc_hd__a22oi_2
XFILLER_0_78_184 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
X_09439_ _03098_ _03099_ VGND VGND VPWR VPWR _03100_ sky130_fd_sc_hd__xor2_4
XFILLER_0_19_273 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
X_11401_ _05229_ _05203_ _05233_ VGND VGND VPWR VPWR _05235_ sky130_fd_sc_hd__and3_1
XFILLER_0_81_349 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_0_62_530 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XFILLER_0_105_632 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_22_416 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_0_104_164 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
X_11332_ _04800_ _05022_ VGND VGND VPWR VPWR _05161_ sky130_fd_sc_hd__nand2_1
XFILLER_0_22_449 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
X_11263_ _05085_ _05086_ VGND VGND VPWR VPWR _05087_ sky130_fd_sc_hd__xnor2_1
XFILLER_0_120_657 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
X_10214_ _03938_ _03945_ _03946_ VGND VGND VPWR VPWR _03947_ sky130_fd_sc_hd__nand3_1
X_11194_ _00896_ _01042_ _04800_ _03807_ _04948_ VGND VGND VPWR VPWR _05012_ sky130_fd_sc_hd__a41o_1
X_10145_ _00409_ _02236_ _03751_ _03871_ VGND VGND VPWR VPWR _03872_ sky130_fd_sc_hd__a31o_1
XTAP_TAPCELL_ROW_7_350 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_27_15 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
X_10076_ _03794_ _03795_ _03655_ _03657_ VGND VGND VPWR VPWR _03797_ sky130_fd_sc_hd__o211ai_2
XTAP_TAPCELL_ROW_85_1328 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
X_10978_ _04693_ _04739_ _04776_ _04777_ VGND VGND VPWR VPWR _04778_ sky130_fd_sc_hd__o211ai_2
XFILLER_0_57_335 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_57_313 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_0_43_69 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_72_316 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_108_492 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_80_360 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_0_13_405 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XTAP_TAPCELL_ROW_96_1468 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_96_1457 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_13_449 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_7_69 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_0_343 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
X_08810_ _01353_ _02411_ _02412_ VGND VGND VPWR VPWR _02413_ sky130_fd_sc_hd__a21bo_1
XFILLER_0_68_99 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
X_09790_ _03110_ _03112_ _03269_ _03270_ VGND VGND VPWR VPWR _03484_ sky130_fd_sc_hd__a211oi_2
X_08741_ _02336_ _02337_ _02319_ VGND VGND VPWR VPWR _02340_ sky130_fd_sc_hd__a21oi_2
X_05953_ _02611_ _02622_ _02633_ VGND VGND VPWR VPWR _03059_ sky130_fd_sc_hd__nand3_2
X_08672_ _02255_ _02261_ _02263_ VGND VGND VPWR VPWR _02264_ sky130_fd_sc_hd__nand3_1
X_05884_ _02284_ _02295_ VGND VGND VPWR VPWR _02306_ sky130_fd_sc_hd__nand2_1
XFILLER_0_108_83 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
X_07623_ _01115_ _01117_ _01113_ VGND VGND VPWR VPWR _01119_ sky130_fd_sc_hd__a21o_1
XPHY_EDGE_ROW_5_Right_5 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_0_119_713 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
X_07554_ _01247_ _00895_ _01042_ _01760_ VGND VGND VPWR VPWR _01043_ sky130_fd_sc_hd__a22oi_1
XTAP_TAPCELL_ROW_52_915 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_105_1575 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_76_655 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_75_143 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_0_8_421 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
X_07485_ _00808_ _00811_ _00966_ _00967_ VGND VGND VPWR VPWR _00968_ sky130_fd_sc_hd__a211oi_4
X_06505_ _05548_ _05549_ _05568_ VGND VGND VPWR VPWR _05634_ sky130_fd_sc_hd__o21ai_1
XFILLER_0_91_647 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_90_102 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_76_699 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
X_09224_ _03627_ _02864_ _02866_ _00340_ VGND VGND VPWR VPWR _02867_ sky130_fd_sc_hd__a22oi_1
XFILLER_0_63_327 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
X_06436_ _05563_ _05564_ _05560_ _05474_ VGND VGND VPWR VPWR _05566_ sky130_fd_sc_hd__a211o_1
XFILLER_0_63_349 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XTAP_TAPCELL_ROW_32_661 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
X_09155_ _02751_ _02790_ VGND VGND VPWR VPWR _02791_ sky130_fd_sc_hd__xnor2_2
X_06367_ _02677_ _05497_ VGND VGND VPWR VPWR _05498_ sky130_fd_sc_hd__nand2_1
XFILLER_0_114_451 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_71_393 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_09086_ _02687_ _02715_ VGND VGND VPWR VPWR _02716_ sky130_fd_sc_hd__xnor2_4
X_08106_ _01600_ _01601_ _01643_ _01644_ VGND VGND VPWR VPWR _01646_ sky130_fd_sc_hd__o22ai_4
XFILLER_0_16_298 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_06298_ _05427_ _05428_ _05429_ VGND VGND VPWR VPWR _05430_ sky130_fd_sc_hd__nand3_1
X_08037_ _01426_ _01536_ net163 _01569_ VGND VGND VPWR VPWR _01570_ sky130_fd_sc_hd__a211oi_4
XFILLER_0_4_693 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_0_3_181 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_101_156 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_12_471 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
X_09988_ _03536_ _03552_ _03553_ VGND VGND VPWR VPWR _03700_ sky130_fd_sc_hd__nand3_2
X_08939_ _02449_ _02554_ VGND VGND VPWR VPWR _02555_ sky130_fd_sc_hd__xor2_2
X_10901_ _04691_ _04692_ _04610_ _04676_ VGND VGND VPWR VPWR _04695_ sky130_fd_sc_hd__a211oi_1
X_10832_ _04616_ _04617_ _04481_ VGND VGND VPWR VPWR _04620_ sky130_fd_sc_hd__o21ai_1
X_10763_ _04543_ VGND VGND VPWR VPWR _04545_ sky130_fd_sc_hd__inv_2
XFILLER_0_13_39 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XPHY_EDGE_ROW_17_Left_139 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_0_109_223 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_94_474 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XFILLER_0_82_636 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_81_113 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XTAP_TAPCELL_ROW_80_1258 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_54_305 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
X_10694_ _00350_ _03030_ _02868_ _00348_ VGND VGND VPWR VPWR _04469_ sky130_fd_sc_hd__a22o_1
XFILLER_0_35_530 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_0_120_29 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_35_574 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_0_35_585 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XFILLER_0_62_393 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_50_533 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
X_11315_ _05044_ _05093_ VGND VGND VPWR VPWR _05143_ sky130_fd_sc_hd__and2_1
XFILLER_0_105_484 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_50_555 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XTAP_TAPCELL_ROW_10_388 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_10_419 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
X_11246_ _05066_ _01673_ _04883_ _05064_ VGND VGND VPWR VPWR _05068_ sky130_fd_sc_hd__and4b_1
XPHY_EDGE_ROW_26_Left_148 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_0_38_36 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
X_11177_ _04990_ _04993_ VGND VGND VPWR VPWR _04994_ sky130_fd_sc_hd__xor2_1
XTAP_TAPCELL_ROW_91_1398 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
X_10128_ _03815_ _03732_ _03851_ _03852_ VGND VGND VPWR VPWR _03853_ sky130_fd_sc_hd__o211ai_4
X_10059_ _03759_ _03776_ _03777_ VGND VGND VPWR VPWR _03778_ sky130_fd_sc_hd__or3_1
XFILLER_0_58_633 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XPHY_EDGE_ROW_35_Left_157 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_0_85_441 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_0_58_655 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XTAP_TAPCELL_ROW_18_488 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_70_45 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_58_688 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_57_165 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
X_07270_ _00600_ _00732_ VGND VGND VPWR VPWR _00733_ sky130_fd_sc_hd__nor2_2
XFILLER_0_26_541 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
X_06221_ _04965_ _05095_ _05084_ VGND VGND VPWR VPWR _05354_ sky130_fd_sc_hd__a21bo_1
XFILLER_0_79_54 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XFILLER_0_79_43 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_0_53_393 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_06152_ _04009_ _04487_ _05202_ _05213_ VGND VGND VPWR VPWR _05223_ sky130_fd_sc_hd__o211a_1
XFILLER_0_13_268 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
X_06083_ _04052_ _04118_ VGND VGND VPWR VPWR _04476_ sky130_fd_sc_hd__nand2_1
X_09911_ _03472_ _03473_ VGND VGND VPWR VPWR _03617_ sky130_fd_sc_hd__and2b_1
XFILLER_0_1_641 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_1_652 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XPHY_EDGE_ROW_44_Left_166 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_0_1_685 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_111_498 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
X_09842_ _00798_ _02174_ _03537_ _03538_ VGND VGND VPWR VPWR _03541_ sky130_fd_sc_hd__nand4_2
XFILLER_0_0_195 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
X_09773_ _03273_ VGND VGND VPWR VPWR _03466_ sky130_fd_sc_hd__inv_2
XFILLER_0_119_93 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
X_08724_ _02320_ VGND VGND VPWR VPWR _02321_ sky130_fd_sc_hd__buf_4
XFILLER_0_28_91 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
X_06985_ _02677_ _00421_ VGND VGND VPWR VPWR _00422_ sky130_fd_sc_hd__nand2_1
XTAP_TAPCELL_ROW_107_1604 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
X_05936_ _02841_ _02852_ _02284_ VGND VGND VPWR VPWR _02874_ sky130_fd_sc_hd__o21ai_2
X_08655_ _02243_ _02244_ VGND VGND VPWR VPWR _02245_ sky130_fd_sc_hd__xnor2_1
XFILLER_0_68_419 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XPHY_EDGE_ROW_53_Left_175 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
X_05867_ _02098_ _02109_ VGND VGND VPWR VPWR _02120_ sky130_fd_sc_hd__xnor2_2
XTAP_TAPCELL_ROW_37_720 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
X_07606_ _02721_ _02732_ _00197_ _00301_ VGND VGND VPWR VPWR _01100_ sky130_fd_sc_hd__and4_1
X_08586_ _02167_ _02168_ _02162_ VGND VGND VPWR VPWR _02170_ sky130_fd_sc_hd__a21o_1
X_05798_ _00319_ _01356_ VGND VGND VPWR VPWR _01367_ sky130_fd_sc_hd__nand2_1
X_07537_ _00867_ _00890_ net132 _01024_ VGND VGND VPWR VPWR _01025_ sky130_fd_sc_hd__a211o_1
XFILLER_0_91_411 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_76_485 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XTAP_TAPCELL_ROW_66_1091 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_63_135 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
X_07468_ _00818_ _00826_ _00825_ VGND VGND VPWR VPWR _00949_ sky130_fd_sc_hd__a21o_1
XFILLER_0_91_488 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
X_09207_ _05307_ _05308_ _01976_ _02173_ VGND VGND VPWR VPWR _02848_ sky130_fd_sc_hd__nand4_4
X_07399_ _00729_ _00728_ VGND VGND VPWR VPWR _00874_ sky130_fd_sc_hd__or2_1
X_06419_ _05484_ _05492_ VGND VGND VPWR VPWR _05549_ sky130_fd_sc_hd__and2_1
XFILLER_0_44_360 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XTAP_TAPCELL_ROW_118_1733 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_106_259 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_09138_ _00408_ _00750_ _02621_ _02620_ _00610_ VGND VGND VPWR VPWR _02772_ sky130_fd_sc_hd__a32o_1
XPHY_EDGE_ROW_62_Left_184 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_0_17_596 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_0_32_533 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_11100_ _04907_ _04908_ VGND VGND VPWR VPWR _04910_ sky130_fd_sc_hd__and2_1
X_09069_ _02690_ _02694_ _02696_ VGND VGND VPWR VPWR _02697_ sky130_fd_sc_hd__nand3_1
XFILLER_0_102_465 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
X_11031_ _03827_ _01673_ _04741_ _04740_ _01355_ VGND VGND VPWR VPWR _04836_ sky130_fd_sc_hd__a32o_1
XFILLER_0_99_544 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XPHY_EDGE_ROW_71_Left_193 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_0_87_717 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_0_24_27 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_39_110 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
X_10815_ _03490_ _01977_ _03491_ _02351_ VGND VGND VPWR VPWR _04601_ sky130_fd_sc_hd__a22o_1
XFILLER_0_54_102 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XTAP_TAPCELL_ROW_15_447 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
X_10746_ _04481_ _04482_ _04523_ _04524_ VGND VGND VPWR VPWR _04526_ sky130_fd_sc_hd__a22o_1
XFILLER_0_40_15 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
X_10677_ _04449_ _04450_ VGND VGND VPWR VPWR _04451_ sky130_fd_sc_hd__and2_1
XFILLER_0_54_179 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_54_157 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_35_393 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_105_281 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XTAP_TAPCELL_ROW_93_1427 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_50_363 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_10_216 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XFILLER_0_23_588 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
X_11229_ _04986_ _05049_ VGND VGND VPWR VPWR _05050_ sky130_fd_sc_hd__nor2_1
XFILLER_0_65_45 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
X_06770_ net42 VGND VGND VPWR VPWR _00197_ sky130_fd_sc_hd__buf_2
X_05721_ net1 VGND VGND VPWR VPWR _00526_ sky130_fd_sc_hd__buf_4
XFILLER_0_77_216 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
X_08440_ _02007_ _02008_ _01938_ VGND VGND VPWR VPWR _02010_ sky130_fd_sc_hd__o21ai_2
XFILLER_0_105_51 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_0_93_709 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XTAP_TAPCELL_ROW_102_1534 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
X_08371_ _01897_ _01748_ _01933_ _01934_ VGND VGND VPWR VPWR _01936_ sky130_fd_sc_hd__o211ai_2
XFILLER_0_46_625 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_105_95 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
X_07322_ _00786_ _00787_ _00641_ _00745_ VGND VGND VPWR VPWR _00790_ sky130_fd_sc_hd__a211o_1
XFILLER_0_18_327 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_07253_ _00672_ _00673_ _00711_ _00713_ VGND VGND VPWR VPWR _00715_ sky130_fd_sc_hd__o22ai_4
XFILLER_0_5_221 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_0_116_568 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_104_719 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
X_07184_ _00637_ _00638_ VGND VGND VPWR VPWR _00639_ sky130_fd_sc_hd__and2_1
X_06204_ _00985_ _03332_ _04976_ _00974_ VGND VGND VPWR VPWR _05337_ sky130_fd_sc_hd__a22o_1
XFILLER_0_121_83 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_30_70 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
X_06135_ _00657_ _03834_ _05030_ _00635_ VGND VGND VPWR VPWR _05041_ sky130_fd_sc_hd__a22o_1
XFILLER_0_76_3 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
X_06066_ _04249_ _04238_ VGND VGND VPWR VPWR _04292_ sky130_fd_sc_hd__or2b_1
XFILLER_0_1_471 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XTAP_TAPCELL_ROW_113_1674 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_111_284 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_0_111_273 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
X_09825_ _03521_ _03522_ VGND VGND VPWR VPWR _03523_ sky130_fd_sc_hd__and2b_1
X_09756_ _03442_ _03445_ _03446_ VGND VGND VPWR VPWR _03447_ sky130_fd_sc_hd__nand3_1
X_06968_ _00383_ _00385_ _00401_ VGND VGND VPWR VPWR _00403_ sky130_fd_sc_hd__nand3_2
X_09687_ _03369_ _03370_ _03232_ VGND VGND VPWR VPWR _03372_ sky130_fd_sc_hd__a21bo_1
X_08707_ _00546_ VGND VGND VPWR VPWR _02302_ sky130_fd_sc_hd__clkbuf_4
X_05919_ _02666_ _02677_ _02098_ _02087_ VGND VGND VPWR VPWR _02688_ sky130_fd_sc_hd__a31o_1
X_08638_ _02028_ _02226_ VGND VGND VPWR VPWR net89 sky130_fd_sc_hd__xnor2_4
X_06899_ _00231_ _00326_ _00327_ VGND VGND VPWR VPWR _00328_ sky130_fd_sc_hd__and3_1
XFILLER_0_96_569 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_08569_ _02148_ _02149_ _02140_ VGND VGND VPWR VPWR _02151_ sky130_fd_sc_hd__a21o_1
XFILLER_0_107_502 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
X_10600_ _05637_ _02864_ VGND VGND VPWR VPWR _04367_ sky130_fd_sc_hd__and2_1
XFILLER_0_64_433 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XTAP_TAPCELL_ROW_12_417 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_12_406 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
X_10531_ _04254_ _04290_ VGND VGND VPWR VPWR _04293_ sky130_fd_sc_hd__or2_4
XFILLER_0_64_477 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_0_64_466 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XTAP_TAPCELL_ROW_40_759 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_64_499 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
X_10462_ _04214_ _04215_ _04209_ VGND VGND VPWR VPWR _04218_ sky130_fd_sc_hd__a21o_1
XFILLER_0_10_29 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
X_10393_ _04141_ _04142_ VGND VGND VPWR VPWR _04143_ sky130_fd_sc_hd__xnor2_2
XFILLER_0_32_363 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_102_273 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_19_27 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
X_11014_ _04811_ _04815_ _04816_ VGND VGND VPWR VPWR _04817_ sky130_fd_sc_hd__nand3_1
XFILLER_0_35_15 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XTAP_TAPCELL_ROW_48_859 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_75_709 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XPHY_EDGE_ROW_109_Left_231 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_0_51_69 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
X_10729_ _04501_ _04504_ _04506_ VGND VGND VPWR VPWR _04507_ sky130_fd_sc_hd__nand3_2
XFILLER_0_82_285 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_113_527 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_50_193 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_0_11_558 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XPHY_EDGE_ROW_118_Left_240 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_0_11_569 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
X_07940_ _01296_ _01430_ _01463_ _01464_ VGND VGND VPWR VPWR _01465_ sky130_fd_sc_hd__a211oi_4
XFILLER_0_76_66 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
X_07871_ net35 _05345_ _00035_ _05635_ VGND VGND VPWR VPWR _01390_ sky130_fd_sc_hd__and4_1
X_09610_ _03283_ _03284_ _03285_ VGND VGND VPWR VPWR _03287_ sky130_fd_sc_hd__a21oi_1
X_06822_ _00161_ _00163_ _00246_ _00247_ VGND VGND VPWR VPWR _00248_ sky130_fd_sc_hd__a211o_2
X_09541_ _03047_ _03050_ _03210_ _03211_ VGND VGND VPWR VPWR _03213_ sky130_fd_sc_hd__a211o_2
X_06753_ _03572_ _05589_ VGND VGND VPWR VPWR _00180_ sky130_fd_sc_hd__nand2_1
X_05704_ _00330_ VGND VGND VPWR VPWR _00340_ sky130_fd_sc_hd__buf_4
XFILLER_0_116_83 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
X_09472_ _01582_ _00488_ _02973_ _02974_ VGND VGND VPWR VPWR _03137_ sky130_fd_sc_hd__and4_1
X_06684_ _00071_ _00072_ _00109_ _00110_ VGND VGND VPWR VPWR _00112_ sky130_fd_sc_hd__o22a_1
XFILLER_0_19_625 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
X_08423_ _01803_ _01806_ _01807_ VGND VGND VPWR VPWR _01992_ sky130_fd_sc_hd__a21bo_1
XTAP_TAPCELL_ROW_63_1050 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
X_08354_ _01737_ _01740_ VGND VGND VPWR VPWR _01917_ sky130_fd_sc_hd__nand2_1
XFILLER_0_73_263 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
X_07305_ _00632_ _00634_ VGND VGND VPWR VPWR _00771_ sky130_fd_sc_hd__or2_1
XFILLER_0_46_477 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
X_08285_ _01840_ _01841_ VGND VGND VPWR VPWR _01842_ sky130_fd_sc_hd__nand2_2
XFILLER_0_116_365 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_0_61_447 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
X_07236_ _02447_ _00843_ _00565_ _00695_ VGND VGND VPWR VPWR _00696_ sky130_fd_sc_hd__nand4_2
XTAP_TAPCELL_ROW_115_1703 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
X_07167_ _00619_ VGND VGND VPWR VPWR _00620_ sky130_fd_sc_hd__inv_2
XFILLER_0_42_661 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
X_06118_ _04759_ _04846_ VGND VGND VPWR VPWR _04857_ sky130_fd_sc_hd__xnor2_1
X_07098_ _00413_ _00415_ VGND VGND VPWR VPWR _00545_ sky130_fd_sc_hd__nor2_1
XTAP_TAPCELL_ROW_74_1190 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
X_06049_ _01192_ _01171_ _03026_ _04085_ VGND VGND VPWR VPWR _04107_ sky130_fd_sc_hd__and4_1
X_09808_ _03501_ _03502_ _03264_ _03267_ VGND VGND VPWR VPWR _03504_ sky130_fd_sc_hd__o211ai_2
X_09739_ _02105_ _00355_ _03331_ _03333_ VGND VGND VPWR VPWR _03428_ sky130_fd_sc_hd__and4_1
XFILLER_0_69_503 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XTAP_TAPCELL_ROW_45_829 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_96_377 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XTAP_TAPCELL_ROW_25_575 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_80_701 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_25_617 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_0_37_444 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_0_37_455 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XFILLER_0_21_39 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_107_387 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
X_10514_ _04272_ _04273_ VGND VGND VPWR VPWR _04274_ sky130_fd_sc_hd__and2_1
XTAP_TAPCELL_ROW_77_1219 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_52_469 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
X_10445_ _02302_ _02045_ VGND VGND VPWR VPWR _04199_ sky130_fd_sc_hd__nand2_1
X_10376_ _03971_ _03973_ _04122_ _04123_ VGND VGND VPWR VPWR _04124_ sky130_fd_sc_hd__o211ai_4
XFILLER_0_20_388 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_0_46_47 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XTAP_TAPCELL_ROW_88_1359 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_87_344 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_7_305 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_28_411 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_43_414 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_0_43_425 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
X_08070_ _01605_ VGND VGND VPWR VPWR _01606_ sky130_fd_sc_hd__clkbuf_4
XFILLER_0_15_138 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XTAP_TAPCELL_ROW_99_1499 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
X_07021_ _00457_ _00458_ _00459_ VGND VGND VPWR VPWR _00462_ sky130_fd_sc_hd__a21o_1
XFILLER_0_24_683 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_30_108 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_0_87_10 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XFILLER_0_87_76 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_0_87_54 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
X_08972_ _02577_ _02579_ _02588_ VGND VGND VPWR VPWR _02591_ sky130_fd_sc_hd__a21oi_1
XTAP_TAPCELL_ROW_110_1633 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
X_07923_ _01442_ _01446_ VGND VGND VPWR VPWR _01447_ sky130_fd_sc_hd__xnor2_2
X_07854_ _03616_ _00750_ _01368_ _01369_ VGND VGND VPWR VPWR _01371_ sky130_fd_sc_hd__a22o_1
XFILLER_0_39_3 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
X_06805_ _05640_ _00048_ _00155_ _00230_ VGND VGND VPWR VPWR _00231_ sky130_fd_sc_hd__a31o_1
XFILLER_0_97_119 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_0_78_300 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
X_07785_ _01293_ _01294_ _01295_ VGND VGND VPWR VPWR _01296_ sky130_fd_sc_hd__nand3_4
X_09524_ _05307_ _05308_ _02160_ _02692_ VGND VGND VPWR VPWR _03194_ sky130_fd_sc_hd__nand4_4
X_06736_ _03255_ _05557_ _00161_ _00162_ VGND VGND VPWR VPWR _00163_ sky130_fd_sc_hd__nand4_2
XFILLER_0_78_377 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
X_09455_ _03115_ _03116_ _02949_ _02952_ VGND VGND VPWR VPWR _03118_ sky130_fd_sc_hd__o211ai_2
X_06667_ _00635_ _03321_ _05693_ _00094_ VGND VGND VPWR VPWR _00095_ sky130_fd_sc_hd__nand4_1
XFILLER_0_66_539 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
X_08406_ _01970_ _01971_ _01797_ _01799_ VGND VGND VPWR VPWR _01973_ sky130_fd_sc_hd__a211o_1
XTAP_TAPCELL_ROW_121_1784 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_121_1773 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
X_09386_ _02882_ _03041_ _03042_ VGND VGND VPWR VPWR _03043_ sky130_fd_sc_hd__and3_1
XFILLER_0_62_701 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
X_06598_ _00024_ _00025_ _00026_ VGND VGND VPWR VPWR _00027_ sky130_fd_sc_hd__nand3_1
XFILLER_0_19_444 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XTAP_TAPCELL_ROW_22_534 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_46_230 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
X_08337_ _00747_ VGND VGND VPWR VPWR _01898_ sky130_fd_sc_hd__clkbuf_4
XFILLER_0_61_200 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_117_685 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XTAP_TAPCELL_ROW_50_887 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
X_08268_ _01783_ _01821_ _01822_ VGND VGND VPWR VPWR _01823_ sky130_fd_sc_hd__or3_2
XFILLER_0_116_184 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
X_07219_ _02197_ _02732_ _05695_ _05696_ VGND VGND VPWR VPWR _00677_ sky130_fd_sc_hd__nand4_2
X_10230_ _03958_ _03959_ _03962_ _03963_ VGND VGND VPWR VPWR _03964_ sky130_fd_sc_hd__o211a_1
XFILLER_0_14_160 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
X_08199_ _01561_ _01733_ _01745_ VGND VGND VPWR VPWR _01747_ sky130_fd_sc_hd__nand3_1
XFILLER_0_14_193 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
X_10161_ _03886_ _03887_ _03876_ VGND VGND VPWR VPWR _03890_ sky130_fd_sc_hd__a21oi_1
XFILLER_0_30_697 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
X_10092_ _03811_ _03813_ VGND VGND VPWR VPWR _03814_ sky130_fd_sc_hd__and2_1
XFILLER_0_88_119 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
X_10994_ _04794_ _04795_ VGND VGND VPWR VPWR _04796_ sky130_fd_sc_hd__nor2_2
XTAP_TAPCELL_ROW_58_987 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_2_281 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_2_292 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_97_697 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_96_141 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_0_84_347 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_0_32_27 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_65_561 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XFILLER_0_120_9 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_108_652 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_65_583 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_80_553 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XFILLER_0_52_266 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_0_503 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_33_491 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
X_10428_ _04177_ _04178_ _04173_ _04174_ VGND VGND VPWR VPWR _04180_ sky130_fd_sc_hd__a211oi_2
XFILLER_0_0_525 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_0_20_141 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
X_10359_ _02321_ _00753_ _03953_ _03952_ _02813_ VGND VGND VPWR VPWR _04105_ sky130_fd_sc_hd__a32o_2
XFILLER_0_57_13 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XFILLER_0_0_569 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_21_697 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_88_620 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XFILLER_0_73_67 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
X_07570_ net15 VGND VGND VPWR VPWR _01060_ sky130_fd_sc_hd__buf_2
X_06521_ _05559_ _05567_ VGND VGND VPWR VPWR _05650_ sky130_fd_sc_hd__or2_1
XFILLER_0_75_325 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
X_09240_ _02700_ _02701_ _02711_ _02709_ VGND VGND VPWR VPWR _02884_ sky130_fd_sc_hd__a31o_1
XFILLER_0_118_438 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_90_306 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XFILLER_0_7_113 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
X_06452_ _05579_ _05580_ _05576_ VGND VGND VPWR VPWR _05582_ sky130_fd_sc_hd__a21o_1
XFILLER_0_113_51 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
X_09171_ _02806_ _02807_ VGND VGND VPWR VPWR _02809_ sky130_fd_sc_hd__and2b_1
XFILLER_0_8_669 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
X_06383_ _05493_ _05512_ _05513_ VGND VGND VPWR VPWR _05514_ sky130_fd_sc_hd__or3_2
X_08122_ _01660_ _01661_ _01482_ VGND VGND VPWR VPWR _01664_ sky130_fd_sc_hd__a21o_1
XFILLER_0_22_82 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XFILLER_0_43_211 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
X_08053_ _00094_ VGND VGND VPWR VPWR _01588_ sky130_fd_sc_hd__buf_4
XFILLER_0_31_417 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XFILLER_0_12_631 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
X_07004_ _00438_ _00440_ _00441_ VGND VGND VPWR VPWR _00443_ sky130_fd_sc_hd__a21o_1
XFILLER_0_114_699 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_3_396 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_0_3_385 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
X_08955_ _02407_ _02448_ VGND VGND VPWR VPWR _02572_ sky130_fd_sc_hd__and2b_1
X_07906_ _01406_ _01407_ _01426_ _01427_ VGND VGND VPWR VPWR _01428_ sky130_fd_sc_hd__o211a_1
X_08886_ _02493_ _02496_ VGND VGND VPWR VPWR _02497_ sky130_fd_sc_hd__xor2_1
XFILLER_0_98_428 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
X_07837_ _01349_ _01351_ VGND VGND VPWR VPWR _01352_ sky130_fd_sc_hd__xnor2_2
XTAP_TAPCELL_ROW_27_604 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
X_07768_ _02054_ _03201_ _00695_ _00837_ VGND VGND VPWR VPWR _01277_ sky130_fd_sc_hd__and4_1
X_09507_ _02251_ _02868_ _02865_ VGND VGND VPWR VPWR _03175_ sky130_fd_sc_hd__and3_1
X_06719_ _00137_ _00145_ VGND VGND VPWR VPWR _00146_ sky130_fd_sc_hd__xnor2_2
XTAP_TAPCELL_ROW_55_946 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_109_405 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_0_79_697 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
X_07699_ _01180_ _01200_ VGND VGND VPWR VPWR _01201_ sky130_fd_sc_hd__xnor2_1
XFILLER_0_109_416 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_93_155 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
X_09438_ _04900_ _02051_ VGND VGND VPWR VPWR _03099_ sky130_fd_sc_hd__nand2_2
XFILLER_0_109_449 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
X_09369_ _02854_ _02856_ _03022_ _03023_ VGND VGND VPWR VPWR _03024_ sky130_fd_sc_hd__a211oi_4
XFILLER_0_47_561 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_0_47_572 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
X_11400_ _05231_ _05232_ VGND VGND VPWR VPWR _05233_ sky130_fd_sc_hd__xor2_1
X_11331_ _01501_ _05157_ _05158_ VGND VGND VPWR VPWR _05160_ sky130_fd_sc_hd__a21bo_1
XFILLER_0_105_655 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_104_176 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
X_11262_ _05013_ _05016_ VGND VGND VPWR VPWR _05086_ sky130_fd_sc_hd__or2_1
XFILLER_0_120_669 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
X_11193_ _05009_ _05010_ VGND VGND VPWR VPWR _05011_ sky130_fd_sc_hd__nor2_1
X_10213_ _03942_ _03944_ _03939_ VGND VGND VPWR VPWR _03946_ sky130_fd_sc_hd__o21ai_2
X_10144_ _03749_ _03750_ VGND VGND VPWR VPWR _03871_ sky130_fd_sc_hd__and2b_1
XFILLER_0_118_29 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XTAP_TAPCELL_ROW_7_351 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_27_27 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
X_10075_ _03655_ _03657_ _03794_ _03795_ VGND VGND VPWR VPWR _03796_ sky130_fd_sc_hd__a211oi_1
XTAP_TAPCELL_ROW_85_1329 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_43_15 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
X_10977_ _04774_ _04775_ _04657_ VGND VGND VPWR VPWR _04777_ sky130_fd_sc_hd__o21ai_1
XFILLER_0_85_623 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_84_111 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_69_196 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_57_369 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_72_306 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XFILLER_0_26_701 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_5_617 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_53_586 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_0_13_417 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XTAP_TAPCELL_ROW_96_1458 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_111_669 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_0_21_461 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_0_84_22 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_0_84_11 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XFILLER_0_0_399 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
X_08740_ _02319_ _02336_ _02337_ VGND VGND VPWR VPWR _02338_ sky130_fd_sc_hd__and3_2
X_05952_ _02993_ _03037_ VGND VGND VPWR VPWR _03048_ sky130_fd_sc_hd__nor2_1
XFILLER_0_84_99 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_84_66 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_08671_ _02259_ _02260_ _02256_ VGND VGND VPWR VPWR _02263_ sky130_fd_sc_hd__a21o_1
X_05883_ _02186_ _02273_ VGND VGND VPWR VPWR _02295_ sky130_fd_sc_hd__or2_1
X_07622_ _01113_ _01115_ _01117_ VGND VGND VPWR VPWR _01118_ sky130_fd_sc_hd__nand3_1
XFILLER_0_76_601 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_88_483 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_0_76_645 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
X_07553_ _01041_ VGND VGND VPWR VPWR _01042_ sky130_fd_sc_hd__buf_4
XTAP_TAPCELL_ROW_52_916 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_105_1576 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_76_667 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
X_06504_ _05538_ _05545_ VGND VGND VPWR VPWR _05633_ sky130_fd_sc_hd__nand2_1
X_07484_ _00964_ _00965_ _00949_ VGND VGND VPWR VPWR _00967_ sky130_fd_sc_hd__a21oi_2
XFILLER_0_90_114 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
X_09223_ _02865_ VGND VGND VPWR VPWR _02866_ sky130_fd_sc_hd__buf_4
XFILLER_0_29_561 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
X_06435_ _05560_ _05474_ _05563_ _05564_ VGND VGND VPWR VPWR _05565_ sky130_fd_sc_hd__o211ai_2
XFILLER_0_106_408 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_91_659 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
X_09154_ _02769_ _02789_ VGND VGND VPWR VPWR _02790_ sky130_fd_sc_hd__xnor2_2
XFILLER_0_8_477 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XFILLER_0_29_594 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XTAP_TAPCELL_ROW_32_662 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_90_169 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
X_08105_ _01600_ _01601_ _01643_ _01644_ VGND VGND VPWR VPWR _01645_ sky130_fd_sc_hd__or4_2
X_06366_ _03343_ VGND VGND VPWR VPWR _05497_ sky130_fd_sc_hd__buf_4
XFILLER_0_44_575 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
X_09085_ _02713_ _02714_ VGND VGND VPWR VPWR _02715_ sky130_fd_sc_hd__xnor2_4
X_06297_ _05340_ _05346_ _05344_ VGND VGND VPWR VPWR _05429_ sky130_fd_sc_hd__a21bo_1
XFILLER_0_101_113 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_08036_ _01566_ _01567_ _01553_ VGND VGND VPWR VPWR _01569_ sky130_fd_sc_hd__o21a_1
XFILLER_0_3_193 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_09987_ _03697_ _03698_ VGND VGND VPWR VPWR _03699_ sky130_fd_sc_hd__or2_1
X_08938_ _02551_ _02553_ VGND VGND VPWR VPWR _02554_ sky130_fd_sc_hd__xor2_4
XTAP_TAPCELL_ROW_4_310 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
X_08869_ _02475_ _02476_ _02468_ VGND VGND VPWR VPWR _02478_ sky130_fd_sc_hd__a21o_1
X_10900_ _04610_ _04676_ _04691_ _04692_ VGND VGND VPWR VPWR _04693_ sky130_fd_sc_hd__o211a_1
X_10831_ _04481_ _04616_ _04617_ VGND VGND VPWR VPWR _04619_ sky130_fd_sc_hd__or3_1
XFILLER_0_94_431 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
X_10762_ _03074_ _03664_ _04543_ _02400_ VGND VGND VPWR VPWR _04544_ sky130_fd_sc_hd__or4b_2
XPHY_EDGE_ROW_11_Right_11 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XTAP_TAPCELL_ROW_80_1259 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_66_188 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_109_279 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
X_10693_ _00762_ _04275_ _04383_ _04384_ VGND VGND VPWR VPWR _04468_ sky130_fd_sc_hd__and4_1
XFILLER_0_81_169 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_50_501 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_117_290 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_90_681 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
X_11314_ _05140_ _05141_ VGND VGND VPWR VPWR _05142_ sky130_fd_sc_hd__nor2_1
XFILLER_0_105_463 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_50_567 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XTAP_TAPCELL_ROW_10_389 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
X_11245_ _04883_ _05022_ _05065_ _05066_ VGND VGND VPWR VPWR _05067_ sky130_fd_sc_hd__o2bb2a_1
XFILLER_0_50_589 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_120_488 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XPHY_EDGE_ROW_20_Right_20 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_0_38_15 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
X_11176_ _04991_ _04992_ VGND VGND VPWR VPWR _04993_ sky130_fd_sc_hd__nand2_1
X_10127_ _03849_ _03850_ _03697_ VGND VGND VPWR VPWR _03852_ sky130_fd_sc_hd__a21o_1
XTAP_TAPCELL_ROW_91_1399 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
X_10058_ _03774_ _03775_ _03760_ _03637_ VGND VGND VPWR VPWR _03777_ sky130_fd_sc_hd__o211a_1
XFILLER_0_89_225 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_0_58_601 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_54_69 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_54_58 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_0_85_453 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XTAP_TAPCELL_ROW_18_489 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_115_205 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_0_26_531 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
X_06220_ _05350_ _05351_ _05339_ VGND VGND VPWR VPWR _05353_ sky130_fd_sc_hd__a21o_1
XFILLER_0_72_169 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_0_60_309 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_81_670 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XFILLER_0_13_225 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_0_26_597 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
X_06151_ _05181_ _05192_ _04672_ VGND VGND VPWR VPWR _05213_ sky130_fd_sc_hd__a21o_1
XFILLER_0_110_41 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
X_06082_ _03048_ _04161_ _04172_ VGND VGND VPWR VPWR _04465_ sky130_fd_sc_hd__nand3_2
XFILLER_0_13_236 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XFILLER_0_111_422 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_110_85 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
X_09910_ _03613_ _03614_ VGND VGND VPWR VPWR _03615_ sky130_fd_sc_hd__xnor2_2
XFILLER_0_0_130 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_41_578 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_0_141 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
X_09841_ _05467_ _02174_ _03537_ _03538_ VGND VGND VPWR VPWR _03540_ sky130_fd_sc_hd__a22o_1
XFILLER_0_95_65 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_0_1_697 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
X_09772_ _03461_ _03462_ _03317_ _03390_ VGND VGND VPWR VPWR _03465_ sky130_fd_sc_hd__o211a_1
X_06984_ _05593_ VGND VGND VPWR VPWR _00421_ sky130_fd_sc_hd__clkbuf_4
X_08723_ _00830_ VGND VGND VPWR VPWR _02320_ sky130_fd_sc_hd__buf_4
X_05935_ _02284_ _02841_ _02852_ VGND VGND VPWR VPWR _02863_ sky130_fd_sc_hd__or3_1
XTAP_TAPCELL_ROW_107_1605 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_21_3 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_95_206 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_08654_ _00472_ _02041_ _02037_ _02035_ _01354_ VGND VGND VPWR VPWR _02244_ sky130_fd_sc_hd__a32o_1
X_05866_ _00690_ _01039_ VGND VGND VPWR VPWR _02109_ sky130_fd_sc_hd__nand2_1
XTAP_TAPCELL_ROW_37_721 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
X_05797_ _01181_ VGND VGND VPWR VPWR _01356_ sky130_fd_sc_hd__clkbuf_8
X_07605_ _03124_ _00195_ _00688_ _04802_ VGND VGND VPWR VPWR _01099_ sky130_fd_sc_hd__a22oi_2
X_08585_ _02162_ _02167_ _02168_ VGND VGND VPWR VPWR _02169_ sky130_fd_sc_hd__and3_1
XFILLER_0_48_100 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XTAP_TAPCELL_ROW_66_1081 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
X_07536_ _01021_ _01022_ _00741_ VGND VGND VPWR VPWR _01024_ sky130_fd_sc_hd__o21a_1
XTAP_TAPCELL_ROW_66_1092 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_63_103 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_0_119_566 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_107_717 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
X_09206_ _05305_ _01976_ _02173_ _05304_ VGND VGND VPWR VPWR _02847_ sky130_fd_sc_hd__a22o_1
X_07467_ _00945_ _00946_ _00910_ _00911_ VGND VGND VPWR VPWR _00948_ sky130_fd_sc_hd__a211oi_2
XFILLER_0_8_263 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_36_339 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_48_188 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
X_07398_ _00870_ _00872_ VGND VGND VPWR VPWR _00873_ sky130_fd_sc_hd__xnor2_2
X_06418_ _05491_ _05485_ VGND VGND VPWR VPWR _05548_ sky130_fd_sc_hd__and2b_1
XTAP_TAPCELL_ROW_118_1734 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
X_09137_ _02599_ _02602_ VGND VGND VPWR VPWR _02771_ sky130_fd_sc_hd__nand2_1
X_06349_ _05460_ _05461_ _05479_ VGND VGND VPWR VPWR _05480_ sky130_fd_sc_hd__o21a_1
XFILLER_0_32_512 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_09068_ _03572_ _02695_ _02691_ _02693_ VGND VGND VPWR VPWR _02696_ sky130_fd_sc_hd__a22o_1
XFILLER_0_44_394 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_08019_ _01542_ _01549_ VGND VGND VPWR VPWR _01550_ sky130_fd_sc_hd__and2_1
XFILLER_0_102_477 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
X_11030_ _04832_ _04833_ VGND VGND VPWR VPWR _04834_ sky130_fd_sc_hd__xnor2_1
XFILLER_0_99_534 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_0_99_523 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
X_10814_ _02281_ _03396_ _04462_ _04461_ _04275_ VGND VGND VPWR VPWR _04600_ sky130_fd_sc_hd__a32o_1
XFILLER_0_79_291 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_55_604 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XTAP_TAPCELL_ROW_15_448 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
X_10745_ _04481_ _04482_ _04523_ _04524_ VGND VGND VPWR VPWR _04525_ sky130_fd_sc_hd__nand4_2
XFILLER_0_40_27 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
X_10676_ _04343_ _04345_ _04447_ _04448_ VGND VGND VPWR VPWR _04450_ sky130_fd_sc_hd__a211o_1
XFILLER_0_54_147 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XFILLER_0_42_309 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_113_709 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_63_670 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XFILLER_0_23_523 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_35_372 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XFILLER_0_23_556 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XTAP_TAPCELL_ROW_93_1428 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_49_47 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
X_11228_ _05046_ _05048_ VGND VGND VPWR VPWR _05049_ sky130_fd_sc_hd__xnor2_1
X_11159_ _04973_ _04910_ VGND VGND VPWR VPWR _04974_ sky130_fd_sc_hd__nor2_1
XFILLER_0_4_27 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
X_05720_ _00504_ VGND VGND VPWR VPWR _00515_ sky130_fd_sc_hd__clkbuf_4
X_08370_ _01931_ _01932_ _01778_ _01780_ VGND VGND VPWR VPWR _01934_ sky130_fd_sc_hd__o211ai_4
XFILLER_0_105_63 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XTAP_TAPCELL_ROW_102_1535 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
X_07321_ _00641_ _00745_ _00786_ _00787_ VGND VGND VPWR VPWR _00789_ sky130_fd_sc_hd__o211ai_4
XFILLER_0_6_701 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_14_83 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
X_07252_ _00672_ _00673_ _00711_ _00713_ VGND VGND VPWR VPWR _00714_ sky130_fd_sc_hd__or4_2
XTAP_TAPCELL_ROW_42_790 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_60_128 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_14_523 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_26_361 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
X_06203_ _00974_ _00985_ _03376_ _03343_ VGND VGND VPWR VPWR _05336_ sky130_fd_sc_hd__and4_1
X_07183_ _00634_ _00636_ _00524_ _00527_ VGND VGND VPWR VPWR _00638_ sky130_fd_sc_hd__o211ai_1
XFILLER_0_30_82 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
X_06134_ net35 VGND VGND VPWR VPWR _05030_ sky130_fd_sc_hd__clkbuf_4
XFILLER_0_41_320 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XFILLER_0_14_589 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_0_30_93 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XFILLER_0_41_364 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_69_3 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
X_06065_ _04183_ _04194_ _04259_ VGND VGND VPWR VPWR _04281_ sky130_fd_sc_hd__o21ai_1
XTAP_TAPCELL_ROW_113_1675 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_111_296 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
X_09824_ _03519_ _03520_ _03369_ _03371_ VGND VGND VPWR VPWR _03522_ sky130_fd_sc_hd__o211ai_1
X_09755_ _00042_ _02813_ _03443_ _03444_ VGND VGND VPWR VPWR _03446_ sky130_fd_sc_hd__nand4_1
X_06967_ _00383_ _00385_ _00401_ VGND VGND VPWR VPWR _00402_ sky130_fd_sc_hd__a21o_2
X_09686_ _03232_ _03369_ _03370_ VGND VGND VPWR VPWR _03371_ sky130_fd_sc_hd__nand3b_2
XTAP_TAPCELL_ROW_68_1110 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
X_08706_ _01759_ _00041_ _02299_ _02300_ VGND VGND VPWR VPWR _02301_ sky130_fd_sc_hd__a22o_1
XFILLER_0_55_90 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
X_05918_ _01651_ VGND VGND VPWR VPWR _02677_ sky130_fd_sc_hd__buf_4
X_06898_ net143 _00325_ _00215_ _00217_ VGND VGND VPWR VPWR _00327_ sky130_fd_sc_hd__o211ai_2
X_05849_ _01138_ _01444_ _01902_ VGND VGND VPWR VPWR _01924_ sky130_fd_sc_hd__o21ai_1
X_08637_ _02224_ _02225_ VGND VGND VPWR VPWR _02226_ sky130_fd_sc_hd__and2_1
XFILLER_0_96_548 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_0_49_420 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
X_08568_ _02140_ _02148_ _02149_ VGND VGND VPWR VPWR _02150_ sky130_fd_sc_hd__nand3_4
X_08499_ _02073_ VGND VGND VPWR VPWR _02074_ sky130_fd_sc_hd__inv_2
XTAP_TAPCELL_ROW_12_418 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_12_407 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_9_561 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
X_07519_ _00981_ _01003_ _01004_ VGND VGND VPWR VPWR _01005_ sky130_fd_sc_hd__nor3_1
X_10530_ _04254_ _04290_ VGND VGND VPWR VPWR _04291_ sky130_fd_sc_hd__nand2_2
XFILLER_0_107_525 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_24_309 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_0_36_169 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
X_10461_ _04209_ _04214_ _04215_ VGND VGND VPWR VPWR _04217_ sky130_fd_sc_hd__nand3_2
XFILLER_0_51_106 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_0_45_670 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XTAP_TAPCELL_ROW_79_1250 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
X_10392_ _04028_ _04030_ VGND VGND VPWR VPWR _04142_ sky130_fd_sc_hd__or2_2
XFILLER_0_32_375 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_0_102_241 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_0_102_285 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
X_11013_ _03440_ _03489_ _04812_ _04814_ VGND VGND VPWR VPWR _04816_ sky130_fd_sc_hd__nand4_2
XFILLER_0_19_39 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_35_27 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_67_272 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_10728_ _03827_ _04505_ _04502_ _04503_ VGND VGND VPWR VPWR _04506_ sky130_fd_sc_hd__nand4_2
XFILLER_0_55_478 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_55_456 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_0_55_445 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_0_27_136 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_0_27_147 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_27_169 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_0_82_275 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
X_10659_ _04413_ _04429_ _04430_ VGND VGND VPWR VPWR _04431_ sky130_fd_sc_hd__nor3_2
XFILLER_0_51_640 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_42_139 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_51_673 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_0_23_364 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_121_561 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_23_397 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_76_23 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_76_78 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
X_07870_ _05343_ _05539_ _05636_ _05030_ VGND VGND VPWR VPWR _01388_ sky130_fd_sc_hd__a22oi_1
X_06821_ _02666_ _00033_ _00244_ _00245_ VGND VGND VPWR VPWR _00247_ sky130_fd_sc_hd__o2bb2a_1
X_09540_ _03165_ _03166_ _03208_ _03209_ VGND VGND VPWR VPWR _03211_ sky130_fd_sc_hd__a22oi_2
X_06752_ _00085_ _00088_ _00090_ VGND VGND VPWR VPWR _00179_ sky130_fd_sc_hd__o21ba_2
X_09471_ _02134_ _02105_ _00344_ _00346_ VGND VGND VPWR VPWR _03136_ sky130_fd_sc_hd__and4_1
X_05703_ net27 VGND VGND VPWR VPWR _00330_ sky130_fd_sc_hd__buf_4
X_06683_ _00071_ _00072_ _00109_ _00110_ VGND VGND VPWR VPWR _00111_ sky130_fd_sc_hd__nor4_2
X_08422_ _01986_ _01988_ _01985_ VGND VGND VPWR VPWR _01991_ sky130_fd_sc_hd__a21o_1
XFILLER_0_93_518 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XTAP_TAPCELL_ROW_63_1051 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
X_08353_ _01905_ _01915_ VGND VGND VPWR VPWR _01916_ sky130_fd_sc_hd__xor2_2
XFILLER_0_19_637 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_116_322 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
X_08284_ _01836_ _01838_ _01839_ VGND VGND VPWR VPWR _01841_ sky130_fd_sc_hd__a21o_1
X_07304_ _00631_ _00639_ VGND VGND VPWR VPWR _00770_ sky130_fd_sc_hd__nand2_1
XFILLER_0_33_106 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
X_07235_ net47 VGND VGND VPWR VPWR _00695_ sky130_fd_sc_hd__clkbuf_4
XTAP_TAPCELL_ROW_115_1704 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
X_07166_ net59 net58 net10 net11 VGND VGND VPWR VPWR _00619_ sky130_fd_sc_hd__and4_1
XFILLER_0_14_342 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_0_42_673 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_0_100_701 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
X_07097_ _00420_ _00442_ _00443_ VGND VGND VPWR VPWR _00544_ sky130_fd_sc_hd__nand3_2
X_06117_ _04824_ _04835_ VGND VGND VPWR VPWR _04846_ sky130_fd_sc_hd__or2b_1
X_06048_ _01192_ _03026_ _04085_ _01171_ VGND VGND VPWR VPWR _04096_ sky130_fd_sc_hd__a22oi_1
XTAP_TAPCELL_ROW_74_1191 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_5_81 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
X_09807_ _03264_ _03267_ _03501_ _03502_ VGND VGND VPWR VPWR _03503_ sky130_fd_sc_hd__a211o_1
X_07999_ _01401_ _01403_ _01526_ _01527_ VGND VGND VPWR VPWR _01528_ sky130_fd_sc_hd__o211a_1
X_09738_ _00344_ _02492_ _00346_ _02141_ VGND VGND VPWR VPWR _03427_ sky130_fd_sc_hd__and4_1
XFILLER_0_96_301 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XTAP_TAPCELL_ROW_45_819 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_96_356 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_96_334 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
X_09669_ _03147_ _03154_ _03153_ VGND VGND VPWR VPWR _03352_ sky130_fd_sc_hd__a21bo_1
XTAP_TAPCELL_ROW_25_576 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_92_551 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_25_607 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_107_333 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_0_107_322 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
X_10513_ _02840_ _01903_ _04269_ _04271_ VGND VGND VPWR VPWR _04273_ sky130_fd_sc_hd__nand4_2
XFILLER_0_92_573 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_0_80_713 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_0_9_391 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_24_106 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XFILLER_0_24_139 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
X_10444_ _04196_ _04197_ VGND VGND VPWR VPWR _04198_ sky130_fd_sc_hd__xnor2_1
X_10375_ _04120_ _04121_ _04102_ VGND VGND VPWR VPWR _04123_ sky130_fd_sc_hd__o21ai_2
XFILLER_0_103_561 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XFILLER_0_103_550 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_60_481 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_0_32_194 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XFILLER_0_46_59 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_0_87_312 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_87_356 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_0_75_529 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_0_28_456 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XPHY_EDGE_ROW_112_Right_112 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_0_15_117 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_11_51 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_0_3_512 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
X_07020_ _00457_ _00458_ _00459_ VGND VGND VPWR VPWR _00460_ sky130_fd_sc_hd__nand3_1
XPHY_EDGE_ROW_49_Right_49 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_0_23_161 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_0_24_695 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
X_08971_ _02577_ _02579_ _02588_ VGND VGND VPWR VPWR _02590_ sky130_fd_sc_hd__and3_1
XTAP_TAPCELL_ROW_110_1634 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
X_07922_ _01443_ _01445_ VGND VGND VPWR VPWR _01446_ sky130_fd_sc_hd__and2b_1
X_07853_ _03605_ net16 _01368_ _01369_ VGND VGND VPWR VPWR _01370_ sky130_fd_sc_hd__nand4_1
X_06804_ _00135_ _00154_ VGND VGND VPWR VPWR _00230_ sky130_fd_sc_hd__and2b_1
XPHY_EDGE_ROW_58_Right_58 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
X_07784_ _01112_ _01122_ _01121_ VGND VGND VPWR VPWR _01295_ sky130_fd_sc_hd__a21bo_1
X_06735_ _04878_ _05463_ _05387_ _03780_ VGND VGND VPWR VPWR _00162_ sky130_fd_sc_hd__a22o_1
X_09523_ _05305_ _02160_ _02177_ _05304_ VGND VGND VPWR VPWR _03193_ sky130_fd_sc_hd__a22o_1
X_09454_ _02949_ _02952_ _03115_ _03116_ VGND VGND VPWR VPWR _03117_ sky130_fd_sc_hd__a211o_1
X_06666_ net41 VGND VGND VPWR VPWR _00094_ sky130_fd_sc_hd__clkbuf_4
XFILLER_0_109_609 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_0_93_337 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
X_09385_ _03627_ _03027_ _03039_ _03040_ VGND VGND VPWR VPWR _03042_ sky130_fd_sc_hd__a22o_1
XFILLER_0_59_581 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
X_08405_ _01797_ _01799_ _01970_ _01971_ VGND VGND VPWR VPWR _01972_ sky130_fd_sc_hd__o211a_1
XTAP_TAPCELL_ROW_121_1785 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_121_1774 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
X_08336_ _01561_ _01733_ _01745_ VGND VGND VPWR VPWR _01897_ sky130_fd_sc_hd__a21oi_1
X_06597_ _05448_ _05529_ _05619_ VGND VGND VPWR VPWR _00026_ sky130_fd_sc_hd__nor3_1
XFILLER_0_62_713 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_0_19_478 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XTAP_TAPCELL_ROW_22_535 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_61_212 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XTAP_TAPCELL_ROW_50_888 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
X_08267_ _01819_ _01820_ _01638_ _01784_ VGND VGND VPWR VPWR _01822_ sky130_fd_sc_hd__o211a_1
XFILLER_0_117_697 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_104_336 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XPHY_EDGE_ROW_67_Right_67 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_0_15_673 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
X_08198_ _01561_ _01733_ _01745_ VGND VGND VPWR VPWR _01746_ sky130_fd_sc_hd__a21o_1
X_07218_ _01651_ _05693_ _00561_ _00560_ _00195_ VGND VGND VPWR VPWR _00676_ sky130_fd_sc_hd__a32o_1
XFILLER_0_104_358 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
X_07149_ _00474_ _00599_ _00475_ VGND VGND VPWR VPWR _00601_ sky130_fd_sc_hd__and3_1
XFILLER_0_30_621 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_0_30_643 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
X_10160_ _03876_ _03886_ _03887_ VGND VGND VPWR VPWR _03888_ sky130_fd_sc_hd__and3_1
X_10091_ _03687_ _03800_ _03810_ VGND VGND VPWR VPWR _03813_ sky130_fd_sc_hd__nand3_1
XFILLER_0_100_586 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XPHY_EDGE_ROW_76_Right_76 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_0_16_29 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
X_10993_ _04791_ _04793_ _04789_ _04790_ VGND VGND VPWR VPWR _04795_ sky130_fd_sc_hd__o211a_1
XTAP_TAPCELL_ROW_58_988 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_2_282 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_2_293 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_37_242 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_108_642 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XFILLER_0_52_201 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_108_664 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_107_130 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XPHY_EDGE_ROW_85_Right_85 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_0_4_309 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_25_437 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_80_565 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
X_10427_ _04173_ _04174_ _04177_ _04178_ VGND VGND VPWR VPWR _04179_ sky130_fd_sc_hd__o211a_1
X_10358_ _02325_ _03433_ _00896_ _01042_ _04003_ VGND VGND VPWR VPWR _04104_ sky130_fd_sc_hd__a41o_1
XFILLER_0_0_548 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
X_10289_ _04026_ _04027_ _03904_ _03906_ VGND VGND VPWR VPWR _04029_ sky130_fd_sc_hd__o211a_1
XFILLER_0_20_197 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XPHY_EDGE_ROW_94_Right_94 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_0_79_109 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
X_06520_ _05608_ VGND VGND VPWR VPWR _05649_ sky130_fd_sc_hd__inv_2
XFILLER_0_48_507 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_75_337 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
X_06451_ _05576_ _05579_ _05580_ VGND VGND VPWR VPWR _05581_ sky130_fd_sc_hd__and3_1
XFILLER_0_75_359 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XTAP_TAPCELL_ROW_60_1010 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_28_231 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
X_09170_ _02804_ _02805_ _02800_ _02801_ VGND VGND VPWR VPWR _02807_ sky130_fd_sc_hd__a211o_1
XFILLER_0_7_125 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
X_06382_ _05509_ _05510_ _05511_ VGND VGND VPWR VPWR _05513_ sky130_fd_sc_hd__a21oi_2
XFILLER_0_28_253 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_28_275 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_7_169 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_08121_ _01482_ _01660_ _01661_ VGND VGND VPWR VPWR _01663_ sky130_fd_sc_hd__nand3_2
XFILLER_0_43_223 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_114_645 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_113_111 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
X_08052_ _01581_ _01586_ VGND VGND VPWR VPWR _01587_ sky130_fd_sc_hd__xor2_2
XFILLER_0_113_133 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_12_621 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
X_07003_ _00438_ _00440_ _00441_ VGND VGND VPWR VPWR _00442_ sky130_fd_sc_hd__nand3_4
XFILLER_0_24_481 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_0_43_289 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_0_12_643 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
X_08954_ _02446_ _02408_ VGND VGND VPWR VPWR _02571_ sky130_fd_sc_hd__and2b_1
XFILLER_0_51_3 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XTAP_TAPCELL_ROW_71_1150 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
X_07905_ _01408_ _01409_ _01425_ VGND VGND VPWR VPWR _01427_ sky130_fd_sc_hd__nand3_4
X_08885_ _01605_ _02494_ _02495_ VGND VGND VPWR VPWR _02496_ sky130_fd_sc_hd__a21bo_1
X_07836_ _01046_ _01195_ _01350_ VGND VGND VPWR VPWR _01351_ sky130_fd_sc_hd__o21ai_2
XTAP_TAPCELL_ROW_27_605 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
X_07767_ _01039_ _00983_ VGND VGND VPWR VPWR _01276_ sky130_fd_sc_hd__nand2_1
XFILLER_0_94_602 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
X_09506_ _01782_ _02865_ _03173_ VGND VGND VPWR VPWR _03174_ sky130_fd_sc_hd__a21o_1
XFILLER_0_78_131 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
X_06718_ _00142_ _00144_ VGND VGND VPWR VPWR _00145_ sky130_fd_sc_hd__or2b_1
XTAP_TAPCELL_ROW_55_947 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_78_164 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
X_07698_ _01198_ _01199_ VGND VGND VPWR VPWR _01200_ sky130_fd_sc_hd__and2_1
XFILLER_0_39_529 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_109_428 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
X_09437_ _03095_ _03097_ VGND VGND VPWR VPWR _03098_ sky130_fd_sc_hd__xnor2_4
XFILLER_0_66_348 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
X_06649_ _03572_ _00076_ VGND VGND VPWR VPWR _00077_ sky130_fd_sc_hd__nand2_1
XFILLER_0_93_167 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XTAP_TAPCELL_ROW_82_1290 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
X_09368_ _03020_ _03021_ _03005_ VGND VGND VPWR VPWR _03023_ sky130_fd_sc_hd__a21oi_2
XFILLER_0_34_201 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
X_09299_ _00283_ _02947_ _02942_ _02945_ VGND VGND VPWR VPWR _02948_ sky130_fd_sc_hd__nand4_4
X_08319_ _01875_ _01876_ _01872_ VGND VGND VPWR VPWR _01878_ sky130_fd_sc_hd__a21o_1
X_11330_ _01501_ _03807_ _04042_ _01357_ VGND VGND VPWR VPWR _05158_ sky130_fd_sc_hd__a22o_1
XFILLER_0_120_604 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_105_667 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_0_62_587 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
X_11261_ _05082_ _05083_ VGND VGND VPWR VPWR _05085_ sky130_fd_sc_hd__nor2_1
X_11192_ _05006_ _05007_ _04505_ _04800_ VGND VGND VPWR VPWR _05010_ sky130_fd_sc_hd__and4bb_1
X_10212_ _03939_ _03942_ _03944_ VGND VGND VPWR VPWR _03945_ sky130_fd_sc_hd__or3_1
X_10143_ _03868_ _03869_ VGND VGND VPWR VPWR _03870_ sky130_fd_sc_hd__xnor2_2
XFILLER_0_100_361 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XTAP_TAPCELL_ROW_7_352 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
X_10074_ _03792_ _03793_ _03674_ _03676_ VGND VGND VPWR VPWR _03795_ sky130_fd_sc_hd__o211a_1
XFILLER_0_27_39 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XTAP_TAPCELL_ROW_85_1319 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_69_142 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_43_27 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
X_10976_ _04657_ _04774_ _04775_ VGND VGND VPWR VPWR _04776_ sky130_fd_sc_hd__or3_1
XFILLER_0_84_123 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_0_26_713 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_0_38_562 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_0_108_461 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_0_5_629 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_25_223 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_4_139 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XTAP_TAPCELL_ROW_96_1459 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_111_615 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
X_11459_ _01378_ _01422_ VGND VGND VPWR VPWR _05290_ sky130_fd_sc_hd__nor2_1
XFILLER_0_0_378 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
X_05951_ _01181_ _03026_ VGND VGND VPWR VPWR _03037_ sky130_fd_sc_hd__nand2_1
XFILLER_0_108_41 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
X_08670_ _02256_ _02259_ _02260_ VGND VGND VPWR VPWR _02261_ sky130_fd_sc_hd__nand3_2
X_05882_ _02186_ _02273_ VGND VGND VPWR VPWR _02284_ sky130_fd_sc_hd__nand2_1
XFILLER_0_108_85 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
X_07621_ _00646_ _00991_ _01114_ _00624_ VGND VGND VPWR VPWR _01117_ sky130_fd_sc_hd__a22o_1
XFILLER_0_88_440 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
X_07552_ _01040_ VGND VGND VPWR VPWR _01041_ sky130_fd_sc_hd__buf_4
XFILLER_0_88_473 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XTAP_TAPCELL_ROW_52_917 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_52_906 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
X_06503_ _05520_ _05616_ _05631_ _05456_ VGND VGND VPWR VPWR _05632_ sky130_fd_sc_hd__a211o_1
XTAP_TAPCELL_ROW_105_1577 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_76_679 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
X_07483_ _00949_ _00964_ _00965_ VGND VGND VPWR VPWR _00966_ sky130_fd_sc_hd__and3_2
XFILLER_0_48_348 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_09222_ _02185_ VGND VGND VPWR VPWR _02865_ sky130_fd_sc_hd__buf_4
XFILLER_0_8_434 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
X_06434_ _03255_ _05311_ _05561_ _05562_ VGND VGND VPWR VPWR _05564_ sky130_fd_sc_hd__nand4_4
XFILLER_0_90_126 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
X_09153_ _02787_ _02788_ VGND VGND VPWR VPWR _02789_ sky130_fd_sc_hd__xnor2_2
XFILLER_0_8_456 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XTAP_TAPCELL_ROW_32_663 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
X_06365_ _05008_ _05494_ _05495_ VGND VGND VPWR VPWR _05496_ sky130_fd_sc_hd__a21bo_1
XFILLER_0_44_510 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_71_351 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
X_08104_ _01641_ _01642_ _01461_ _01602_ VGND VGND VPWR VPWR _01644_ sky130_fd_sc_hd__o211a_1
X_09084_ _02523_ _02525_ _02541_ _02540_ _02538_ VGND VGND VPWR VPWR _02714_ sky130_fd_sc_hd__o32a_2
X_06296_ _05424_ _05426_ _05422_ VGND VGND VPWR VPWR _05428_ sky130_fd_sc_hd__a21o_1
XFILLER_0_114_475 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_102_637 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_0_3_161 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
X_08035_ _01553_ _01566_ _01567_ VGND VGND VPWR VPWR _01568_ sky130_fd_sc_hd__nor3_2
XFILLER_0_101_169 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_7_9 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
X_09986_ _03549_ _03552_ _03696_ VGND VGND VPWR VPWR _03698_ sky130_fd_sc_hd__and3_1
X_08937_ _02318_ _02377_ _02552_ VGND VGND VPWR VPWR _02553_ sky130_fd_sc_hd__a21oi_4
XTAP_TAPCELL_ROW_4_311 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
X_08868_ _02468_ _02475_ _02476_ VGND VGND VPWR VPWR _02477_ sky130_fd_sc_hd__nand3_1
XFILLER_0_98_237 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
X_07819_ _01198_ VGND VGND VPWR VPWR _01332_ sky130_fd_sc_hd__inv_2
XFILLER_0_98_259 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
X_08799_ _02231_ _02388_ _02401_ VGND VGND VPWR VPWR _02402_ sky130_fd_sc_hd__a21oi_1
X_10830_ _04614_ _04615_ _04595_ VGND VGND VPWR VPWR _04617_ sky130_fd_sc_hd__o21a_1
X_10761_ _04144_ _04541_ VGND VGND VPWR VPWR _04543_ sky130_fd_sc_hd__nand2_2
XFILLER_0_66_134 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_0_66_123 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_39_337 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
X_10692_ _00152_ _00237_ _03690_ _03172_ VGND VGND VPWR VPWR _04467_ sky130_fd_sc_hd__and4_1
XFILLER_0_66_156 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_109_258 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_0_62_340 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XFILLER_0_105_442 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_0_90_693 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_0_50_524 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_11313_ _05137_ _05139_ VGND VGND VPWR VPWR _05141_ sky130_fd_sc_hd__nor2_1
X_11244_ _01357_ _04732_ _01501_ _03178_ VGND VGND VPWR VPWR _05066_ sky130_fd_sc_hd__and4_1
XFILLER_0_50_579 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_38_27 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
X_11175_ _03827_ _04724_ _04915_ VGND VGND VPWR VPWR _04992_ sky130_fd_sc_hd__nand3_1
X_10126_ _03697_ _03849_ _03850_ VGND VGND VPWR VPWR _03851_ sky130_fd_sc_hd__nand3_4
XFILLER_0_100_191 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
X_10057_ _03760_ _03637_ _03774_ _03775_ VGND VGND VPWR VPWR _03776_ sky130_fd_sc_hd__a211oi_2
XFILLER_0_58_613 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_10959_ _04681_ _04684_ VGND VGND VPWR VPWR _04757_ sky130_fd_sc_hd__nand2_1
XFILLER_0_97_281 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_85_465 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XFILLER_0_72_126 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_5_404 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_45_329 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_5_437 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
X_06150_ _04672_ _05181_ _05192_ VGND VGND VPWR VPWR _05202_ sky130_fd_sc_hd__nand3_1
XFILLER_0_110_53 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
X_06081_ _04183_ _04194_ VGND VGND VPWR VPWR _04455_ sky130_fd_sc_hd__nor2_1
XFILLER_0_110_97 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_21_281 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_95_55 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
X_09840_ _05551_ _02136_ _01980_ _02178_ VGND VGND VPWR VPWR _03538_ sky130_fd_sc_hd__nand4_4
XFILLER_0_0_197 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_0_175 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_119_51 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_0_95_77 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_09771_ _03317_ _03390_ _03461_ _03462_ VGND VGND VPWR VPWR _03464_ sky130_fd_sc_hd__a211oi_1
X_06983_ _00410_ _00419_ VGND VGND VPWR VPWR _00420_ sky130_fd_sc_hd__xor2_2
X_05934_ _02819_ _02830_ _02164_ _02425_ VGND VGND VPWR VPWR _02852_ sky130_fd_sc_hd__a211oi_2
X_08722_ _02159_ _02170_ _02169_ VGND VGND VPWR VPWR _02319_ sky130_fd_sc_hd__a21o_1
XFILLER_0_96_719 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
X_08653_ _02241_ _02242_ VGND VGND VPWR VPWR _02243_ sky130_fd_sc_hd__xnor2_1
X_05865_ _02076_ _02087_ VGND VGND VPWR VPWR _02098_ sky130_fd_sc_hd__nor2_1
XFILLER_0_14_3 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XTAP_TAPCELL_ROW_37_722 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_95_229 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
X_05796_ _01160_ _01324_ VGND VGND VPWR VPWR _01345_ sky130_fd_sc_hd__xnor2_1
XFILLER_0_49_613 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
X_07604_ _00984_ _00988_ _00982_ VGND VGND VPWR VPWR _01098_ sky130_fd_sc_hd__o21ba_1
X_08584_ _03572_ _02163_ _02165_ _02166_ VGND VGND VPWR VPWR _02168_ sky130_fd_sc_hd__nand4_2
XFILLER_0_76_421 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
X_07535_ _00741_ _01021_ _01022_ VGND VGND VPWR VPWR _01023_ sky130_fd_sc_hd__nor3_1
XFILLER_0_48_112 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_0_119_545 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XTAP_TAPCELL_ROW_66_1093 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_66_1082 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
X_07466_ _00910_ _00911_ _00945_ _00946_ VGND VGND VPWR VPWR _00947_ sky130_fd_sc_hd__o211a_1
XFILLER_0_48_145 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_48_167 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XFILLER_0_119_556 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
X_09205_ _02839_ _02845_ VGND VGND VPWR VPWR _02846_ sky130_fd_sc_hd__xor2_4
XFILLER_0_29_381 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_06417_ _05470_ _05478_ VGND VGND VPWR VPWR _05547_ sky130_fd_sc_hd__or2_1
X_07397_ _00477_ _00727_ _00871_ VGND VGND VPWR VPWR _00872_ sky130_fd_sc_hd__o21ai_4
XTAP_TAPCELL_ROW_118_1735 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
X_09136_ _02625_ _02634_ _02632_ VGND VGND VPWR VPWR _02770_ sky130_fd_sc_hd__a21oi_1
X_06348_ _05470_ _05478_ VGND VGND VPWR VPWR _05479_ sky130_fd_sc_hd__xor2_1
X_09067_ _02173_ VGND VGND VPWR VPWR _02695_ sky130_fd_sc_hd__buf_4
X_06279_ _04705_ _05410_ _05407_ _05408_ VGND VGND VPWR VPWR _05411_ sky130_fd_sc_hd__and4_1
XFILLER_0_102_445 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
X_08018_ _01547_ _01548_ VGND VGND VPWR VPWR _01549_ sky130_fd_sc_hd__xor2_1
XFILLER_0_20_719 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_32_579 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_102_489 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
X_09969_ _03603_ _03604_ _03646_ _03647_ VGND VGND VPWR VPWR _03679_ sky130_fd_sc_hd__or4_2
XFILLER_0_67_410 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_0_24_29 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
X_10813_ _04503_ _04506_ VGND VGND VPWR VPWR _04599_ sky130_fd_sc_hd__nand2_1
XTAP_TAPCELL_ROW_15_449 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_39_167 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
X_10744_ _04521_ _04522_ _04429_ _04431_ VGND VGND VPWR VPWR _04524_ sky130_fd_sc_hd__a211o_1
X_10675_ _04447_ _04448_ _04343_ _04345_ VGND VGND VPWR VPWR _04449_ sky130_fd_sc_hd__o211ai_1
Xload_slew6 _01005_ VGND VGND VPWR VPWR net173 sky130_fd_sc_hd__clkbuf_2
XFILLER_0_23_502 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XTAP_TAPCELL_ROW_93_1429 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_50_365 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
X_11227_ _00754_ _04873_ _04984_ _05047_ VGND VGND VPWR VPWR _05048_ sky130_fd_sc_hd__a31o_1
X_11158_ _04905_ _04906_ VGND VGND VPWR VPWR _04973_ sky130_fd_sc_hd__and2b_1
X_10109_ _03820_ _03831_ VGND VGND VPWR VPWR _03832_ sky130_fd_sc_hd__xnor2_2
X_11089_ _04895_ _04897_ VGND VGND VPWR VPWR _04898_ sky130_fd_sc_hd__xnor2_1
XFILLER_0_78_719 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XTAP_TAPCELL_ROW_102_1536 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_85_251 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XFILLER_0_58_465 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_07320_ _00784_ _00785_ _00670_ _00672_ VGND VGND VPWR VPWR _00787_ sky130_fd_sc_hd__a211o_1
XFILLER_0_116_504 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_73_413 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_73_457 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_6_713 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
X_07251_ _00709_ _00710_ _00577_ _00674_ VGND VGND VPWR VPWR _00713_ sky130_fd_sc_hd__o211a_1
XTAP_TAPCELL_ROW_42_791 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
X_06202_ _03627_ _04737_ VGND VGND VPWR VPWR _05335_ sky130_fd_sc_hd__nand2_1
X_07182_ _00524_ _00527_ _00634_ _00636_ VGND VGND VPWR VPWR _00637_ sky130_fd_sc_hd__a211o_1
XFILLER_0_121_85 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
X_06133_ _00635_ _00657_ _04998_ _05008_ VGND VGND VPWR VPWR _05019_ sky130_fd_sc_hd__nand4_2
XFILLER_0_41_376 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
X_06064_ _04183_ _04194_ _04259_ VGND VGND VPWR VPWR _04270_ sky130_fd_sc_hd__or3_1
XTAP_TAPCELL_ROW_113_1676 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
X_09823_ _03369_ _03371_ _03519_ _03520_ VGND VGND VPWR VPWR _03521_ sky130_fd_sc_hd__a211oi_1
X_09754_ _02646_ _02813_ _03443_ _03444_ VGND VGND VPWR VPWR _03445_ sky130_fd_sc_hd__a22o_1
X_06966_ _00391_ _00400_ VGND VGND VPWR VPWR _00401_ sky130_fd_sc_hd__xnor2_1
XFILLER_0_96_505 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_09685_ _03367_ _03368_ _03213_ _03234_ VGND VGND VPWR VPWR _03370_ sky130_fd_sc_hd__o211ai_2
XTAP_TAPCELL_ROW_68_1111 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
X_08705_ _02108_ _00556_ _00038_ _01588_ VGND VGND VPWR VPWR _02300_ sky130_fd_sc_hd__nand4_2
X_05917_ _00679_ VGND VGND VPWR VPWR _02666_ sky130_fd_sc_hd__buf_2
X_06897_ _00215_ _00217_ net143 _00325_ VGND VGND VPWR VPWR _00326_ sky130_fd_sc_hd__a211o_1
XFILLER_0_68_207 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
X_05848_ _01138_ _01444_ _01902_ VGND VGND VPWR VPWR _01913_ sky130_fd_sc_hd__or3_4
X_08636_ _02223_ _02221_ _02222_ VGND VGND VPWR VPWR _02225_ sky130_fd_sc_hd__nand3_2
X_05779_ _00788_ _01149_ VGND VGND VPWR VPWR _01160_ sky130_fd_sc_hd__nand2_1
X_08567_ _02145_ _02146_ _02147_ VGND VGND VPWR VPWR _02149_ sky130_fd_sc_hd__a21o_1
XFILLER_0_37_605 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
X_08498_ _01877_ _01879_ _02071_ _02072_ VGND VGND VPWR VPWR _02073_ sky130_fd_sc_hd__a211oi_2
XTAP_TAPCELL_ROW_12_408 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
X_07518_ _01000_ _01001_ _01002_ VGND VGND VPWR VPWR _01004_ sky130_fd_sc_hd__a21oi_1
XFILLER_0_119_386 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_0_119_375 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_0_91_254 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_07449_ _00773_ _00775_ VGND VGND VPWR VPWR _00928_ sky130_fd_sc_hd__nand2_1
X_10460_ _04212_ _04213_ _04060_ _04062_ VGND VGND VPWR VPWR _04215_ sky130_fd_sc_hd__o211ai_2
XTAP_TAPCELL_ROW_79_1251 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
X_09119_ _02618_ _02659_ _02658_ VGND VGND VPWR VPWR _02751_ sky130_fd_sc_hd__a21bo_2
XFILLER_0_44_181 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
X_10391_ _04137_ _04139_ VGND VGND VPWR VPWR _04141_ sky130_fd_sc_hd__xnor2_2
XFILLER_0_60_696 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_0_3_3 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_102_297 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_11012_ _03440_ _02947_ _04812_ _04814_ VGND VGND VPWR VPWR _04815_ sky130_fd_sc_hd__a22o_1
XFILLER_0_99_398 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_0_67_251 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
X_10727_ _02941_ VGND VGND VPWR VPWR _04505_ sky130_fd_sc_hd__clkbuf_4
X_10658_ _04427_ _04428_ _04414_ _04326_ VGND VGND VPWR VPWR _04430_ sky130_fd_sc_hd__o211a_1
XFILLER_0_63_490 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
X_10589_ _04350_ _04355_ VGND VGND VPWR VPWR net105 sky130_fd_sc_hd__xnor2_2
XFILLER_0_106_592 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XFILLER_0_106_581 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XFILLER_0_51_652 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_11_505 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_0_23_376 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
X_06820_ _00244_ _00245_ _02666_ _00033_ VGND VGND VPWR VPWR _00246_ sky130_fd_sc_hd__and4bb_1
XFILLER_0_92_34 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_06751_ _03583_ _00076_ _00079_ _00078_ VGND VGND VPWR VPWR _00178_ sky130_fd_sc_hd__a31o_2
XFILLER_0_116_41 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
X_09470_ _03132_ _03133_ VGND VGND VPWR VPWR _03134_ sky130_fd_sc_hd__xor2_2
X_06682_ _00107_ _00108_ _00006_ _00073_ VGND VGND VPWR VPWR _00110_ sky130_fd_sc_hd__a211oi_2
X_05702_ _00308_ VGND VGND VPWR VPWR _00319_ sky130_fd_sc_hd__clkbuf_8
XTAP_TAPCELL_ROW_47_850 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_116_85 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
X_08421_ _01985_ _01986_ _01988_ VGND VGND VPWR VPWR _01990_ sky130_fd_sc_hd__nand3_1
XFILLER_0_58_251 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_86_571 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XTAP_TAPCELL_ROW_63_1052 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
X_08352_ _01912_ _01914_ VGND VGND VPWR VPWR _01915_ sky130_fd_sc_hd__and2b_1
X_07303_ _00758_ _00768_ VGND VGND VPWR VPWR _00769_ sky130_fd_sc_hd__xor2_2
X_08283_ _01836_ _01838_ _01839_ VGND VGND VPWR VPWR _01840_ sky130_fd_sc_hd__nand3_4
XFILLER_0_116_334 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_07234_ _00428_ _00430_ VGND VGND VPWR VPWR _00694_ sky130_fd_sc_hd__and2_1
XFILLER_0_81_3 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_61_449 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XFILLER_0_26_181 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_27_693 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_42_630 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_42_641 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XTAP_TAPCELL_ROW_115_1705 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
X_07165_ _00616_ _00617_ VGND VGND VPWR VPWR _00618_ sky130_fd_sc_hd__nor2_1
XFILLER_0_14_365 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
X_07096_ _00540_ _00541_ _00520_ _00521_ VGND VGND VPWR VPWR _00543_ sky130_fd_sc_hd__a211oi_2
X_06116_ _00504_ _03572_ _04792_ _04813_ VGND VGND VPWR VPWR _04835_ sky130_fd_sc_hd__a22o_1
XFILLER_0_100_713 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
X_06047_ _04074_ VGND VGND VPWR VPWR _04085_ sky130_fd_sc_hd__clkbuf_8
XTAP_TAPCELL_ROW_74_1181 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_1_281 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XTAP_TAPCELL_ROW_74_1192 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_10_593 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
X_09806_ _03499_ _03500_ _03486_ VGND VGND VPWR VPWR _03502_ sky130_fd_sc_hd__a21oi_2
XFILLER_0_5_93 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
X_07998_ _01502_ _01503_ _01524_ _01525_ VGND VGND VPWR VPWR _01527_ sky130_fd_sc_hd__o22ai_4
X_09737_ _03424_ _03425_ VGND VGND VPWR VPWR _03426_ sky130_fd_sc_hd__xor2_2
X_06949_ _00268_ _00276_ VGND VGND VPWR VPWR _00382_ sky130_fd_sc_hd__and2_1
X_09668_ _03348_ _03349_ _03340_ VGND VGND VPWR VPWR _03351_ sky130_fd_sc_hd__a21o_1
X_09599_ _03254_ _03273_ _03274_ VGND VGND VPWR VPWR _03275_ sky130_fd_sc_hd__nor3_1
XFILLER_0_49_240 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
X_08619_ _02203_ _02204_ _02130_ _02005_ VGND VGND VPWR VPWR _02206_ sky130_fd_sc_hd__o211ai_4
XPHY_EDGE_ROW_59_Left_181 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XTAP_TAPCELL_ROW_25_577 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
X_10512_ _02840_ _01903_ _04269_ _04271_ VGND VGND VPWR VPWR _04272_ sky130_fd_sc_hd__a22o_1
XFILLER_0_64_265 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_0_52_416 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_0_24_118 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
X_10443_ _04089_ _04091_ VGND VGND VPWR VPWR _04197_ sky130_fd_sc_hd__or2_1
X_10374_ _04102_ _04120_ _04121_ VGND VGND VPWR VPWR _04122_ sky130_fd_sc_hd__or3_2
XFILLER_0_60_493 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XPHY_EDGE_ROW_68_Left_190 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_0_87_335 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_62_37 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XFILLER_0_95_390 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XFILLER_0_43_438 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_43_449 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_113_337 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_0_3_524 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_113_348 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_51_493 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_11_335 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
X_08970_ _02586_ _02587_ VGND VGND VPWR VPWR _02588_ sky130_fd_sc_hd__xor2_1
XFILLER_0_11_379 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XTAP_TAPCELL_ROW_110_1635 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
X_07921_ _01607_ _00837_ _00991_ _00963_ VGND VGND VPWR VPWR _01445_ sky130_fd_sc_hd__a22o_1
X_07852_ _02513_ _04878_ net14 _00611_ VGND VGND VPWR VPWR _01369_ sky130_fd_sc_hd__nand4_2
Xinput1 mcand[0] VGND VGND VPWR VPWR net1 sky130_fd_sc_hd__clkbuf_8
X_06803_ _00228_ _00229_ VGND VGND VPWR VPWR net74 sky130_fd_sc_hd__nor2_1
X_09522_ _03014_ VGND VGND VPWR VPWR _03192_ sky130_fd_sc_hd__inv_2
X_07783_ _01290_ _01292_ _01282_ VGND VGND VPWR VPWR _01294_ sky130_fd_sc_hd__a21o_1
XFILLER_0_36_71 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
X_06734_ _04705_ _05327_ _05319_ _05387_ VGND VGND VPWR VPWR _00161_ sky130_fd_sc_hd__nand4_4
X_09453_ _03112_ _03114_ _03103_ VGND VGND VPWR VPWR _03116_ sky130_fd_sc_hd__a21oi_2
X_06665_ _01497_ _05593_ VGND VGND VPWR VPWR _00093_ sky130_fd_sc_hd__and2_1
X_09384_ _03627_ _03027_ _03039_ _03040_ VGND VGND VPWR VPWR _03041_ sky130_fd_sc_hd__nand4_2
X_08404_ _02764_ _01109_ _01968_ _01969_ VGND VGND VPWR VPWR _01971_ sky130_fd_sc_hd__a22o_1
XTAP_TAPCELL_ROW_121_1786 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_121_1775 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_117_610 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_108_109 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XFILLER_0_93_349 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_0_74_541 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XFILLER_0_74_530 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XFILLER_0_52_81 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
X_08335_ _01643_ net153 _01823_ _01824_ VGND VGND VPWR VPWR _01896_ sky130_fd_sc_hd__o211a_1
XFILLER_0_19_435 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
X_06596_ _05526_ _05629_ _00022_ _00023_ VGND VGND VPWR VPWR _00025_ sky130_fd_sc_hd__a22o_1
XFILLER_0_46_243 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XFILLER_0_74_574 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XTAP_TAPCELL_ROW_22_536 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_104_304 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XTAP_TAPCELL_ROW_50_889 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
X_08266_ _01638_ _01784_ _01819_ _01820_ VGND VGND VPWR VPWR _01821_ sky130_fd_sc_hd__a211oi_4
XFILLER_0_46_298 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_116_175 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_15_652 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
X_07217_ _00549_ _00551_ VGND VGND VPWR VPWR _00675_ sky130_fd_sc_hd__or2_1
X_08197_ _01743_ _01744_ VGND VGND VPWR VPWR _01745_ sky130_fd_sc_hd__or2_2
XTAP_TAPCELL_ROW_76_1210 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
X_07148_ _00474_ _00475_ _00599_ VGND VGND VPWR VPWR _00600_ sky130_fd_sc_hd__a21oi_1
XFILLER_0_15_685 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_100_510 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
X_07079_ _02458_ _05416_ _05318_ net5 VGND VGND VPWR VPWR _00524_ sky130_fd_sc_hd__nand4_2
X_10090_ _03687_ _03800_ _03810_ VGND VGND VPWR VPWR _03811_ sky130_fd_sc_hd__a21o_1
XFILLER_0_10_390 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
X_10992_ _04789_ _04790_ _04791_ _04793_ VGND VGND VPWR VPWR _04794_ sky130_fd_sc_hd__a211oi_2
XTAP_TAPCELL_ROW_87_1350 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_69_335 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XTAP_TAPCELL_ROW_58_989 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_2_283 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_32_29 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_80_500 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XFILLER_0_25_405 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_108_676 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_80_533 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_52_213 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XTAP_TAPCELL_ROW_98_1490 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
X_10426_ _00356_ _03396_ _04175_ _04176_ VGND VGND VPWR VPWR _04178_ sky130_fd_sc_hd__nand4_2
XFILLER_0_110_307 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_60_290 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_0_0_505 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_20_121 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
X_10357_ _03957_ _03966_ _03964_ VGND VGND VPWR VPWR _04103_ sky130_fd_sc_hd__a21o_1
X_10288_ _03904_ _03906_ _04026_ _04027_ VGND VGND VPWR VPWR _04028_ sky130_fd_sc_hd__a211oi_2
XFILLER_0_87_154 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_0_87_132 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_48_519 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_88_699 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
X_06450_ _03736_ _05410_ _05577_ _05578_ VGND VGND VPWR VPWR _05580_ sky130_fd_sc_hd__nand4_1
XFILLER_0_56_541 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XTAP_TAPCELL_ROW_60_1011 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_7_137 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_16_416 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
X_06381_ _05509_ _05510_ _05511_ VGND VGND VPWR VPWR _05512_ sky130_fd_sc_hd__and3_2
XFILLER_0_28_243 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_28_265 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_0_83_393 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_0_71_533 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_0_56_596 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
X_08120_ _01658_ _01659_ _01478_ _01492_ VGND VGND VPWR VPWR _01661_ sky130_fd_sc_hd__a211o_1
XFILLER_0_16_449 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_28_287 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_0_71_566 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
X_08051_ _01582_ _01583_ _01584_ VGND VGND VPWR VPWR _01586_ sky130_fd_sc_hd__a21bo_1
XFILLER_0_114_657 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
X_07002_ _00299_ _00309_ _00307_ VGND VGND VPWR VPWR _00441_ sky130_fd_sc_hd__a21bo_1
XFILLER_0_43_279 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_113_178 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_0_113_167 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_11_121 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_0_12_699 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
X_08953_ _00472_ _02230_ _02423_ _02422_ VGND VGND VPWR VPWR _02570_ sky130_fd_sc_hd__a31o_2
XTAP_TAPCELL_ROW_71_1151 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
X_07904_ _01408_ _01409_ _01425_ VGND VGND VPWR VPWR _01426_ sky130_fd_sc_hd__a21o_2
XFILLER_0_44_3 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
X_08884_ _00387_ _00830_ _00983_ _05550_ VGND VGND VPWR VPWR _02495_ sky130_fd_sc_hd__a22o_1
XFILLER_0_98_419 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
X_07835_ _01182_ _01194_ VGND VGND VPWR VPWR _01350_ sky130_fd_sc_hd__or2_1
X_07766_ _01266_ _01274_ VGND VGND VPWR VPWR _01275_ sky130_fd_sc_hd__xor2_2
X_09505_ _02251_ _02705_ VGND VGND VPWR VPWR _03173_ sky130_fd_sc_hd__and2_1
X_06717_ _01236_ _00143_ _00140_ _00141_ VGND VGND VPWR VPWR _00144_ sky130_fd_sc_hd__a22o_1
XTAP_TAPCELL_ROW_55_948 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_2_83 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_94_614 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_09436_ _04900_ _01849_ _02929_ _03096_ VGND VGND VPWR VPWR _03097_ sky130_fd_sc_hd__a31o_2
XFILLER_0_78_176 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_63_91 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
X_07697_ _01049_ _01197_ _01196_ VGND VGND VPWR VPWR _01199_ sky130_fd_sc_hd__a21o_1
XFILLER_0_94_658 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
X_06648_ _05497_ VGND VGND VPWR VPWR _00076_ sky130_fd_sc_hd__buf_4
XTAP_TAPCELL_ROW_82_1291 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
X_09367_ _03005_ _03020_ _03021_ VGND VGND VPWR VPWR _03022_ sky130_fd_sc_hd__and3_2
XFILLER_0_19_265 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_06579_ _05684_ _00006_ _00007_ VGND VGND VPWR VPWR _00008_ sky130_fd_sc_hd__or3_2
XTAP_TAPCELL_ROW_35_694 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_117_440 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XANTENNA_50 _03672_ VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
X_09298_ _01187_ VGND VGND VPWR VPWR _02947_ sky130_fd_sc_hd__clkbuf_8
X_08318_ _01872_ _01875_ _01876_ VGND VGND VPWR VPWR _01877_ sky130_fd_sc_hd__nand3_2
XFILLER_0_117_484 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_0_105_613 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_0_7_671 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
X_08249_ _01799_ _01801_ VGND VGND VPWR VPWR _01802_ sky130_fd_sc_hd__nor2_1
XFILLER_0_104_145 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_62_599 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_0_120_616 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
X_11260_ _05007_ _05010_ _05081_ VGND VGND VPWR VPWR _05083_ sky130_fd_sc_hd__nor3_1
X_11191_ _04505_ _04800_ _05006_ _05007_ VGND VGND VPWR VPWR _05009_ sky130_fd_sc_hd__o2bb2a_1
X_10211_ _00143_ _02695_ _03940_ _03941_ VGND VGND VPWR VPWR _03944_ sky130_fd_sc_hd__and4_1
X_10142_ _01249_ _03247_ VGND VGND VPWR VPWR _03869_ sky130_fd_sc_hd__nand2_1
X_10073_ _03674_ _03676_ _03792_ _03793_ VGND VGND VPWR VPWR _03794_ sky130_fd_sc_hd__a211oi_2
XTAP_TAPCELL_ROW_7_353 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_69_154 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
X_10975_ _04772_ _04773_ _04754_ VGND VGND VPWR VPWR _04775_ sky130_fd_sc_hd__o21a_1
XFILLER_0_5_608 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_7_17 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_25_279 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
X_11458_ _01400_ _01411_ VGND VGND VPWR VPWR net87 sky130_fd_sc_hd__xnor2_2
X_11389_ _05188_ _05191_ _05186_ VGND VGND VPWR VPWR _05222_ sky130_fd_sc_hd__o21ba_1
X_10409_ _04044_ _04156_ _04158_ VGND VGND VPWR VPWR _04159_ sky130_fd_sc_hd__and3_1
XFILLER_0_110_126 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
X_05950_ _03015_ VGND VGND VPWR VPWR _03026_ sky130_fd_sc_hd__buf_4
XFILLER_0_108_53 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_84_79 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
X_05881_ _02240_ _02262_ VGND VGND VPWR VPWR _02273_ sky130_fd_sc_hd__and2_1
XFILLER_0_17_51 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
X_07620_ _02447_ _00646_ _00991_ _01114_ VGND VGND VPWR VPWR _01115_ sky130_fd_sc_hd__nand4_2
XFILLER_0_108_97 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
X_07551_ net18 VGND VGND VPWR VPWR _01040_ sky130_fd_sc_hd__clkbuf_4
XTAP_TAPCELL_ROW_52_918 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_52_907 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
X_06502_ _05614_ _05615_ _05617_ VGND VGND VPWR VPWR _05631_ sky130_fd_sc_hd__and3b_1
XTAP_TAPCELL_ROW_105_1578 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_75_113 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
X_07482_ _00961_ _00962_ _00955_ VGND VGND VPWR VPWR _00965_ sky130_fd_sc_hd__a21o_1
XFILLER_0_29_530 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
X_09221_ _02862_ VGND VGND VPWR VPWR _02864_ sky130_fd_sc_hd__buf_4
XFILLER_0_91_617 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_0_63_319 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_33_94 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
X_06433_ _03255_ _04585_ _05561_ _05562_ VGND VGND VPWR VPWR _05563_ sky130_fd_sc_hd__a22o_1
XFILLER_0_90_138 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
X_09152_ _02607_ _02609_ VGND VGND VPWR VPWR _02788_ sky130_fd_sc_hd__nor2_1
X_06364_ _03201_ net34 net35 _02054_ VGND VGND VPWR VPWR _05495_ sky130_fd_sc_hd__a22o_1
XTAP_TAPCELL_ROW_32_664 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
X_08103_ _01461_ _01602_ _01641_ _01642_ VGND VGND VPWR VPWR _01643_ sky130_fd_sc_hd__a211oi_4
XFILLER_0_44_544 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_0_114_421 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_71_363 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
X_09083_ _02702_ _02712_ VGND VGND VPWR VPWR _02713_ sky130_fd_sc_hd__xor2_4
X_06295_ _05422_ _05424_ _05426_ VGND VGND VPWR VPWR _05427_ sky130_fd_sc_hd__nand3_1
XFILLER_0_102_627 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
X_08034_ _01554_ _01555_ _01565_ VGND VGND VPWR VPWR _01567_ sky130_fd_sc_hd__and3_1
XFILLER_0_101_137 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_09985_ _03549_ _03552_ _03696_ VGND VGND VPWR VPWR _03697_ sky130_fd_sc_hd__a21oi_2
X_08936_ _02376_ _02375_ VGND VGND VPWR VPWR _02552_ sky130_fd_sc_hd__and2b_1
XTAP_TAPCELL_ROW_4_312 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_99_717 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
X_08867_ _02473_ _02474_ _02470_ VGND VGND VPWR VPWR _02476_ sky130_fd_sc_hd__a21o_1
X_07818_ _01204_ _01309_ _01310_ VGND VGND VPWR VPWR _01331_ sky130_fd_sc_hd__nor3_1
XFILLER_0_79_441 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
X_08798_ _02386_ _02387_ VGND VGND VPWR VPWR _02401_ sky130_fd_sc_hd__nor2_1
XFILLER_0_79_485 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
X_07749_ _05310_ _00189_ _01253_ _01254_ VGND VGND VPWR VPWR _01256_ sky130_fd_sc_hd__o2bb2a_1
X_10760_ _04143_ _04245_ _04350_ _04451_ VGND VGND VPWR VPWR _04541_ sky130_fd_sc_hd__and4_2
XFILLER_0_39_349 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XFILLER_0_109_215 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_94_477 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
X_10691_ _04463_ _04464_ VGND VGND VPWR VPWR _04466_ sky130_fd_sc_hd__xor2_2
X_09419_ _02912_ _03064_ _03077_ VGND VGND VPWR VPWR _03078_ sky130_fd_sc_hd__a21oi_2
XFILLER_0_66_168 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_0_94_499 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_47_393 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XFILLER_0_35_555 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_117_281 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_0_62_363 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_23_717 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
X_11312_ _05137_ _05139_ VGND VGND VPWR VPWR _05140_ sky130_fd_sc_hd__and2_1
XFILLER_0_105_476 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_11243_ _05064_ VGND VGND VPWR VPWR _05065_ sky130_fd_sc_hd__inv_2
XFILLER_0_101_671 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
X_11174_ _04909_ _04910_ _04914_ VGND VGND VPWR VPWR _04991_ sky130_fd_sc_hd__or3b_1
XFILLER_0_30_293 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
X_10125_ _03847_ _03848_ _03832_ VGND VGND VPWR VPWR _03850_ sky130_fd_sc_hd__a21o_1
X_10056_ _03772_ _03773_ _03631_ _03633_ VGND VGND VPWR VPWR _03775_ sky130_fd_sc_hd__o211a_1
XFILLER_0_89_238 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_0_58_625 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
X_10958_ _04645_ _04654_ _04647_ VGND VGND VPWR VPWR _04756_ sky130_fd_sc_hd__a21o_1
XFILLER_0_85_422 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_0_73_617 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_73_606 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_0_70_37 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_116_719 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
X_10889_ _03490_ _03012_ _03491_ _02695_ VGND VGND VPWR VPWR _04681_ sky130_fd_sc_hd__nand4_2
XFILLER_0_72_116 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_0_66_691 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_26_511 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_53_385 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_0_5_449 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_0_13_216 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_41_503 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_102_3 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_79_57 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
X_06080_ _04336_ _04292_ _04183_ _04194_ VGND VGND VPWR VPWR _04444_ sky130_fd_sc_hd__or4_1
XFILLER_0_41_547 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_0_110_65 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XPHY_EDGE_ROW_9_Right_9 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_0_0_154 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_0_187 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_0_21_293 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XPHY_EDGE_ROW_107_Right_107 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
X_09770_ _03417_ _03418_ _03459_ _03460_ VGND VGND VPWR VPWR _03462_ sky130_fd_sc_hd__a22oi_2
XPHY_EDGE_ROW_13_Left_135 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
X_06982_ _00412_ _00418_ VGND VGND VPWR VPWR _00419_ sky130_fd_sc_hd__xnor2_1
X_08721_ _02277_ _02316_ VGND VGND VPWR VPWR _02318_ sky130_fd_sc_hd__xor2_4
X_05933_ _02164_ _02425_ _02819_ _02830_ VGND VGND VPWR VPWR _02841_ sky130_fd_sc_hd__o211a_1
XFILLER_0_28_61 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_0_28_72 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XFILLER_0_28_83 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
X_08652_ _00515_ _01671_ VGND VGND VPWR VPWR _02242_ sky130_fd_sc_hd__nand2_1
X_07603_ _00973_ _00976_ VGND VGND VPWR VPWR _01097_ sky130_fd_sc_hd__nand2_2
XTAP_TAPCELL_ROW_37_723 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
X_05864_ _00854_ net58 _00297_ _01607_ VGND VGND VPWR VPWR _02087_ sky130_fd_sc_hd__and4_1
XFILLER_0_88_260 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_05795_ _01160_ _01324_ VGND VGND VPWR VPWR _01334_ sky130_fd_sc_hd__or2b_1
X_08583_ _03091_ _02163_ _02165_ _02166_ VGND VGND VPWR VPWR _02167_ sky130_fd_sc_hd__a22o_1
XFILLER_0_88_282 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
X_07534_ _01019_ _01020_ _00862_ _00864_ VGND VGND VPWR VPWR _01022_ sky130_fd_sc_hd__o211a_1
XFILLER_0_44_82 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XFILLER_0_76_477 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XTAP_TAPCELL_ROW_66_1083 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
X_07465_ _00943_ _00944_ _00813_ _00815_ VGND VGND VPWR VPWR _00946_ sky130_fd_sc_hd__a211o_1
XFILLER_0_8_210 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XTAP_TAPCELL_ROW_17_480 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XPHY_EDGE_ROW_22_Left_144 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
X_09204_ _02840_ _02842_ _02844_ VGND VGND VPWR VPWR _02845_ sky130_fd_sc_hd__a21bo_1
X_06416_ _05538_ _05545_ VGND VGND VPWR VPWR _05546_ sky130_fd_sc_hd__xnor2_1
XFILLER_0_91_469 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
X_07396_ _00725_ _00726_ VGND VGND VPWR VPWR _00871_ sky130_fd_sc_hd__or2_1
XFILLER_0_29_393 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XTAP_TAPCELL_ROW_118_1736 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
X_09135_ _02767_ _02768_ VGND VGND VPWR VPWR _02769_ sky130_fd_sc_hd__xor2_2
XFILLER_0_8_298 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_06347_ _05476_ _05477_ VGND VGND VPWR VPWR _05478_ sky130_fd_sc_hd__nand2_1
X_09066_ _03572_ _02174_ _02691_ _02693_ VGND VGND VPWR VPWR _02694_ sky130_fd_sc_hd__nand4_1
X_06278_ net31 VGND VGND VPWR VPWR _05410_ sky130_fd_sc_hd__buf_4
X_08017_ _01374_ _01375_ VGND VGND VPWR VPWR _01548_ sky130_fd_sc_hd__or2_1
XFILLER_0_102_457 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_40_580 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XPHY_EDGE_ROW_31_Left_153 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
X_09968_ _03603_ VGND VGND VPWR VPWR _03678_ sky130_fd_sc_hd__inv_2
XFILLER_0_99_503 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XTAP_TAPCELL_ROW_90_1390 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
X_08919_ _00657_ _01987_ VGND VGND VPWR VPWR _02533_ sky130_fd_sc_hd__nand2_1
X_09899_ _03418_ _03535_ _03601_ _03602_ VGND VGND VPWR VPWR _03603_ sky130_fd_sc_hd__a211oi_2
XFILLER_0_87_709 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_10812_ _04466_ _04475_ _04474_ VGND VGND VPWR VPWR _04598_ sky130_fd_sc_hd__a21o_1
XFILLER_0_67_433 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XPHY_EDGE_ROW_40_Left_162 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_0_39_102 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_39_113 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XFILLER_0_39_135 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
X_10743_ _04429_ _04431_ _04521_ _04522_ VGND VGND VPWR VPWR _04523_ sky130_fd_sc_hd__o211ai_4
XFILLER_0_55_617 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_39_146 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_0_54_127 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
X_10674_ _04445_ _04446_ _04356_ _04358_ VGND VGND VPWR VPWR _04448_ sky130_fd_sc_hd__a211oi_2
XFILLER_0_40_29 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_120_210 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XTAP_TAPCELL_ROW_93_1419 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_11_709 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_0_120_232 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_50_399 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
X_11226_ _04979_ _04980_ _04983_ VGND VGND VPWR VPWR _05047_ sky130_fd_sc_hd__and3_1
X_11157_ _04970_ _04971_ VGND VGND VPWR VPWR _04972_ sky130_fd_sc_hd__and2_1
XFILLER_0_4_29 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
X_10108_ _03829_ _03830_ VGND VGND VPWR VPWR _03831_ sky130_fd_sc_hd__or2b_1
XFILLER_0_65_26 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
X_11088_ _04822_ _04823_ _04896_ VGND VGND VPWR VPWR _04897_ sky130_fd_sc_hd__a21o_1
X_10039_ _03753_ _03755_ VGND VGND VPWR VPWR _03756_ sky130_fd_sc_hd__xor2_2
XFILLER_0_81_47 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XTAP_TAPCELL_ROW_102_1537 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_58_477 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_14_41 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_14_85 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_116_516 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_73_447 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_54_650 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_5_213 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_07250_ _00577_ _00674_ _00709_ _00710_ VGND VGND VPWR VPWR _00711_ sky130_fd_sc_hd__a211oi_4
XFILLER_0_26_330 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_0_26_341 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XTAP_TAPCELL_ROW_42_781 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_42_792 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
X_06201_ _05325_ _05333_ VGND VGND VPWR VPWR _05334_ sky130_fd_sc_hd__xnor2_1
X_07181_ _02513_ net9 _00632_ _00633_ VGND VGND VPWR VPWR _00636_ sky130_fd_sc_hd__o2bb2a_1
X_06132_ net35 VGND VGND VPWR VPWR _05008_ sky130_fd_sc_hd__buf_4
X_06063_ _02885_ _04238_ _04249_ VGND VGND VPWR VPWR _04259_ sky130_fd_sc_hd__a21o_1
XFILLER_0_41_388 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XTAP_TAPCELL_ROW_113_1677 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
X_09822_ _03516_ _03517_ _03388_ VGND VGND VPWR VPWR _03520_ sky130_fd_sc_hd__o21a_1
X_09753_ _05541_ _05637_ _02163_ _02351_ VGND VGND VPWR VPWR _03444_ sky130_fd_sc_hd__nand4_2
X_08704_ _00294_ _00038_ _00686_ _05540_ VGND VGND VPWR VPWR _02299_ sky130_fd_sc_hd__a22o_1
X_06965_ _00398_ _00399_ VGND VGND VPWR VPWR _00400_ sky130_fd_sc_hd__xor2_1
X_09684_ _03213_ _03234_ _03367_ _03368_ VGND VGND VPWR VPWR _03369_ sky130_fd_sc_hd__a211o_1
XFILLER_0_69_709 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XTAP_TAPCELL_ROW_68_1112 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
X_05916_ _02611_ _02622_ _02633_ VGND VGND VPWR VPWR _02655_ sky130_fd_sc_hd__a21oi_1
X_06896_ _00257_ _00258_ _00322_ _00323_ VGND VGND VPWR VPWR _00325_ sky130_fd_sc_hd__o22a_1
X_05847_ _01880_ _01891_ VGND VGND VPWR VPWR _01902_ sky130_fd_sc_hd__nand2_1
X_08635_ _02221_ _02222_ _02223_ VGND VGND VPWR VPWR _02224_ sky130_fd_sc_hd__a21o_1
XFILLER_0_89_591 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
X_08566_ _02145_ _02146_ _02147_ VGND VGND VPWR VPWR _02148_ sky130_fd_sc_hd__nand3_4
XFILLER_0_119_321 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_92_701 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
X_05778_ _00766_ _00777_ VGND VGND VPWR VPWR _01149_ sky130_fd_sc_hd__or2_1
X_07517_ _01000_ _01001_ _01002_ VGND VGND VPWR VPWR _01003_ sky130_fd_sc_hd__and3_1
XFILLER_0_91_200 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_71_80 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
X_08497_ _02069_ _02070_ _02056_ VGND VGND VPWR VPWR _02072_ sky130_fd_sc_hd__a21boi_2
XFILLER_0_49_477 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XTAP_TAPCELL_ROW_12_409 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_107_505 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
X_07448_ _00918_ _00926_ VGND VGND VPWR VPWR _00927_ sky130_fd_sc_hd__xor2_2
XFILLER_0_36_138 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XFILLER_0_107_549 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_0_17_363 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
X_07379_ _00849_ _00850_ _00828_ VGND VGND VPWR VPWR _00852_ sky130_fd_sc_hd__a21oi_1
XTAP_TAPCELL_ROW_79_1252 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
X_09118_ _02594_ _02614_ _02749_ VGND VGND VPWR VPWR _02750_ sky130_fd_sc_hd__o21ba_2
XFILLER_0_44_193 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_0_115_582 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
X_10390_ _03990_ _03992_ _04138_ VGND VGND VPWR VPWR _04139_ sky130_fd_sc_hd__a21o_1
XFILLER_0_20_506 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
X_09049_ _02672_ _02673_ _02674_ VGND VGND VPWR VPWR _02675_ sky130_fd_sc_hd__nand3_1
X_11011_ _03490_ _03491_ _03297_ _03690_ VGND VGND VPWR VPWR _04814_ sky130_fd_sc_hd__nand4_2
XFILLER_0_99_322 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_99_388 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_0_87_528 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_0_95_561 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_28_606 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_0_67_285 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_55_414 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XFILLER_0_27_105 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
X_10726_ _03827_ _03489_ _04502_ _04503_ VGND VGND VPWR VPWR _04504_ sky130_fd_sc_hd__a22o_1
X_10657_ _04414_ _04326_ _04427_ _04428_ VGND VGND VPWR VPWR _04429_ sky130_fd_sc_hd__a211oi_4
XFILLER_0_70_439 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XFILLER_0_3_717 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_0_23_311 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_0_35_182 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
X_10588_ _04149_ _04351_ _04354_ VGND VGND VPWR VPWR _04355_ sky130_fd_sc_hd__o21a_1
XFILLER_0_51_664 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_2_238 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_23_388 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
X_11209_ _05026_ _05027_ VGND VGND VPWR VPWR _05028_ sky130_fd_sc_hd__xnor2_1
X_06750_ _00174_ _00175_ _00158_ VGND VGND VPWR VPWR _00177_ sky130_fd_sc_hd__a21oi_2
X_06681_ _00006_ _00073_ _00107_ _00108_ VGND VGND VPWR VPWR _00109_ sky130_fd_sc_hd__o211a_2
X_05701_ _00297_ VGND VGND VPWR VPWR _00308_ sky130_fd_sc_hd__buf_4
XFILLER_0_116_53 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
X_08420_ _03310_ _03321_ _01805_ _01987_ VGND VGND VPWR VPWR _01988_ sky130_fd_sc_hd__nand4_1
XTAP_TAPCELL_ROW_47_851 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_116_97 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_74_701 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_86_583 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XTAP_TAPCELL_ROW_63_1053 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
X_08351_ _01909_ _01910_ _01911_ VGND VGND VPWR VPWR _01914_ sky130_fd_sc_hd__a21o_1
XFILLER_0_19_617 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_08282_ _01494_ _01657_ _01656_ VGND VGND VPWR VPWR _01839_ sky130_fd_sc_hd__o21bai_2
X_07302_ _00765_ _00767_ VGND VGND VPWR VPWR _00768_ sky130_fd_sc_hd__xor2_2
XFILLER_0_6_533 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
X_07233_ _00687_ _00692_ VGND VGND VPWR VPWR _00693_ sky130_fd_sc_hd__xor2_2
X_07164_ _01247_ _01760_ _00496_ _00614_ VGND VGND VPWR VPWR _00617_ sky130_fd_sc_hd__and4_4
XFILLER_0_112_541 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_0_112_530 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XFILLER_0_14_377 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
X_07095_ _00520_ _00521_ _00540_ _00541_ VGND VGND VPWR VPWR _00542_ sky130_fd_sc_hd__o211a_1
X_06115_ _00504_ _03091_ _04792_ _04813_ VGND VGND VPWR VPWR _04824_ sky130_fd_sc_hd__and4_1
XFILLER_0_112_563 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
X_06046_ _04063_ VGND VGND VPWR VPWR _04074_ sky130_fd_sc_hd__buf_4
XTAP_TAPCELL_ROW_74_1182 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_74_1193 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
X_09805_ _03486_ _03499_ _03500_ VGND VGND VPWR VPWR _03501_ sky130_fd_sc_hd__and3_2
X_07997_ _01502_ _01503_ _01524_ _01525_ VGND VGND VPWR VPWR _01526_ sky130_fd_sc_hd__or4_2
X_09736_ _02976_ _00751_ VGND VGND VPWR VPWR _03425_ sky130_fd_sc_hd__nand2_1
X_06948_ _00274_ _00275_ VGND VGND VPWR VPWR _00381_ sky130_fd_sc_hd__and2_1
X_09667_ _03340_ _03348_ _03349_ VGND VGND VPWR VPWR _03350_ sky130_fd_sc_hd__nand3_1
XFILLER_0_69_539 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
X_06879_ _00194_ _00198_ _00196_ VGND VGND VPWR VPWR _00306_ sky130_fd_sc_hd__a21bo_1
X_08618_ _02130_ _02005_ _02203_ _02204_ VGND VGND VPWR VPWR _02205_ sky130_fd_sc_hd__a211o_1
X_09598_ _03271_ _03272_ _03115_ _03256_ VGND VGND VPWR VPWR _03274_ sky130_fd_sc_hd__a211oi_2
XFILLER_0_77_583 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XFILLER_0_77_561 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_49_285 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
X_08549_ _02127_ _02128_ VGND VGND VPWR VPWR _02129_ sky130_fd_sc_hd__nor2_2
XFILLER_0_64_244 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XTAP_TAPCELL_ROW_25_578 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
X_10511_ _00495_ _03324_ _03006_ _03012_ VGND VGND VPWR VPWR _04271_ sky130_fd_sc_hd__nand4_4
XFILLER_0_9_393 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_0_45_491 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
X_10442_ _04193_ _04195_ VGND VGND VPWR VPWR _04196_ sky130_fd_sc_hd__or2_1
XFILLER_0_32_141 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
X_10373_ _04117_ _04119_ _04008_ _04011_ VGND VGND VPWR VPWR _04121_ sky130_fd_sc_hd__a211oi_2
XFILLER_0_0_709 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_99_130 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_62_27 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XTAP_TAPCELL_ROW_44_810 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_28_403 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_0_55_211 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
X_10709_ _03433_ _01856_ _04483_ _04484_ VGND VGND VPWR VPWR _04485_ sky130_fd_sc_hd__o2bb2a_1
XFILLER_0_3_503 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_3_536 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_11_358 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_0_23_185 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_121_393 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_121_371 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_07920_ _00297_ net27 net48 net49 VGND VGND VPWR VPWR _01443_ sky130_fd_sc_hd__and4_1
XTAP_TAPCELL_ROW_110_1636 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
X_07851_ _03223_ net14 _00611_ _00810_ VGND VGND VPWR VPWR _01368_ sky130_fd_sc_hd__a22o_1
X_06802_ _00128_ _00227_ _00129_ VGND VGND VPWR VPWR _00229_ sky130_fd_sc_hd__nor3_1
X_07782_ _01282_ _01290_ _01292_ VGND VGND VPWR VPWR _01293_ sky130_fd_sc_hd__nand3_2
Xinput2 mcand[10] VGND VGND VPWR VPWR net2 sky130_fd_sc_hd__buf_2
X_09521_ _03188_ _03189_ VGND VGND VPWR VPWR _03191_ sky130_fd_sc_hd__xor2_1
X_06733_ _00074_ _00082_ VGND VGND VPWR VPWR _00160_ sky130_fd_sc_hd__nand2_1
XFILLER_0_36_83 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_78_358 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
X_09452_ _03103_ _03112_ _03114_ VGND VGND VPWR VPWR _03115_ sky130_fd_sc_hd__and3_2
X_06664_ _00085_ _00091_ VGND VGND VPWR VPWR _00092_ sky130_fd_sc_hd__xnor2_2
XFILLER_0_93_317 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
X_09383_ _03036_ _03038_ _03028_ VGND VGND VPWR VPWR _03040_ sky130_fd_sc_hd__a21o_1
XFILLER_0_59_561 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
X_06595_ _05526_ _05629_ _00022_ _00023_ VGND VGND VPWR VPWR _00024_ sky130_fd_sc_hd__nand4_1
X_08403_ _05410_ _01441_ _01968_ _01969_ VGND VGND VPWR VPWR _01970_ sky130_fd_sc_hd__nand4_2
XTAP_TAPCELL_ROW_121_1776 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_59_594 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
X_08334_ _01892_ _01893_ _01848_ _01708_ VGND VGND VPWR VPWR _01895_ sky130_fd_sc_hd__o211a_1
XTAP_TAPCELL_ROW_121_1787 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_116_121 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_0_74_586 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XTAP_TAPCELL_ROW_22_537 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_34_417 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_0_116_154 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
X_08265_ _01817_ _01818_ _01795_ VGND VGND VPWR VPWR _01820_ sky130_fd_sc_hd__a21oi_2
XFILLER_0_6_363 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_15_664 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_07216_ _00555_ _00577_ _00578_ VGND VGND VPWR VPWR _00674_ sky130_fd_sc_hd__nand3_2
X_08196_ _01741_ _01742_ _01734_ VGND VGND VPWR VPWR _01744_ sky130_fd_sc_hd__a21oi_1
XTAP_TAPCELL_ROW_76_1211 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
X_07147_ _00596_ _00598_ VGND VGND VPWR VPWR _00599_ sky130_fd_sc_hd__xnor2_2
XFILLER_0_15_697 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_30_601 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_42_483 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XPHY_EDGE_ROW_5_Left_127 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_0_30_645 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
X_07078_ _00410_ _00419_ VGND VGND VPWR VPWR _00523_ sky130_fd_sc_hd__and2_1
XFILLER_0_30_678 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
X_06029_ _03845_ _03867_ _03823_ VGND VGND VPWR VPWR _03889_ sky130_fd_sc_hd__a21o_1
XFILLER_0_97_612 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_69_303 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
X_10991_ _04711_ _04713_ VGND VGND VPWR VPWR _04793_ sky130_fd_sc_hd__and2b_1
XTAP_TAPCELL_ROW_87_1351 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
X_09719_ _03300_ _03400_ _03404_ _03405_ VGND VGND VPWR VPWR _03406_ sky130_fd_sc_hd__a211o_1
XFILLER_0_69_358 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XTAP_TAPCELL_ROW_2_284 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_96_166 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_37_222 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XFILLER_0_53_704 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XFILLER_0_92_372 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_25_417 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XFILLER_0_108_688 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_107_165 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_0_80_545 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_107_198 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XTAP_TAPCELL_ROW_98_1491 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
X_10425_ _00762_ _03396_ _04175_ _04176_ VGND VGND VPWR VPWR _04177_ sky130_fd_sc_hd__a22o_1
XFILLER_0_80_589 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_0_0_517 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
X_10356_ _04100_ _04101_ VGND VGND VPWR VPWR _04102_ sky130_fd_sc_hd__xor2_2
XFILLER_0_20_166 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
X_10287_ _04024_ _04025_ _03897_ _03899_ VGND VGND VPWR VPWR _04027_ sky130_fd_sc_hd__o211a_1
XFILLER_0_88_645 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_88_612 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_87_144 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_0_87_166 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XFILLER_0_118_419 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_7_105 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_0_90_309 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XTAP_TAPCELL_ROW_60_1012 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_56_575 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_22_41 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
X_06380_ _05421_ _05431_ _05430_ VGND VGND VPWR VPWR _05511_ sky130_fd_sc_hd__a21bo_1
XFILLER_0_7_149 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_22_74 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_22_85 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_114_625 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_113_113 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_3_300 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_31_409 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_08050_ net5 _05593_ _05696_ _05318_ VGND VGND VPWR VPWR _01584_ sky130_fd_sc_hd__a22o_1
XFILLER_0_114_669 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_71_589 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_12_601 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
X_07001_ _00436_ _00437_ _00427_ VGND VGND VPWR VPWR _00440_ sky130_fd_sc_hd__a21o_1
XFILLER_0_12_645 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_11_111 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_11_144 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
X_08952_ _02567_ _02569_ VGND VGND VPWR VPWR net91 sky130_fd_sc_hd__xor2_4
XFILLER_0_11_188 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XTAP_TAPCELL_ROW_71_1152 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
X_08883_ _05550_ _00387_ _00830_ VGND VGND VPWR VPWR _02494_ sky130_fd_sc_hd__and3_1
X_07903_ _01416_ _01424_ VGND VGND VPWR VPWR _01425_ sky130_fd_sc_hd__xnor2_2
X_07834_ _01335_ _01348_ VGND VGND VPWR VPWR _01349_ sky130_fd_sc_hd__xor2_2
XFILLER_0_47_82 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
X_07765_ _01267_ _01273_ VGND VGND VPWR VPWR _01274_ sky130_fd_sc_hd__xnor2_2
X_09504_ _03171_ VGND VGND VPWR VPWR _03172_ sky130_fd_sc_hd__buf_4
X_06716_ net9 VGND VGND VPWR VPWR _00143_ sky130_fd_sc_hd__buf_4
XTAP_TAPCELL_ROW_55_949 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
X_07696_ _01049_ _01196_ _01197_ VGND VGND VPWR VPWR _01198_ sky130_fd_sc_hd__nand3_1
X_09435_ _02926_ _02927_ VGND VGND VPWR VPWR _03096_ sky130_fd_sc_hd__and2b_1
XFILLER_0_66_328 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_66_306 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
X_06647_ _05687_ _05690_ _05685_ VGND VGND VPWR VPWR _00075_ sky130_fd_sc_hd__o21ba_2
XFILLER_0_93_147 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_0_93_136 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_19_222 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XFILLER_0_19_233 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_0_93_169 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XTAP_TAPCELL_ROW_82_1292 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_82_1281 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_74_350 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
X_09366_ _03018_ _03019_ _03011_ VGND VGND VPWR VPWR _03021_ sky130_fd_sc_hd__a21o_1
X_06578_ _00003_ _00004_ _00005_ VGND VGND VPWR VPWR _00007_ sky130_fd_sc_hd__a21oi_2
XTAP_TAPCELL_ROW_35_695 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_35_704 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
X_09297_ _00283_ _02941_ _02942_ _02945_ VGND VGND VPWR VPWR _02946_ sky130_fd_sc_hd__a22o_1
X_08317_ _03255_ _01187_ _01873_ _01874_ VGND VGND VPWR VPWR _01876_ sky130_fd_sc_hd__nand4_2
XANTENNA_40 net117 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_0_47_597 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_0_117_496 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_105_625 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_0_105_603 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XANTENNA_51 _04748_ VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_0_62_567 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
X_08248_ _01662_ _01800_ _01796_ _01797_ VGND VGND VPWR VPWR _01801_ sky130_fd_sc_hd__o2bb2a_1
XFILLER_0_15_461 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_120_628 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_104_157 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
X_10210_ _00041_ _02174_ _03940_ _03941_ VGND VGND VPWR VPWR _03942_ sky130_fd_sc_hd__a22oi_2
X_08179_ _01722_ _01723_ _01724_ VGND VGND VPWR VPWR _01725_ sky130_fd_sc_hd__nand3_1
X_11190_ _00896_ _03027_ _05005_ VGND VGND VPWR VPWR _05007_ sky130_fd_sc_hd__and3_1
XFILLER_0_30_453 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
X_10141_ _03865_ _03866_ VGND VGND VPWR VPWR _03868_ sky130_fd_sc_hd__xnor2_2
X_10072_ _03789_ _03790_ _03651_ _03653_ VGND VGND VPWR VPWR _03793_ sky130_fd_sc_hd__o211a_1
XTAP_TAPCELL_ROW_7_354 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_69_111 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
X_10974_ _04754_ _04772_ _04773_ VGND VGND VPWR VPWR _04774_ sky130_fd_sc_hd__nor3_1
XFILLER_0_97_453 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_97_442 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_0_84_169 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_0_84_147 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_0_65_383 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_0_65_372 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XFILLER_0_53_523 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_25_225 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XFILLER_0_53_578 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_41_718 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XFILLER_0_111_617 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_80_397 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
X_11457_ _01411_ _05289_ VGND VGND VPWR VPWR net76 sky130_fd_sc_hd__nor2_2
XFILLER_0_7_29 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
X_11388_ _05219_ _05220_ VGND VGND VPWR VPWR _05221_ sky130_fd_sc_hd__nand2_1
XFILLER_0_110_138 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
X_10408_ _00042_ _04157_ _04154_ _04155_ VGND VGND VPWR VPWR _04158_ sky130_fd_sc_hd__nand4_2
XFILLER_0_68_37 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
X_10339_ _04043_ _04044_ _04080_ _04081_ VGND VGND VPWR VPWR _04083_ sky130_fd_sc_hd__o22a_1
XFILLER_0_21_486 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
X_05880_ _00362_ _01782_ _02251_ net33 VGND VGND VPWR VPWR _02262_ sky130_fd_sc_hd__a22o_1
XFILLER_0_108_65 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_88_453 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
X_07550_ _00918_ _00926_ VGND VGND VPWR VPWR _01038_ sky130_fd_sc_hd__or2_1
XTAP_TAPCELL_ROW_52_908 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
X_06501_ _05616_ _05617_ VGND VGND VPWR VPWR _05630_ sky130_fd_sc_hd__or2b_1
XFILLER_0_118_205 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XTAP_TAPCELL_ROW_105_1579 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
X_09220_ _02705_ VGND VGND VPWR VPWR _02862_ sky130_fd_sc_hd__clkbuf_4
XFILLER_0_76_637 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
X_07481_ _00955_ _00961_ _00962_ VGND VGND VPWR VPWR _00964_ sky130_fd_sc_hd__nand3_1
XFILLER_0_75_169 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_0_8_425 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
X_06432_ _04705_ _05327_ _05307_ _05308_ VGND VGND VPWR VPWR _05562_ sky130_fd_sc_hd__nand4_4
XPHY_EDGE_ROW_86_Left_208 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
X_09151_ _02784_ _02785_ VGND VGND VPWR VPWR _02787_ sky130_fd_sc_hd__or2b_1
XFILLER_0_16_214 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
X_06363_ _02054_ _03201_ net34 VGND VGND VPWR VPWR _05494_ sky130_fd_sc_hd__and3_1
XTAP_TAPCELL_ROW_32_665 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_44_523 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
X_09082_ _02709_ _02711_ VGND VGND VPWR VPWR _02712_ sky130_fd_sc_hd__and2b_1
XFILLER_0_16_236 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
X_08102_ _01638_ _01639_ _01619_ VGND VGND VPWR VPWR _01642_ sky130_fd_sc_hd__a21oi_2
XFILLER_0_44_567 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
X_08033_ _01554_ _01555_ _01565_ VGND VGND VPWR VPWR _01566_ sky130_fd_sc_hd__a21oi_4
X_06294_ _00548_ _05342_ _05425_ _00526_ VGND VGND VPWR VPWR _05426_ sky130_fd_sc_hd__a22o_1
XFILLER_0_44_589 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_0_114_477 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
Xinput60 mplier[5] VGND VGND VPWR VPWR net60 sky130_fd_sc_hd__buf_2
XFILLER_0_24_291 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
X_09984_ _03688_ _03695_ VGND VGND VPWR VPWR _03696_ sky130_fd_sc_hd__xor2_1
XFILLER_0_58_92 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_0_58_81 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XPHY_EDGE_ROW_95_Left_217 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
X_08935_ _02489_ _02550_ VGND VGND VPWR VPWR _02551_ sky130_fd_sc_hd__xnor2_4
XTAP_TAPCELL_ROW_4_313 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
X_08866_ _02470_ _02473_ _02474_ VGND VGND VPWR VPWR _02475_ sky130_fd_sc_hd__nand3_1
X_08797_ _02391_ _02400_ VGND VGND VPWR VPWR net90 sky130_fd_sc_hd__xor2_2
X_07817_ _01201_ _01202_ _01329_ VGND VGND VPWR VPWR _01330_ sky130_fd_sc_hd__a21oi_1
XTAP_TAPCELL_ROW_84_1310 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_74_91 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
X_07748_ _01253_ _01254_ net3 _00189_ VGND VGND VPWR VPWR _01255_ sky130_fd_sc_hd__and4bb_1
X_07679_ _00738_ _00903_ _01056_ _01178_ VGND VGND VPWR VPWR _01179_ sky130_fd_sc_hd__a31oi_2
X_10690_ _00751_ _03396_ VGND VGND VPWR VPWR _04464_ sky130_fd_sc_hd__nand2_1
X_09418_ _03061_ _03063_ VGND VGND VPWR VPWR _03077_ sky130_fd_sc_hd__nor2_1
XFILLER_0_54_309 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_0_94_489 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
X_09349_ _02965_ _02827_ _03000_ _03001_ VGND VGND VPWR VPWR _03002_ sky130_fd_sc_hd__o211ai_4
XFILLER_0_90_640 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
X_11311_ _05079_ _05087_ _05085_ _05016_ VGND VGND VPWR VPWR _05139_ sky130_fd_sc_hd__a2bb2o_1
XFILLER_0_35_578 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XTAP_TAPCELL_ROW_95_1450 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
X_11242_ _04732_ _01500_ _03178_ _01357_ VGND VGND VPWR VPWR _05064_ sky130_fd_sc_hd__a22o_1
X_11173_ _04940_ _04989_ VGND VGND VPWR VPWR _04990_ sky130_fd_sc_hd__xnor2_1
X_10124_ _03832_ _03847_ _03848_ VGND VGND VPWR VPWR _03849_ sky130_fd_sc_hd__nand3_4
X_10055_ _03631_ _03633_ _03772_ _03773_ VGND VGND VPWR VPWR _03774_ sky130_fd_sc_hd__a211oi_4
XFILLER_0_89_217 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_0_97_250 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
X_10957_ _04605_ _04608_ _04689_ _04690_ VGND VGND VPWR VPWR _04755_ sky130_fd_sc_hd__a211oi_1
XFILLER_0_57_136 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
X_10888_ _01977_ _02944_ _02695_ _02943_ VGND VGND VPWR VPWR _04680_ sky130_fd_sc_hd__a22o_1
XFILLER_0_26_523 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_0_38_383 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_81_673 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_81_662 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_80_194 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XFILLER_0_79_69 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_110_77 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_0_0_111 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_111_447 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_95_57 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_95_46 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_0_166 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
X_06981_ _00415_ _00416_ VGND VGND VPWR VPWR _00418_ sky130_fd_sc_hd__or2_1
X_08720_ _02314_ _02315_ VGND VGND VPWR VPWR _02316_ sky130_fd_sc_hd__nor2_2
X_05932_ _02644_ _02655_ _02808_ VGND VGND VPWR VPWR _02830_ sky130_fd_sc_hd__o21ai_2
X_08651_ _01850_ _02238_ _02239_ VGND VGND VPWR VPWR _02241_ sky130_fd_sc_hd__a21bo_1
X_05863_ _00854_ _02054_ _02065_ _00581_ VGND VGND VPWR VPWR _02076_ sky130_fd_sc_hd__a22oi_1
X_07602_ _00968_ _00969_ _01008_ _01009_ VGND VGND VPWR VPWR _01096_ sky130_fd_sc_hd__or4bb_1
XTAP_TAPCELL_ROW_37_724 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
X_05794_ _00319_ _01181_ _01302_ _01313_ VGND VGND VPWR VPWR _01324_ sky130_fd_sc_hd__a31o_1
X_08582_ _04770_ _02251_ _01798_ _01976_ VGND VGND VPWR VPWR _02166_ sky130_fd_sc_hd__nand4_2
XFILLER_0_88_294 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XFILLER_0_49_626 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
X_07533_ _00862_ _00864_ _01019_ _01020_ VGND VGND VPWR VPWR _01021_ sky130_fd_sc_hd__a211oi_2
XFILLER_0_48_125 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XTAP_TAPCELL_ROW_66_1084 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
X_07464_ _00813_ _00815_ _00943_ _00944_ VGND VGND VPWR VPWR _00945_ sky130_fd_sc_hd__o211ai_4
XTAP_TAPCELL_ROW_17_470 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_107_709 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_09203_ _05553_ _02812_ _02843_ _05464_ VGND VGND VPWR VPWR _02844_ sky130_fd_sc_hd__a22o_1
XFILLER_0_57_681 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
X_06415_ _05543_ _05544_ VGND VGND VPWR VPWR _05545_ sky130_fd_sc_hd__nor2_1
XFILLER_0_17_501 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
X_09134_ _03616_ _02227_ VGND VGND VPWR VPWR _02768_ sky130_fd_sc_hd__nand2_1
XFILLER_0_60_71 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
X_07395_ _00735_ _00869_ VGND VGND VPWR VPWR _00870_ sky130_fd_sc_hd__xor2_2
XTAP_TAPCELL_ROW_118_1737 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
X_06346_ _05473_ _05474_ _05475_ VGND VGND VPWR VPWR _05477_ sky130_fd_sc_hd__o21bai_1
XFILLER_0_114_230 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_09065_ _01782_ _02251_ _02160_ _02692_ VGND VGND VPWR VPWR _02693_ sky130_fd_sc_hd__nand4_2
X_06277_ _03791_ _03091_ _05407_ _05408_ VGND VGND VPWR VPWR _05409_ sky130_fd_sc_hd__a22oi_1
X_08016_ _01543_ _01546_ VGND VGND VPWR VPWR _01547_ sky130_fd_sc_hd__xor2_1
XFILLER_0_8_83 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_69_91 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XFILLER_0_110_491 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
X_09967_ _03646_ VGND VGND VPWR VPWR _03677_ sky130_fd_sc_hd__inv_2
XTAP_TAPCELL_ROW_90_1391 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
X_08918_ _02528_ _02530_ _02527_ VGND VGND VPWR VPWR _02532_ sky130_fd_sc_hd__a21o_1
X_09898_ _03599_ _03600_ _03559_ VGND VGND VPWR VPWR _03602_ sky130_fd_sc_hd__o21a_1
X_08849_ _05686_ net13 VGND VGND VPWR VPWR _02456_ sky130_fd_sc_hd__and2_1
X_10811_ _04421_ _04423_ _04512_ _04513_ VGND VGND VPWR VPWR _04597_ sky130_fd_sc_hd__a211oi_2
XFILLER_0_67_423 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_0_39_125 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
X_10742_ _04518_ _04519_ _04395_ VGND VGND VPWR VPWR _04522_ sky130_fd_sc_hd__a21o_1
XFILLER_0_94_253 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_0_67_445 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_0_67_478 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_55_629 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_54_117 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
X_10673_ _04356_ _04358_ _04445_ _04446_ VGND VGND VPWR VPWR _04447_ sky130_fd_sc_hd__o211a_1
XFILLER_0_54_139 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_63_673 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_63_662 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_121_701 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XFILLER_0_105_241 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_90_470 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_0_62_194 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XFILLER_0_62_161 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
X_11225_ _05044_ _05045_ VGND VGND VPWR VPWR _05046_ sky130_fd_sc_hd__nor2_1
X_11156_ _04968_ _04969_ VGND VGND VPWR VPWR _04971_ sky130_fd_sc_hd__nand2_1
XFILLER_0_4_19 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_11087_ _04808_ _04819_ _04820_ VGND VGND VPWR VPWR _04896_ sky130_fd_sc_hd__and3_1
X_10107_ _03826_ _03828_ _03821_ _03822_ VGND VGND VPWR VPWR _03830_ sky130_fd_sc_hd__a211o_1
X_10038_ _00283_ _03478_ _03613_ _03754_ VGND VGND VPWR VPWR _03755_ sky130_fd_sc_hd__a31o_1
XFILLER_0_65_49 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_81_15 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_105_55 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_85_242 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XFILLER_0_14_53 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XTAP_TAPCELL_ROW_102_1538 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_14_440 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_39_670 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XFILLER_0_14_97 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
X_06200_ _05326_ _05332_ VGND VGND VPWR VPWR _05333_ sky130_fd_sc_hd__xor2_1
XTAP_TAPCELL_ROW_42_782 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_60_109 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XFILLER_0_54_662 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_30_41 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
X_07180_ _00632_ _00633_ _02513_ net9 VGND VGND VPWR VPWR _00634_ sky130_fd_sc_hd__and4bb_1
XTAP_TAPCELL_ROW_42_793 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_121_65 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_112_701 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
X_06131_ net34 VGND VGND VPWR VPWR _04998_ sky130_fd_sc_hd__buf_4
XFILLER_0_41_301 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
X_06062_ _02841_ _04227_ _04205_ _04216_ VGND VGND VPWR VPWR _04249_ sky130_fd_sc_hd__o211a_2
XFILLER_0_30_85 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_111_244 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_22_581 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_0_111_288 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XTAP_TAPCELL_ROW_113_1678 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
X_09821_ _03388_ _03516_ _03517_ VGND VGND VPWR VPWR _03519_ sky130_fd_sc_hd__nor3_2
XFILLER_0_39_72 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
X_09752_ _02641_ _02843_ _02351_ _02640_ VGND VGND VPWR VPWR _03443_ sky130_fd_sc_hd__a22o_1
X_08703_ _05467_ _02134_ _02138_ _02137_ _01604_ VGND VGND VPWR VPWR _02298_ sky130_fd_sc_hd__a32o_1
X_06964_ _05419_ _05311_ _00272_ _00271_ VGND VGND VPWR VPWR _00399_ sky130_fd_sc_hd__a31o_1
X_09683_ _03280_ _03281_ _03364_ _03366_ VGND VGND VPWR VPWR _03368_ sky130_fd_sc_hd__a2bb2oi_1
XTAP_TAPCELL_ROW_68_1113 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
X_06895_ _00257_ _00258_ _00322_ _00323_ VGND VGND VPWR VPWR _00324_ sky130_fd_sc_hd__nor4_2
X_05915_ _02611_ _02622_ _02633_ VGND VGND VPWR VPWR _02644_ sky130_fd_sc_hd__and3_1
X_05846_ _01138_ _01334_ _01858_ _01869_ VGND VGND VPWR VPWR _01891_ sky130_fd_sc_hd__a2bb2o_1
X_08634_ _02020_ VGND VGND VPWR VPWR _02223_ sky130_fd_sc_hd__inv_2
X_05777_ _01116_ _01127_ VGND VGND VPWR VPWR _01138_ sky130_fd_sc_hd__or2_4
X_08565_ _01948_ _01950_ _01951_ VGND VGND VPWR VPWR _02147_ sky130_fd_sc_hd__a21bo_1
XFILLER_0_76_253 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_0_76_220 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
X_07516_ _00835_ _00845_ _00844_ VGND VGND VPWR VPWR _01002_ sky130_fd_sc_hd__a21bo_1
XFILLER_0_92_713 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_0_91_212 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_71_92 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
X_08496_ _02056_ _02069_ _02070_ VGND VGND VPWR VPWR _02071_ sky130_fd_sc_hd__and3b_1
XFILLER_0_9_553 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_0_119_355 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_76_297 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
X_07447_ _00924_ _00925_ VGND VGND VPWR VPWR _00926_ sky130_fd_sc_hd__xnor2_2
X_07378_ _00828_ _00849_ _00850_ VGND VGND VPWR VPWR _00851_ sky130_fd_sc_hd__and3_1
XFILLER_0_45_651 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_45_673 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XFILLER_0_91_289 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
X_09117_ _02612_ _02613_ VGND VGND VPWR VPWR _02749_ sky130_fd_sc_hd__nor2_1
X_06329_ _05412_ _05406_ VGND VGND VPWR VPWR _05460_ sky130_fd_sc_hd__and2b_1
XFILLER_0_115_572 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XTAP_TAPCELL_ROW_79_1253 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
X_09048_ _03026_ _04085_ _02351_ _01977_ VGND VGND VPWR VPWR _02674_ sky130_fd_sc_hd__nand4_2
XFILLER_0_60_665 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_60_643 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_4_291 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_0_20_518 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
X_11010_ _03491_ _02161_ _03690_ _03490_ VGND VGND VPWR VPWR _04812_ sky130_fd_sc_hd__a22o_1
XFILLER_0_99_334 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XFILLER_0_95_551 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_95_584 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_95_573 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
X_10725_ _02984_ _02850_ _00895_ _01041_ VGND VGND VPWR VPWR _04503_ sky130_fd_sc_hd__nand4_2
XFILLER_0_82_234 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_55_437 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_10656_ _04425_ _04426_ _04319_ _04321_ VGND VGND VPWR VPWR _04428_ sky130_fd_sc_hd__o211a_1
XFILLER_0_35_150 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_51_621 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
X_10587_ _04246_ _04352_ _04353_ VGND VGND VPWR VPWR _04354_ sky130_fd_sc_hd__a21o_1
XFILLER_0_50_120 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XFILLER_0_121_531 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_51_698 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_121_586 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XFILLER_0_50_197 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_121_597 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
X_11208_ _04374_ _01673_ VGND VGND VPWR VPWR _05027_ sky130_fd_sc_hd__nand2_1
XFILLER_0_76_48 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
X_11139_ _04880_ _04884_ _04881_ VGND VGND VPWR VPWR _04952_ sky130_fd_sc_hd__o21ba_1
XFILLER_0_116_21 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
X_06680_ _00105_ _00106_ _00083_ VGND VGND VPWR VPWR _00108_ sky130_fd_sc_hd__a21o_1
X_05700_ net26 VGND VGND VPWR VPWR _00297_ sky130_fd_sc_hd__buf_4
XFILLER_0_116_65 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XTAP_TAPCELL_ROW_47_852 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
X_08350_ _01909_ _01910_ _01911_ VGND VGND VPWR VPWR _01912_ sky130_fd_sc_hd__and3_1
XFILLER_0_74_713 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
X_07301_ _00619_ _00622_ VGND VGND VPWR VPWR _00767_ sky130_fd_sc_hd__or2_4
XFILLER_0_73_245 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XTAP_TAPCELL_ROW_63_1054 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
X_08281_ _01834_ _01835_ _01667_ VGND VGND VPWR VPWR _01838_ sky130_fd_sc_hd__o21ai_2
XFILLER_0_6_545 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
X_07232_ _00688_ _00689_ _00691_ VGND VGND VPWR VPWR _00692_ sky130_fd_sc_hd__a21bo_1
XFILLER_0_73_289 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
X_07163_ _00615_ VGND VGND VPWR VPWR _00616_ sky130_fd_sc_hd__inv_2
XFILLER_0_27_684 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XFILLER_0_14_334 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_06114_ _02513_ _04802_ _04781_ _01486_ VGND VGND VPWR VPWR _04813_ sky130_fd_sc_hd__a22o_1
X_07094_ _00522_ _00523_ _00539_ VGND VGND VPWR VPWR _00541_ sky130_fd_sc_hd__or3_1
XFILLER_0_112_586 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XFILLER_0_67_3 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
X_06045_ net2 VGND VGND VPWR VPWR _04063_ sky130_fd_sc_hd__clkbuf_4
XFILLER_0_10_551 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
X_09804_ _03497_ _03498_ _03487_ VGND VGND VPWR VPWR _03500_ sky130_fd_sc_hd__a21o_1
XTAP_TAPCELL_ROW_74_1183 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_5_51 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
X_07996_ _01522_ _01523_ _01504_ _01505_ VGND VGND VPWR VPWR _01525_ sky130_fd_sc_hd__o211a_1
X_09735_ _00496_ _03422_ _03423_ VGND VGND VPWR VPWR _03424_ sky130_fd_sc_hd__a21bo_1
X_06947_ _00280_ _00281_ _00317_ _00318_ VGND VGND VPWR VPWR _00380_ sky130_fd_sc_hd__nor4_1
X_09666_ _03346_ _03347_ _03342_ VGND VGND VPWR VPWR _03349_ sky130_fd_sc_hd__a21o_1
XFILLER_0_69_518 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
X_06878_ _00302_ _00303_ _00300_ VGND VGND VPWR VPWR _00305_ sky130_fd_sc_hd__a21o_1
X_08617_ _02201_ _02202_ _02157_ VGND VGND VPWR VPWR _02204_ sky130_fd_sc_hd__a21oi_2
XFILLER_0_82_91 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
X_09597_ _03115_ _03256_ _03271_ _03272_ VGND VGND VPWR VPWR _03273_ sky130_fd_sc_hd__o211a_2
XFILLER_0_77_540 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
X_05829_ _01585_ _01596_ _01683_ VGND VGND VPWR VPWR _01705_ sky130_fd_sc_hd__a21o_1
XFILLER_0_49_231 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
X_08548_ _02125_ _02126_ _02086_ VGND VGND VPWR VPWR _02128_ sky130_fd_sc_hd__a21oi_1
X_08479_ _02051_ VGND VGND VPWR VPWR _02052_ sky130_fd_sc_hd__clkbuf_8
XFILLER_0_107_303 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XTAP_TAPCELL_ROW_25_579 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
X_10510_ _03324_ _02351_ _03012_ _03323_ VGND VGND VPWR VPWR _04269_ sky130_fd_sc_hd__a22o_1
XFILLER_0_92_587 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_92_565 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_9_383 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_107_347 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
X_10441_ _04191_ _04192_ _00411_ net22 VGND VGND VPWR VPWR _04195_ sky130_fd_sc_hd__and4bb_1
XFILLER_0_17_172 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
X_10372_ _04008_ _04011_ _04117_ _04119_ VGND VGND VPWR VPWR _04120_ sky130_fd_sc_hd__o211a_2
XFILLER_0_103_520 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XFILLER_0_60_473 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_0_32_175 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XFILLER_0_32_197 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_99_120 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XFILLER_0_99_153 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XTAP_TAPCELL_ROW_44_811 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_68_595 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_55_223 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
X_10708_ _01610_ _01949_ _01674_ _01675_ VGND VGND VPWR VPWR _04484_ sky130_fd_sc_hd__and4_1
XFILLER_0_43_418 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_83_598 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
X_10639_ _04407_ _04409_ VGND VGND VPWR VPWR _04410_ sky130_fd_sc_hd__xor2_1
XFILLER_0_3_548 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_11_337 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XTAP_TAPCELL_ROW_110_1637 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XPHY_EDGE_ROW_18_Right_18 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
X_07850_ _01242_ _01262_ _01263_ VGND VGND VPWR VPWR _01366_ sky130_fd_sc_hd__nand3_2
X_06801_ _00128_ _00129_ _00227_ VGND VGND VPWR VPWR _00228_ sky130_fd_sc_hd__o21a_1
X_07781_ _01287_ _01288_ _01289_ VGND VGND VPWR VPWR _01292_ sky130_fd_sc_hd__a21o_1
X_09520_ _05656_ _02984_ VGND VGND VPWR VPWR _03189_ sky130_fd_sc_hd__nand2_1
Xinput3 mcand[11] VGND VGND VPWR VPWR net3 sky130_fd_sc_hd__buf_4
X_06732_ _00075_ _00081_ VGND VGND VPWR VPWR _00159_ sky130_fd_sc_hd__or2b_1
X_09451_ _03110_ _03111_ _03104_ VGND VGND VPWR VPWR _03114_ sky130_fd_sc_hd__a21o_1
X_06663_ _00088_ _00090_ VGND VGND VPWR VPWR _00091_ sky130_fd_sc_hd__nor2_1
X_09382_ _03028_ _03036_ _03038_ VGND VGND VPWR VPWR _03039_ sky130_fd_sc_hd__nand3_1
X_06594_ _00020_ _00021_ _05630_ _05632_ VGND VGND VPWR VPWR _00023_ sky130_fd_sc_hd__o211ai_2
XPHY_EDGE_ROW_27_Right_27 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
X_08402_ _01771_ _02219_ _01278_ _00991_ VGND VGND VPWR VPWR _01969_ sky130_fd_sc_hd__nand4_2
XTAP_TAPCELL_ROW_121_1777 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_52_61 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
X_08333_ _01848_ _01708_ _01892_ _01893_ VGND VGND VPWR VPWR _01894_ sky130_fd_sc_hd__a211oi_2
XFILLER_0_46_201 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XTAP_TAPCELL_ROW_121_1788 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_22_538 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
X_08264_ _01795_ _01817_ _01818_ VGND VGND VPWR VPWR _01819_ sky130_fd_sc_hd__and3_1
XFILLER_0_46_267 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_6_342 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_0_27_470 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_0_34_429 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
X_07215_ _00670_ _00671_ _00651_ _00652_ VGND VGND VPWR VPWR _00673_ sky130_fd_sc_hd__o211a_1
X_08195_ _01734_ _01741_ _01742_ VGND VGND VPWR VPWR _01743_ sky130_fd_sc_hd__and3_1
XTAP_TAPCELL_ROW_76_1212 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
X_07146_ _00331_ _00462_ _00597_ VGND VGND VPWR VPWR _00598_ sky130_fd_sc_hd__a21oi_1
XFILLER_0_30_613 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_42_473 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_0_14_197 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
X_07077_ _00418_ _00412_ VGND VGND VPWR VPWR _00522_ sky130_fd_sc_hd__and2b_1
XFILLER_0_30_657 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_42_495 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_0_2_581 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XPHY_EDGE_ROW_36_Right_36 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
X_06028_ _03823_ _03845_ _03867_ VGND VGND VPWR VPWR _03878_ sky130_fd_sc_hd__nand3_1
X_09718_ _03401_ _03402_ _03403_ VGND VGND VPWR VPWR _03405_ sky130_fd_sc_hd__and3_1
X_07979_ _01339_ _01344_ VGND VGND VPWR VPWR _01506_ sky130_fd_sc_hd__or2_1
X_10990_ _04709_ _04710_ VGND VGND VPWR VPWR _04791_ sky130_fd_sc_hd__and2_1
XTAP_TAPCELL_ROW_87_1352 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_69_315 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_97_657 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
X_09649_ _02134_ _00623_ _03138_ _03139_ VGND VGND VPWR VPWR _03330_ sky130_fd_sc_hd__and4_1
XFILLER_0_69_337 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XTAP_TAPCELL_ROW_2_285 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XPHY_EDGE_ROW_45_Right_45 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XPHY_EDGE_ROW_106_Left_228 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_0_108_601 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_77_370 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XFILLER_0_108_634 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_53_716 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_0_108_645 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_0_107_155 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XTAP_TAPCELL_ROW_98_1492 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_98_1481 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
X_10424_ _00348_ _00350_ _02695_ _02161_ VGND VGND VPWR VPWR _04176_ sky130_fd_sc_hd__nand4_2
XFILLER_0_33_462 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XPHY_EDGE_ROW_115_Left_237 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_0_110_309 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XPHY_EDGE_ROW_54_Right_54 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_0_21_646 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
X_10355_ _01221_ _02051_ VGND VGND VPWR VPWR _04101_ sky130_fd_sc_hd__nand2_1
X_10286_ _03897_ _03899_ _04024_ _04025_ VGND VGND VPWR VPWR _04026_ sky130_fd_sc_hd__a211oi_4
XFILLER_0_73_49 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XPHY_EDGE_ROW_63_Right_63 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_0_88_657 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XTAP_TAPCELL_ROW_57_980 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_113_55 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XTAP_TAPCELL_ROW_60_1013 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_56_554 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_56_587 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_22_53 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_0_71_557 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_0_22_97 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_114_637 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_0_113_125 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XPHY_EDGE_ROW_72_Right_72 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_0_12_613 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_3_323 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_3_312 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_07000_ _00427_ _00436_ _00437_ VGND VGND VPWR VPWR _00438_ sky130_fd_sc_hd__nand3_2
XFILLER_0_113_169 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XFILLER_0_11_156 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
X_08951_ _02389_ _02390_ _02391_ _02400_ VGND VGND VPWR VPWR _02569_ sky130_fd_sc_hd__a22o_1
XFILLER_0_11_167 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XTAP_TAPCELL_ROW_71_1153 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
X_08882_ _05557_ _02492_ VGND VGND VPWR VPWR _02493_ sky130_fd_sc_hd__nand2_1
X_07902_ _01421_ _01423_ VGND VGND VPWR VPWR _01424_ sky130_fd_sc_hd__xor2_2
X_07833_ _01337_ _01347_ VGND VGND VPWR VPWR _01348_ sky130_fd_sc_hd__xnor2_2
XPHY_EDGE_ROW_81_Right_81 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_0_2_41 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
X_07764_ _01271_ _01272_ VGND VGND VPWR VPWR _01273_ sky130_fd_sc_hd__nor2_1
X_09503_ _02529_ VGND VGND VPWR VPWR _03171_ sky130_fd_sc_hd__buf_4
X_06715_ _00362_ _00033_ _00140_ _00141_ VGND VGND VPWR VPWR _00142_ sky130_fd_sc_hd__and4_1
X_07695_ _00898_ _01052_ VGND VGND VPWR VPWR _01197_ sky130_fd_sc_hd__or2_1
XFILLER_0_2_85 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
X_09434_ _03093_ _03094_ VGND VGND VPWR VPWR _03095_ sky130_fd_sc_hd__xor2_4
X_06646_ _05678_ _05680_ VGND VGND VPWR VPWR _00074_ sky130_fd_sc_hd__nand2_1
XTAP_TAPCELL_ROW_82_1282 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
X_09365_ _03011_ _03018_ _03019_ VGND VGND VPWR VPWR _03020_ sky130_fd_sc_hd__nand3_2
X_06577_ _00003_ _00004_ _00005_ VGND VGND VPWR VPWR _00006_ sky130_fd_sc_hd__and3_2
XTAP_TAPCELL_ROW_35_696 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_47_565 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XTAP_TAPCELL_ROW_82_1293 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
X_09296_ _00408_ _00084_ _02943_ _02944_ VGND VGND VPWR VPWR _02945_ sky130_fd_sc_hd__nand4_4
XFILLER_0_74_362 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
X_08316_ _03255_ _01187_ _01873_ _01874_ VGND VGND VPWR VPWR _01875_ sky130_fd_sc_hd__a22o_1
XANTENNA_30 net55 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XANTENNA_41 net118 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_0_35_716 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_0_47_576 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XANTENNA_52 _05293_ VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_0_117_464 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XPHY_EDGE_ROW_90_Right_90 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_0_7_673 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
X_08247_ _00991_ VGND VGND VPWR VPWR _01800_ sky130_fd_sc_hd__buf_4
XFILLER_0_50_719 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_15_473 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
X_08178_ _04998_ _05030_ _00150_ _00349_ VGND VGND VPWR VPWR _01724_ sky130_fd_sc_hd__nand4_2
XFILLER_0_30_421 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_07129_ _00555_ _00577_ _00578_ VGND VGND VPWR VPWR _00579_ sky130_fd_sc_hd__and3_1
X_10140_ _03745_ _03748_ VGND VGND VPWR VPWR _03866_ sky130_fd_sc_hd__or2_2
X_10071_ _03651_ _03653_ _03789_ _03790_ VGND VGND VPWR VPWR _03792_ sky130_fd_sc_hd__a211oi_2
XTAP_TAPCELL_ROW_7_355 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_7_344 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
X_10973_ _04769_ _04771_ _04689_ _04755_ VGND VGND VPWR VPWR _04773_ sky130_fd_sc_hd__a211oi_1
XFILLER_0_97_421 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_69_134 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_69_123 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_0_57_329 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XFILLER_0_108_442 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_0_93_671 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_111_9 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_108_475 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_53_535 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_4_109 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_80_365 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_0_53_568 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_0_111_607 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_11456_ _00635_ _01192_ _01356_ _00657_ VGND VGND VPWR VPWR _05289_ sky130_fd_sc_hd__a22oi_1
XFILLER_0_33_281 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_0_40_229 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
X_11387_ _05183_ _05218_ _05217_ VGND VGND VPWR VPWR _05220_ sky130_fd_sc_hd__a21o_1
XFILLER_0_111_629 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
X_10407_ _03690_ VGND VGND VPWR VPWR _04157_ sky130_fd_sc_hd__buf_4
XFILLER_0_68_49 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_0_0_337 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
X_10338_ _04043_ _04044_ _04080_ _04081_ VGND VGND VPWR VPWR _04082_ sky130_fd_sc_hd__nor4_2
XFILLER_0_103_191 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_0_0_348 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
X_10269_ _04004_ _04005_ _03999_ VGND VGND VPWR VPWR _04007_ sky130_fd_sc_hd__a21o_1
XFILLER_0_84_48 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XFILLER_0_108_77 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_0_16_9 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_88_487 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_88_465 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XTAP_TAPCELL_ROW_52_909 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
X_06500_ _05456_ _05618_ VGND VGND VPWR VPWR _05629_ sky130_fd_sc_hd__xor2_1
X_07480_ _00959_ _00960_ _00804_ _00806_ VGND VGND VPWR VPWR _00962_ sky130_fd_sc_hd__o211ai_1
XFILLER_0_48_307 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XTAP_TAPCELL_ROW_105_1569 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_75_104 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_06431_ _05327_ _05304_ _05305_ _03780_ VGND VGND VPWR VPWR _05561_ sky130_fd_sc_hd__a22o_1
X_09150_ _02782_ _02783_ _02603_ _02605_ VGND VGND VPWR VPWR _02785_ sky130_fd_sc_hd__o211ai_1
XFILLER_0_56_362 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
X_06362_ _05484_ _05492_ VGND VGND VPWR VPWR _05493_ sky130_fd_sc_hd__xnor2_2
XTAP_TAPCELL_ROW_32_666 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_44_502 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_83_181 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_09081_ _02364_ _02536_ _02708_ VGND VGND VPWR VPWR _02711_ sky130_fd_sc_hd__or3_1
XFILLER_0_16_226 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
X_08101_ _01619_ _01638_ _01639_ VGND VGND VPWR VPWR _01641_ sky130_fd_sc_hd__and3_1
X_06293_ net37 VGND VGND VPWR VPWR _05425_ sky130_fd_sc_hd__clkbuf_4
XFILLER_0_114_445 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_0_4_643 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
X_08032_ _01556_ _01564_ VGND VGND VPWR VPWR _01565_ sky130_fd_sc_hd__xnor2_2
XFILLER_0_32_719 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
Xinput61 mplier[6] VGND VGND VPWR VPWR net61 sky130_fd_sc_hd__clkbuf_2
Xinput50 mplier[25] VGND VGND VPWR VPWR net50 sky130_fd_sc_hd__dlymetal6s2s_1
XFILLER_0_114_489 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
X_09983_ _03693_ _03694_ VGND VGND VPWR VPWR _03695_ sky130_fd_sc_hd__xor2_1
XFILLER_0_12_498 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
X_08934_ _02547_ _02549_ VGND VGND VPWR VPWR _02550_ sky130_fd_sc_hd__xor2_4
XTAP_TAPCELL_ROW_4_314 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
X_08865_ _01582_ _00034_ _02471_ _02472_ VGND VGND VPWR VPWR _02474_ sky130_fd_sc_hd__nand4_2
XFILLER_0_98_207 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
X_07816_ _01180_ _01200_ VGND VGND VPWR VPWR _01329_ sky130_fd_sc_hd__and2b_1
X_08796_ _00882_ _02393_ _02395_ _02399_ VGND VGND VPWR VPWR _02400_ sky130_fd_sc_hd__a211o_4
X_07747_ _03004_ net2 net40 net41 VGND VGND VPWR VPWR _01254_ sky130_fd_sc_hd__and4_1
XTAP_TAPCELL_ROW_84_1311 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_67_638 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_0_66_115 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_07678_ _00945_ _01035_ _01055_ VGND VGND VPWR VPWR _01178_ sky130_fd_sc_hd__a21oi_1
XPHY_EDGE_ROW_0_Right_0 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_0_39_318 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
X_09417_ _03068_ _03076_ VGND VGND VPWR VPWR net94 sky130_fd_sc_hd__xor2_1
X_06629_ _03791_ _05464_ _05388_ _03255_ VGND VGND VPWR VPWR _00057_ sky130_fd_sc_hd__a22o_1
X_09348_ _02998_ _02999_ _02858_ _02860_ VGND VGND VPWR VPWR _03001_ sky130_fd_sc_hd__o211ai_4
XFILLER_0_105_412 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
X_11310_ _05135_ _05136_ VGND VGND VPWR VPWR _05137_ sky130_fd_sc_hd__nor2_1
X_09279_ _02924_ _02925_ VGND VGND VPWR VPWR _02926_ sky130_fd_sc_hd__xnor2_1
XFILLER_0_15_281 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XTAP_TAPCELL_ROW_95_1451 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
X_11241_ _03294_ _04724_ _05038_ _05037_ VGND VGND VPWR VPWR _05063_ sky130_fd_sc_hd__a31o_1
X_11172_ _04986_ _04988_ VGND VGND VPWR VPWR _04989_ sky130_fd_sc_hd__and2_1
XFILLER_0_101_673 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
X_10123_ _03843_ _03844_ _03846_ VGND VGND VPWR VPWR _03848_ sky130_fd_sc_hd__a21o_1
X_10054_ _03770_ _03771_ _03761_ VGND VGND VPWR VPWR _03773_ sky130_fd_sc_hd__a21oi_2
XFILLER_0_89_229 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_89_207 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_0_54_29 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XPHY_EDGE_ROW_121_Right_121 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_0_97_262 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
X_10956_ _04752_ _04753_ VGND VGND VPWR VPWR _04754_ sky130_fd_sc_hd__xor2_1
X_10887_ _02281_ _03440_ _04558_ _04557_ _04157_ VGND VGND VPWR VPWR _04679_ sky130_fd_sc_hd__a32o_1
XFILLER_0_81_685 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_14_719 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_41_505 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_0_41_527 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
X_11439_ _05259_ _05262_ _04873_ _04724_ VGND VGND VPWR VPWR _05274_ sky130_fd_sc_hd__o211ai_4
XFILLER_0_1_657 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_28_41 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
X_06980_ net31 _05343_ _00413_ _00414_ VGND VGND VPWR VPWR _00416_ sky130_fd_sc_hd__o2bb2a_1
X_05931_ _02644_ _02655_ _02808_ VGND VGND VPWR VPWR _02819_ sky130_fd_sc_hd__or3_4
X_08650_ _03780_ _02036_ _01499_ _01552_ VGND VGND VPWR VPWR _02239_ sky130_fd_sc_hd__a22o_1
XFILLER_0_28_85 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
X_05862_ net27 VGND VGND VPWR VPWR _02065_ sky130_fd_sc_hd__buf_4
X_07601_ _01091_ _01092_ _00940_ _00943_ VGND VGND VPWR VPWR _01095_ sky130_fd_sc_hd__o211a_1
XTAP_TAPCELL_ROW_37_725 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
X_05793_ _01225_ _01291_ VGND VGND VPWR VPWR _01313_ sky130_fd_sc_hd__and2_1
XFILLER_0_44_40 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_08581_ _04781_ _01798_ _01976_ _04770_ VGND VGND VPWR VPWR _02165_ sky130_fd_sc_hd__a22o_1
XFILLER_0_49_638 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
X_07532_ _01016_ _01017_ _00907_ VGND VGND VPWR VPWR _01020_ sky130_fd_sc_hd__a21oi_2
XFILLER_0_119_515 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XTAP_TAPCELL_ROW_66_1085 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
X_07463_ _00940_ _00942_ _00927_ VGND VGND VPWR VPWR _00944_ sky130_fd_sc_hd__a21o_1
XTAP_TAPCELL_ROW_17_471 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_48_137 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
X_09202_ _01278_ VGND VGND VPWR VPWR _02843_ sky130_fd_sc_hd__buf_4
XFILLER_0_57_671 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
X_06414_ _01356_ _05541_ _05542_ VGND VGND VPWR VPWR _05544_ sky130_fd_sc_hd__a21oi_1
XFILLER_0_106_209 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
X_09133_ _02765_ _02766_ VGND VGND VPWR VPWR _02767_ sky130_fd_sc_hd__nor2_1
XFILLER_0_60_83 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
X_07394_ _00867_ _00868_ VGND VGND VPWR VPWR _00869_ sky130_fd_sc_hd__and2_1
XFILLER_0_97_3 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
X_06345_ _05473_ _05474_ _05475_ VGND VGND VPWR VPWR _05476_ sky130_fd_sc_hd__or3b_2
XTAP_TAPCELL_ROW_118_1738 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_71_162 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
X_09064_ net53 VGND VGND VPWR VPWR _02692_ sky130_fd_sc_hd__buf_4
XFILLER_0_32_549 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
X_06276_ _04878_ _04802_ _03288_ _03124_ VGND VGND VPWR VPWR _05408_ sky130_fd_sc_hd__nand4_1
XFILLER_0_114_286 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_102_415 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
X_08015_ _01379_ _01544_ _01545_ VGND VGND VPWR VPWR _01546_ sky130_fd_sc_hd__a21bo_1
X_09966_ _00076_ _03675_ _03619_ VGND VGND VPWR VPWR _03676_ sky130_fd_sc_hd__nand3_2
X_09897_ _03559_ _03599_ _03600_ VGND VGND VPWR VPWR _03601_ sky130_fd_sc_hd__nor3_2
XTAP_TAPCELL_ROW_90_1392 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_90_1381 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
X_08917_ _02527_ _02528_ _02530_ VGND VGND VPWR VPWR _02531_ sky130_fd_sc_hd__nand3_1
X_08848_ _02453_ _02454_ VGND VGND VPWR VPWR _02455_ sky130_fd_sc_hd__xor2_2
XFILLER_0_79_251 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
X_08779_ _02276_ _02380_ VGND VGND VPWR VPWR _02381_ sky130_fd_sc_hd__xnor2_4
X_10810_ _04593_ _04594_ VGND VGND VPWR VPWR _04595_ sky130_fd_sc_hd__xor2_1
X_10741_ _04395_ _04518_ _04519_ VGND VGND VPWR VPWR _04521_ sky130_fd_sc_hd__nand3_4
XFILLER_0_94_287 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_48_682 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
X_10672_ _04442_ _04443_ _04359_ _04360_ VGND VGND VPWR VPWR _04446_ sky130_fd_sc_hd__a211o_1
XFILLER_0_94_298 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_90_460 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_0_23_505 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_63_685 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_50_313 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
X_11224_ _05042_ _05043_ _05004_ _04980_ VGND VGND VPWR VPWR _05045_ sky130_fd_sc_hd__o211a_1
X_11155_ _04968_ _04969_ VGND VGND VPWR VPWR _04970_ sky130_fd_sc_hd__or2_1
X_11086_ _04893_ _04894_ VGND VGND VPWR VPWR _04895_ sky130_fd_sc_hd__and2_1
X_10106_ _03821_ _03822_ _03826_ _03828_ VGND VGND VPWR VPWR _03829_ sky130_fd_sc_hd__o211a_1
X_10037_ _03611_ _03612_ VGND VGND VPWR VPWR _03754_ sky130_fd_sc_hd__and2b_1
XFILLER_0_81_27 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
X_10939_ _00356_ _03027_ VGND VGND VPWR VPWR _04735_ sky130_fd_sc_hd__nand2_1
XFILLER_0_85_221 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XTAP_TAPCELL_ROW_102_1539 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_14_65 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_116_529 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_0_73_449 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XTAP_TAPCELL_ROW_14_441 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_42_783 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_121_44 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_54_674 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_0_26_365 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_38_192 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_0_121_77 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_0_5_259 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
X_06130_ _00439_ _04976_ VGND VGND VPWR VPWR _04987_ sky130_fd_sc_hd__and2_1
XFILLER_0_112_713 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
X_06061_ _04205_ _04216_ _02841_ _04227_ VGND VGND VPWR VPWR _04238_ sky130_fd_sc_hd__a211o_1
XFILLER_0_111_256 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XTAP_TAPCELL_ROW_113_1679 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
X_09820_ _03514_ _03515_ _03364_ _03389_ VGND VGND VPWR VPWR _03517_ sky130_fd_sc_hd__o211a_1
X_09751_ _05656_ _02850_ _03292_ _03291_ _03440_ VGND VGND VPWR VPWR _03442_ sky130_fd_sc_hd__a32o_1
X_06963_ _00393_ _00397_ VGND VGND VPWR VPWR _00398_ sky130_fd_sc_hd__xor2_1
X_08702_ _02111_ _02114_ VGND VGND VPWR VPWR _02297_ sky130_fd_sc_hd__nand2_1
X_05914_ _02043_ _02120_ _02032_ VGND VGND VPWR VPWR _02633_ sky130_fd_sc_hd__a21bo_1
X_09682_ _03280_ _03281_ _03364_ _03366_ VGND VGND VPWR VPWR _03367_ sky130_fd_sc_hd__and4bb_1
XTAP_TAPCELL_ROW_68_1114 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
X_06894_ _00320_ _00321_ _00211_ net172 VGND VGND VPWR VPWR _00323_ sky130_fd_sc_hd__a211oi_2
X_05845_ _01138_ _01334_ _01858_ _01869_ VGND VGND VPWR VPWR _01880_ sky130_fd_sc_hd__or4bb_2
X_08633_ _02218_ _02220_ _01865_ VGND VGND VPWR VPWR _02222_ sky130_fd_sc_hd__o21ai_2
X_05776_ _01094_ _01105_ _00417_ VGND VGND VPWR VPWR _01127_ sky130_fd_sc_hd__a21oi_1
X_08564_ _05311_ _02141_ _02143_ _02144_ VGND VGND VPWR VPWR _02146_ sky130_fd_sc_hd__a22o_1
X_07515_ _00998_ _00999_ _00989_ VGND VGND VPWR VPWR _01001_ sky130_fd_sc_hd__a21o_1
XFILLER_0_119_345 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
X_08495_ _02067_ _02068_ _02057_ VGND VGND VPWR VPWR _02070_ sky130_fd_sc_hd__a21o_1
XFILLER_0_64_416 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_0_119_367 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_17_310 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
X_07446_ _00759_ _00761_ VGND VGND VPWR VPWR _00925_ sky130_fd_sc_hd__or2_2
X_07377_ _00846_ _00847_ _00848_ VGND VGND VPWR VPWR _00850_ sky130_fd_sc_hd__a21o_1
X_09116_ _02746_ _02747_ VGND VGND VPWR VPWR _02748_ sky130_fd_sc_hd__or2_2
XFILLER_0_72_471 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_0_60_611 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
X_06328_ _05390_ _05391_ _05399_ _05398_ _05397_ VGND VGND VPWR VPWR _05459_ sky130_fd_sc_hd__o32a_1
XTAP_TAPCELL_ROW_79_1254 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
X_09047_ _04552_ _01800_ _02516_ _04531_ VGND VGND VPWR VPWR _02673_ sky130_fd_sc_hd__a22o_1
XTAP_TAPCELL_ROW_92_1410 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
X_06259_ _01247_ _01760_ _05320_ _05388_ VGND VGND VPWR VPWR _05391_ sky130_fd_sc_hd__and4_2
X_09949_ _03655_ _03656_ _03532_ VGND VGND VPWR VPWR _03658_ sky130_fd_sc_hd__a21o_1
XFILLER_0_67_243 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_10724_ _02850_ _00895_ _01041_ _02984_ VGND VGND VPWR VPWR _04502_ sky130_fd_sc_hd__a22o_1
XFILLER_0_82_213 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
X_10655_ _04319_ _04321_ _04425_ _04426_ VGND VGND VPWR VPWR _04427_ sky130_fd_sc_hd__a211oi_4
XFILLER_0_70_419 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XTAP_TAPCELL_ROW_11_400 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_106_551 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
X_10586_ _04243_ _04244_ VGND VGND VPWR VPWR _04353_ sky130_fd_sc_hd__and2b_1
XFILLER_0_90_290 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_0_50_176 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_0_121_576 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
X_11207_ _04732_ _05024_ _05025_ VGND VGND VPWR VPWR _05026_ sky130_fd_sc_hd__a21bo_1
X_11138_ _04949_ _04950_ VGND VGND VPWR VPWR _04951_ sky130_fd_sc_hd__or2_1
X_11069_ _04875_ VGND VGND VPWR VPWR _04876_ sky130_fd_sc_hd__inv_2
XFILLER_0_92_15 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XTAP_TAPCELL_ROW_19_500 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_25_31 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XTAP_TAPCELL_ROW_47_853 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_116_77 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_0_58_243 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XTAP_TAPCELL_ROW_63_1044 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_18_107 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
X_07300_ _00761_ _00764_ VGND VGND VPWR VPWR _00765_ sky130_fd_sc_hd__or2_2
XTAP_TAPCELL_ROW_63_1055 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_58_298 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_08280_ _01667_ _01834_ _01835_ VGND VGND VPWR VPWR _01836_ sky130_fd_sc_hd__or3_2
XFILLER_0_39_490 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_0_73_257 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
X_07231_ net27 net42 net43 _00297_ VGND VGND VPWR VPWR _00691_ sky130_fd_sc_hd__a22o_1
XFILLER_0_73_279 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
X_07162_ _00373_ _00610_ _00614_ _00395_ VGND VGND VPWR VPWR _00615_ sky130_fd_sc_hd__a22o_2
XFILLER_0_42_611 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_112_510 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
X_06113_ _02699_ VGND VGND VPWR VPWR _04802_ sky130_fd_sc_hd__buf_4
X_07093_ _00522_ _00523_ _00539_ VGND VGND VPWR VPWR _00540_ sky130_fd_sc_hd__o21ai_1
XFILLER_0_41_198 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
X_06044_ _04031_ _04041_ VGND VGND VPWR VPWR _04052_ sky130_fd_sc_hd__nand2_1
XFILLER_0_10_563 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
X_09803_ _03487_ _03497_ _03498_ VGND VGND VPWR VPWR _03499_ sky130_fd_sc_hd__nand3_2
XTAP_TAPCELL_ROW_74_1184 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
X_07995_ _01504_ _01505_ _01522_ _01523_ VGND VGND VPWR VPWR _01524_ sky130_fd_sc_hd__a211oi_2
X_09734_ _01943_ _00747_ _00914_ _01762_ VGND VGND VPWR VPWR _03423_ sky130_fd_sc_hd__a22o_1
X_06946_ _00376_ _00377_ _00341_ VGND VGND VPWR VPWR _00379_ sky130_fd_sc_hd__o21a_1
X_09665_ _03342_ _03346_ _03347_ VGND VGND VPWR VPWR _03348_ sky130_fd_sc_hd__nand3_1
XPHY_EDGE_ROW_19_Left_141 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
X_06877_ _00300_ _00302_ _00303_ VGND VGND VPWR VPWR _00304_ sky130_fd_sc_hd__nand3_1
XFILLER_0_96_338 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
X_05828_ _01585_ _01596_ _01683_ VGND VGND VPWR VPWR _01694_ sky130_fd_sc_hd__nand3_1
X_08616_ _02157_ _02201_ _02202_ VGND VGND VPWR VPWR _02203_ sky130_fd_sc_hd__and3_1
X_09596_ _03269_ _03270_ _03110_ _03112_ VGND VGND VPWR VPWR _03272_ sky130_fd_sc_hd__o211ai_2
X_05759_ _00886_ _00897_ _00919_ VGND VGND VPWR VPWR _00941_ sky130_fd_sc_hd__a21o_1
X_08547_ _02086_ _02125_ _02126_ VGND VGND VPWR VPWR _02127_ sky130_fd_sc_hd__and3_1
XFILLER_0_92_533 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_92_511 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
X_08478_ net25 VGND VGND VPWR VPWR _02051_ sky130_fd_sc_hd__buf_4
XTAP_TAPCELL_ROW_25_569 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_107_337 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_0_107_326 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_9_362 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
X_07429_ _00786_ _00789_ _00904_ VGND VGND VPWR VPWR _00906_ sky130_fd_sc_hd__and3_1
X_10440_ _01582_ _01680_ _04191_ _04192_ VGND VGND VPWR VPWR _04193_ sky130_fd_sc_hd__o2bb2a_1
XFILLER_0_64_279 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_0_45_460 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_17_184 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XPHY_EDGE_ROW_28_Left_150 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_0_32_110 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
X_10371_ _04115_ _04116_ _04004_ _04006_ VGND VGND VPWR VPWR _04119_ sky130_fd_sc_hd__o211ai_2
XFILLER_0_20_327 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_62_29 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XTAP_TAPCELL_ROW_44_812 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_68_574 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_56_714 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XFILLER_0_95_371 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_0_83_511 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_0_55_202 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
X_10707_ _02837_ _01353_ _03238_ _02141_ VGND VGND VPWR VPWR _04483_ sky130_fd_sc_hd__a22oi_1
XFILLER_0_71_717 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
X_10638_ _02976_ _03478_ _04302_ _04408_ VGND VGND VPWR VPWR _04409_ sky130_fd_sc_hd__a31o_1
XFILLER_0_70_249 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_0_51_430 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XFILLER_0_11_55 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_3_505 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XFILLER_0_36_493 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_10569_ _04294_ _04332_ _04333_ VGND VGND VPWR VPWR _04334_ sky130_fd_sc_hd__nand3_4
XFILLER_0_23_143 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XFILLER_0_11_327 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_24_699 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XTAP_TAPCELL_ROW_110_1638 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
X_06800_ _00225_ _00226_ VGND VGND VPWR VPWR _00227_ sky130_fd_sc_hd__xnor2_1
X_07780_ _01287_ _01288_ _01289_ VGND VGND VPWR VPWR _01290_ sky130_fd_sc_hd__nand3_1
Xinput4 mcand[12] VGND VGND VPWR VPWR net4 sky130_fd_sc_hd__clkbuf_2
X_06731_ _00065_ _00067_ VGND VGND VPWR VPWR _00158_ sky130_fd_sc_hd__nand2_1
XFILLER_0_36_41 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_0_78_327 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_78_316 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
X_09450_ _03104_ _03110_ _03111_ VGND VGND VPWR VPWR _03112_ sky130_fd_sc_hd__nand3_2
XFILLER_0_36_85 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
X_06662_ _00319_ _00340_ _05686_ _00089_ VGND VGND VPWR VPWR _00090_ sky130_fd_sc_hd__and4_1
X_08401_ _02219_ _00837_ _00991_ _02197_ VGND VGND VPWR VPWR _01968_ sky130_fd_sc_hd__a22o_1
X_09381_ _03033_ _03035_ _02869_ VGND VGND VPWR VPWR _03038_ sky130_fd_sc_hd__a21o_1
X_06593_ _05630_ _05632_ _00020_ _00021_ VGND VGND VPWR VPWR _00022_ sky130_fd_sc_hd__a211o_1
XFILLER_0_117_602 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_74_533 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_74_522 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_52_73 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_08332_ net145 _01890_ _01751_ _01753_ VGND VGND VPWR VPWR _01893_ sky130_fd_sc_hd__o211a_1
XFILLER_0_19_449 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XTAP_TAPCELL_ROW_121_1789 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_121_1778 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_117_624 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XTAP_TAPCELL_ROW_22_539 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
X_08263_ _01813_ _01814_ _01816_ VGND VGND VPWR VPWR _01818_ sky130_fd_sc_hd__a21o_1
XFILLER_0_46_235 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_07214_ _00651_ _00652_ _00670_ net164 VGND VGND VPWR VPWR _00672_ sky130_fd_sc_hd__a211oi_4
XFILLER_0_27_482 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
X_08194_ _01739_ _01740_ _01735_ VGND VGND VPWR VPWR _01742_ sky130_fd_sc_hd__a21o_1
XTAP_TAPCELL_ROW_76_1213 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
X_07145_ _00457_ _00458_ _00459_ VGND VGND VPWR VPWR _00597_ sky130_fd_sc_hd__and3_1
XFILLER_0_112_351 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_14_176 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
X_07076_ _00391_ _00400_ VGND VGND VPWR VPWR _00521_ sky130_fd_sc_hd__and2_1
XFILLER_0_30_669 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
X_06027_ _00526_ _03856_ _03343_ _03365_ VGND VGND VPWR VPWR _03867_ sky130_fd_sc_hd__a22o_1
XFILLER_0_100_568 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
X_07978_ _01335_ _01348_ VGND VGND VPWR VPWR _01505_ sky130_fd_sc_hd__or2b_1
X_09717_ _03401_ _03402_ _03403_ VGND VGND VPWR VPWR _03404_ sky130_fd_sc_hd__a21oi_1
X_06929_ _00243_ _00250_ VGND VGND VPWR VPWR _00360_ sky130_fd_sc_hd__nand2_1
XFILLER_0_97_636 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_93_80 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XTAP_TAPCELL_ROW_87_1353 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_97_669 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
X_09648_ _01943_ _00348_ _02492_ _00350_ VGND VGND VPWR VPWR _03329_ sky130_fd_sc_hd__and4_1
XTAP_TAPCELL_ROW_2_286 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
X_09579_ _04748_ _02051_ VGND VGND VPWR VPWR _03253_ sky130_fd_sc_hd__nand2_2
XFILLER_0_77_393 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_77_382 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_37_202 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_0_37_213 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XFILLER_0_108_613 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_92_363 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_80_514 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_52_227 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XTAP_TAPCELL_ROW_98_1482 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
X_10423_ _02459_ _02345_ _01980_ _00151_ VGND VGND VPWR VPWR _04175_ sky130_fd_sc_hd__a22o_1
XFILLER_0_21_603 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_0_33_474 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
X_10354_ _04097_ _04099_ VGND VGND VPWR VPWR _04100_ sky130_fd_sc_hd__xor2_2
XTAP_TAPCELL_ROW_98_1493 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_60_282 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_21_658 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
X_10285_ _04022_ _04023_ _03926_ _03927_ VGND VGND VPWR VPWR _04025_ sky130_fd_sc_hd__a211oi_2
XFILLER_0_87_102 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_0_88_669 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XTAP_TAPCELL_ROW_57_970 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_75_319 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_0_56_533 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_8_608 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XTAP_TAPCELL_ROW_60_1014 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_56_566 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_71_503 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_118_3 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_98_36 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XFILLER_0_3_335 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_11_113 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_24_474 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XFILLER_0_11_135 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
X_08950_ _02565_ _02566_ VGND VGND VPWR VPWR _02567_ sky130_fd_sc_hd__nor2_2
XTAP_TAPCELL_ROW_71_1154 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
X_08881_ _00688_ VGND VGND VPWR VPWR _02492_ sky130_fd_sc_hd__buf_4
X_07901_ _01254_ _01255_ VGND VGND VPWR VPWR _01423_ sky130_fd_sc_hd__or2_2
X_07832_ _01338_ _01346_ VGND VGND VPWR VPWR _01347_ sky130_fd_sc_hd__xnor2_2
XFILLER_0_47_51 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_0_79_625 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
X_09502_ _03032_ _03031_ _03029_ VGND VGND VPWR VPWR _03170_ sky130_fd_sc_hd__and3b_1
X_07763_ _03080_ _00195_ _01268_ _01270_ VGND VGND VPWR VPWR _01272_ sky130_fd_sc_hd__o2bb2a_1
XFILLER_0_79_658 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_78_113 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
X_06714_ _00493_ _05539_ _00139_ _00679_ VGND VGND VPWR VPWR _00141_ sky130_fd_sc_hd__a22o_1
XFILLER_0_2_53 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
X_07694_ _01046_ _01195_ VGND VGND VPWR VPWR _01196_ sky130_fd_sc_hd__xor2_1
X_09433_ _04748_ _02045_ VGND VGND VPWR VPWR _03094_ sky130_fd_sc_hd__nand2_2
XFILLER_0_63_83 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_0_63_61 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_0_2_97 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
X_06645_ _05684_ _00006_ _00007_ VGND VGND VPWR VPWR _00073_ sky130_fd_sc_hd__nor3_1
X_09364_ _03016_ _03017_ _02848_ _02849_ VGND VGND VPWR VPWR _03019_ sky130_fd_sc_hd__o211ai_2
XTAP_TAPCELL_ROW_82_1283 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
X_08315_ _04705_ _05486_ _00893_ _01185_ VGND VGND VPWR VPWR _01874_ sky130_fd_sc_hd__nand4_2
XFILLER_0_59_393 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
X_06576_ _05591_ _05600_ _05599_ VGND VGND VPWR VPWR _00005_ sky130_fd_sc_hd__a21bo_1
XTAP_TAPCELL_ROW_35_697 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_117_432 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_09295_ _01185_ VGND VGND VPWR VPWR _02944_ sky130_fd_sc_hd__clkbuf_8
XANTENNA_31 net58 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_0_7_641 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XANTENNA_20 _05008_ VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_0_117_476 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XANTENNA_53 _05467_ VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_0_7_685 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XANTENNA_42 net118 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
X_08246_ _01796_ _01797_ _01651_ _01798_ VGND VGND VPWR VPWR _01799_ sky130_fd_sc_hd__and4bb_1
XFILLER_0_105_649 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
X_08177_ _05341_ _00485_ _00235_ _03834_ VGND VGND VPWR VPWR _01723_ sky130_fd_sc_hd__a22o_1
XFILLER_0_15_496 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_07128_ _00574_ _00575_ _00576_ VGND VGND VPWR VPWR _00578_ sky130_fd_sc_hd__a21o_1
XFILLER_0_113_671 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_30_477 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
X_07059_ _03223_ _00035_ _00139_ _00810_ VGND VGND VPWR VPWR _00502_ sky130_fd_sc_hd__a22oi_1
XFILLER_0_100_365 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
X_10070_ _03787_ _03788_ _03644_ _03677_ VGND VGND VPWR VPWR _03790_ sky130_fd_sc_hd__o211a_1
XTAP_TAPCELL_ROW_7_345 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XPHY_EDGE_ROW_102_Right_102 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_0_97_400 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
X_10972_ _04689_ _04755_ _04769_ _04771_ VGND VGND VPWR VPWR _04772_ sky130_fd_sc_hd__o211a_1
XFILLER_0_85_617 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_0_69_146 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XTAP_TAPCELL_ROW_54_940 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_84_127 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_38_500 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_38_533 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_108_421 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_0_80_300 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XFILLER_0_65_363 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_0_92_193 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_0_92_171 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_53_547 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_104_9 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
X_11455_ _05288_ VGND VGND VPWR VPWR net65 sky130_fd_sc_hd__clkbuf_1
X_10406_ _02646_ _03690_ _04154_ _04155_ VGND VGND VPWR VPWR _04156_ sky130_fd_sc_hd__a22o_1
X_11386_ _05183_ _05217_ _05218_ VGND VGND VPWR VPWR _05219_ sky130_fd_sc_hd__nand3_1
X_10337_ _04078_ _04079_ _03950_ _03969_ VGND VGND VPWR VPWR _04081_ sky130_fd_sc_hd__a211oi_2
X_10268_ _03999_ _04004_ _04005_ VGND VGND VPWR VPWR _04006_ sky130_fd_sc_hd__nand3_2
X_10199_ _05468_ _03178_ _03928_ _03929_ VGND VGND VPWR VPWR _03930_ sky130_fd_sc_hd__a22o_1
XFILLER_0_76_628 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XFILLER_0_29_522 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_06430_ _03791_ _03255_ _03026_ _04085_ VGND VGND VPWR VPWR _05560_ sky130_fd_sc_hd__and4_1
XFILLER_0_56_341 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XFILLER_0_8_416 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_0_33_64 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_71_300 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_0_17_717 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
X_06361_ _05485_ _05491_ VGND VGND VPWR VPWR _05492_ sky130_fd_sc_hd__xnor2_2
XTAP_TAPCELL_ROW_32_656 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_99_7 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_71_311 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_09080_ _02364_ _02536_ _02708_ VGND VGND VPWR VPWR _02709_ sky130_fd_sc_hd__o21a_1
X_08100_ _01635_ _01636_ _01637_ VGND VGND VPWR VPWR _01639_ sky130_fd_sc_hd__a21o_1
X_06292_ _00799_ _03365_ _05345_ _05423_ VGND VGND VPWR VPWR _05424_ sky130_fd_sc_hd__nand4_2
XTAP_TAPCELL_ROW_32_667 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_114_413 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
Xinput40 mplier[16] VGND VGND VPWR VPWR net40 sky130_fd_sc_hd__clkbuf_2
X_08031_ _01561_ _01562_ VGND VGND VPWR VPWR _01564_ sky130_fd_sc_hd__and2_1
Xinput62 mplier[7] VGND VGND VPWR VPWR net62 sky130_fd_sc_hd__buf_4
XFILLER_0_114_457 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_102_608 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
Xinput51 mplier[26] VGND VGND VPWR VPWR net51 sky130_fd_sc_hd__buf_2
XFILLER_0_101_107 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_0_4_699 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_110_630 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_09982_ _05655_ _01980_ VGND VGND VPWR VPWR _03694_ sky130_fd_sc_hd__and2_1
X_08933_ _02343_ _02374_ _02548_ VGND VGND VPWR VPWR _02549_ sky130_fd_sc_hd__a21oi_4
XTAP_TAPCELL_ROW_4_315 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_42_3 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_99_709 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_08864_ _01582_ _00041_ _02471_ _02472_ VGND VGND VPWR VPWR _02473_ sky130_fd_sc_hd__a22o_1
XFILLER_0_98_219 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_0_74_60 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
X_08795_ _01490_ net130 _02396_ _02398_ VGND VGND VPWR VPWR _02399_ sky130_fd_sc_hd__a211o_1
X_07815_ _01318_ _01177_ VGND VGND VPWR VPWR _01328_ sky130_fd_sc_hd__or2b_1
XFILLER_0_74_82 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
X_07746_ _04063_ _05696_ _00423_ _03004_ VGND VGND VPWR VPWR _01253_ sky130_fd_sc_hd__a22oi_1
XTAP_TAPCELL_ROW_84_1312 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_67_617 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_94_414 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
X_09416_ _03069_ _03073_ _03075_ VGND VGND VPWR VPWR _03076_ sky130_fd_sc_hd__and3_1
X_07677_ _00905_ _01168_ _01167_ VGND VGND VPWR VPWR _01177_ sky130_fd_sc_hd__a21bo_2
XFILLER_0_94_458 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
X_06628_ _04705_ _03605_ _05464_ _05553_ VGND VGND VPWR VPWR _00056_ sky130_fd_sc_hd__and4_1
XFILLER_0_81_108 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_0_75_661 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_09347_ _02858_ _02860_ _02998_ _02999_ VGND VGND VPWR VPWR _03000_ sky130_fd_sc_hd__a211o_2
X_06559_ _05685_ _05687_ VGND VGND VPWR VPWR _05688_ sky130_fd_sc_hd__nor2_1
XFILLER_0_35_503 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_117_251 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_09278_ _04748_ _01856_ VGND VGND VPWR VPWR _02925_ sky130_fd_sc_hd__nand2_1
XFILLER_0_105_424 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_0_23_709 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_08229_ _01756_ _01757_ _01778_ _01779_ VGND VGND VPWR VPWR _01780_ sky130_fd_sc_hd__o211ai_4
XFILLER_0_50_539 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_22_219 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
X_11240_ _05059_ _05061_ VGND VGND VPWR VPWR net115 sky130_fd_sc_hd__xnor2_2
XTAP_TAPCELL_ROW_95_1452 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
X_11171_ _04941_ _04923_ _04985_ VGND VGND VPWR VPWR _04988_ sky130_fd_sc_hd__or3_1
XFILLER_0_101_641 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_101_663 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_10122_ _03843_ _03844_ _03846_ VGND VGND VPWR VPWR _03847_ sky130_fd_sc_hd__nand3_4
XFILLER_0_101_685 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
X_10053_ _03761_ _03770_ _03771_ VGND VGND VPWR VPWR _03772_ sky130_fd_sc_hd__and3_2
XFILLER_0_100_195 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
X_10955_ _03574_ _02051_ VGND VGND VPWR VPWR _04753_ sky130_fd_sc_hd__nand2_1
X_10886_ _04602_ _04604_ VGND VGND VPWR VPWR _04678_ sky130_fd_sc_hd__nand2_1
XFILLER_0_85_447 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_70_29 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_0_72_108 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_38_363 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_26_547 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_81_697 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_80_163 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_41_539 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
X_11438_ _05271_ _05273_ VGND VGND VPWR VPWR net122 sky130_fd_sc_hd__xnor2_1
X_11369_ _04800_ _05033_ VGND VGND VPWR VPWR _05200_ sky130_fd_sc_hd__and2_1
XFILLER_0_0_113 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_0_1_669 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_0_119_55 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
X_05930_ _02240_ _02797_ VGND VGND VPWR VPWR _02808_ sky130_fd_sc_hd__xnor2_1
X_05861_ _00297_ VGND VGND VPWR VPWR _02054_ sky130_fd_sc_hd__clkbuf_4
X_08580_ _01620_ VGND VGND VPWR VPWR _02163_ sky130_fd_sc_hd__buf_4
X_07600_ _00940_ _00943_ _01091_ _01092_ VGND VGND VPWR VPWR _01093_ sky130_fd_sc_hd__a211oi_1
X_05792_ _01225_ _01291_ VGND VGND VPWR VPWR _01302_ sky130_fd_sc_hd__xor2_1
X_07531_ _00907_ _01016_ _01017_ VGND VGND VPWR VPWR _01019_ sky130_fd_sc_hd__and3_1
XTAP_TAPCELL_ROW_37_726 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_44_52 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_76_425 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_44_63 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_119_505 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XTAP_TAPCELL_ROW_66_1086 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_8_202 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
X_07462_ _00927_ _00940_ _00942_ VGND VGND VPWR VPWR _00943_ sky130_fd_sc_hd__nand3_2
XTAP_TAPCELL_ROW_17_472 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
X_09201_ _05464_ _05553_ _02812_ VGND VGND VPWR VPWR _02842_ sky130_fd_sc_hd__and3_1
X_06413_ _01171_ _05541_ _05542_ VGND VGND VPWR VPWR _05543_ sky130_fd_sc_hd__and3_1
XFILLER_0_8_235 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
X_07393_ _00864_ _00866_ _00720_ _00722_ VGND VGND VPWR VPWR _00868_ sky130_fd_sc_hd__a211o_1
X_09132_ _02752_ _02754_ _02763_ VGND VGND VPWR VPWR _02766_ sky130_fd_sc_hd__a21oi_1
XFILLER_0_60_51 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_06344_ _05393_ _05396_ _05394_ VGND VGND VPWR VPWR _05475_ sky130_fd_sc_hd__a21bo_1
XFILLER_0_71_130 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_0_56_193 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XTAP_TAPCELL_ROW_118_1739 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_71_185 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
X_09063_ _04781_ _02160_ _02177_ _04770_ VGND VGND VPWR VPWR _02691_ sky130_fd_sc_hd__a22o_1
XFILLER_0_8_41 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_32_528 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
X_06275_ _01771_ _02000_ _02219_ _03223_ VGND VGND VPWR VPWR _05407_ sky130_fd_sc_hd__a22o_1
X_08014_ _03856_ net10 net11 _05416_ VGND VGND VPWR VPWR _01545_ sky130_fd_sc_hd__a22o_1
XFILLER_0_4_474 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XFILLER_0_114_298 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_8_85 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_40_550 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
X_09965_ _02228_ VGND VGND VPWR VPWR _03675_ sky130_fd_sc_hd__buf_4
XFILLER_0_110_471 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
X_09896_ _03597_ _03598_ _03560_ VGND VGND VPWR VPWR _03600_ sky130_fd_sc_hd__a21boi_1
XTAP_TAPCELL_ROW_90_1393 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_90_1382 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
X_08916_ _00974_ _00985_ _02529_ _01987_ VGND VGND VPWR VPWR _02530_ sky130_fd_sc_hd__nand4_2
X_08847_ _00283_ _00751_ VGND VGND VPWR VPWR _02454_ sky130_fd_sc_hd__nand2_1
X_08778_ _02378_ _02379_ VGND VGND VPWR VPWR _02380_ sky130_fd_sc_hd__xnor2_4
XFILLER_0_79_263 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
X_07729_ _01230_ _01231_ _01232_ VGND VGND VPWR VPWR _01234_ sky130_fd_sc_hd__a21oi_1
X_10740_ _04516_ _04517_ _04497_ VGND VGND VPWR VPWR _04519_ sky130_fd_sc_hd__o21ai_2
XFILLER_0_94_244 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_67_458 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
X_10671_ _04359_ _04360_ _04442_ _04443_ VGND VGND VPWR VPWR _04445_ sky130_fd_sc_hd__o211ai_4
XFILLER_0_90_450 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_0_62_141 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_0_90_483 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_63_697 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_62_174 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_23_517 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_0_120_224 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_105_298 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_11223_ _05004_ _04980_ _05042_ _05043_ VGND VGND VPWR VPWR _05044_ sky130_fd_sc_hd__a211oi_2
XFILLER_0_31_550 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
X_11154_ _03294_ _03478_ VGND VGND VPWR VPWR _04969_ sky130_fd_sc_hd__and2_1
X_11085_ _04891_ _04892_ VGND VGND VPWR VPWR _04894_ sky130_fd_sc_hd__nand2_1
X_10105_ _00356_ _03827_ _03824_ _03825_ VGND VGND VPWR VPWR _03828_ sky130_fd_sc_hd__nand4_1
X_10036_ _03751_ _03752_ VGND VGND VPWR VPWR _03753_ sky130_fd_sc_hd__xnor2_2
XFILLER_0_86_701 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
X_10938_ _04731_ _04733_ VGND VGND VPWR VPWR _04734_ sky130_fd_sc_hd__xnor2_1
XFILLER_0_85_277 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_0_85_255 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XTAP_TAPCELL_ROW_14_431 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_14_77 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
X_10869_ _04657_ _04658_ VGND VGND VPWR VPWR _04659_ sky130_fd_sc_hd__nand2_1
XTAP_TAPCELL_ROW_14_442 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_26_322 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_121_23 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_0_53_130 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XTAP_TAPCELL_ROW_42_784 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_26_377 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_100_3 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
X_06060_ _02284_ _02841_ _02852_ VGND VGND VPWR VPWR _04227_ sky130_fd_sc_hd__nor3_1
XFILLER_0_10_701 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_111_279 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XTAP_TAPCELL_ROW_113_1669 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
X_09750_ _02695_ VGND VGND VPWR VPWR _03440_ sky130_fd_sc_hd__clkbuf_4
X_06962_ _00394_ _00396_ VGND VGND VPWR VPWR _00397_ sky130_fd_sc_hd__nand2_1
X_09681_ _03362_ _03363_ _03208_ _03282_ VGND VGND VPWR VPWR _03366_ sky130_fd_sc_hd__o211ai_2
X_08701_ _02283_ _02294_ VGND VGND VPWR VPWR _02296_ sky130_fd_sc_hd__xnor2_2
X_05913_ _02535_ _02546_ _02600_ VGND VGND VPWR VPWR _02622_ sky130_fd_sc_hd__a21o_1
X_08632_ _01865_ _02218_ _02220_ VGND VGND VPWR VPWR _02221_ sky130_fd_sc_hd__or3_2
X_06893_ _00211_ _00259_ _00320_ _00321_ VGND VGND VPWR VPWR _00322_ sky130_fd_sc_hd__o211a_1
XTAP_TAPCELL_ROW_68_1115 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
X_05844_ _01837_ _01847_ _01476_ _01116_ VGND VGND VPWR VPWR _01869_ sky130_fd_sc_hd__a211o_1
XFILLER_0_55_84 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_0_89_561 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
X_08563_ _05311_ _02141_ _02143_ _02144_ VGND VGND VPWR VPWR _02145_ sky130_fd_sc_hd__nand4_4
X_05775_ _00417_ _01094_ _01105_ VGND VGND VPWR VPWR _01116_ sky130_fd_sc_hd__and3_1
X_08494_ _02057_ _02067_ _02068_ VGND VGND VPWR VPWR _02069_ sky130_fd_sc_hd__nand3_2
XFILLER_0_9_500 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
X_07514_ _00989_ _00998_ _00999_ VGND VGND VPWR VPWR _01000_ sky130_fd_sc_hd__nand3_1
XFILLER_0_64_406 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
X_07445_ _00922_ _00923_ VGND VGND VPWR VPWR _00924_ sky130_fd_sc_hd__nor2_2
XFILLER_0_91_269 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
X_07376_ _00846_ _00847_ _00848_ VGND VGND VPWR VPWR _00849_ sky130_fd_sc_hd__nand3_4
XFILLER_0_29_193 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_44_141 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
X_09115_ _02575_ _02616_ VGND VGND VPWR VPWR _02747_ sky130_fd_sc_hd__and2b_1
X_06327_ _05456_ _05457_ VGND VGND VPWR VPWR _05458_ sky130_fd_sc_hd__and2_1
XFILLER_0_45_686 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XTAP_TAPCELL_ROW_79_1255 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_79_1244 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
X_09046_ _00269_ _01620_ VGND VGND VPWR VPWR _02672_ sky130_fd_sc_hd__and2_1
XFILLER_0_60_645 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
X_06258_ _05389_ VGND VGND VPWR VPWR _05390_ sky130_fd_sc_hd__inv_2
XTAP_TAPCELL_ROW_92_1411 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
X_06189_ _05317_ _05321_ VGND VGND VPWR VPWR _05322_ sky130_fd_sc_hd__xnor2_2
X_09948_ _03532_ _03655_ _03656_ VGND VGND VPWR VPWR _03657_ sky130_fd_sc_hd__nand3_2
XFILLER_0_99_303 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
X_09879_ _05656_ _03341_ _03394_ _03393_ _03297_ VGND VGND VPWR VPWR _03581_ sky130_fd_sc_hd__a32o_1
XFILLER_0_68_701 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
X_10723_ _00754_ _03294_ _04376_ _04375_ _04374_ VGND VGND VPWR VPWR _04501_ sky130_fd_sc_hd__a32o_1
XFILLER_0_36_631 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
X_10654_ _04423_ _04424_ _04415_ VGND VGND VPWR VPWR _04426_ sky130_fd_sc_hd__a21oi_2
XTAP_TAPCELL_ROW_11_401 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
X_10585_ _04241_ _04242_ _04244_ VGND VGND VPWR VPWR _04352_ sky130_fd_sc_hd__or3_1
XFILLER_0_106_541 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_0_63_461 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_51_612 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_0_3_709 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_23_303 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_106_563 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_0_121_511 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_121_555 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
X_11206_ _01355_ _04732_ _01500_ _04883_ VGND VGND VPWR VPWR _05025_ sky130_fd_sc_hd__a22o_1
X_11137_ _04947_ _04948_ _04876_ VGND VGND VPWR VPWR _04950_ sky130_fd_sc_hd__o21a_1
X_11068_ _00614_ _00751_ _02864_ _02866_ VGND VGND VPWR VPWR _04875_ sky130_fd_sc_hd__and4_1
XFILLER_0_92_27 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
X_10019_ _03700_ _03701_ _03732_ _03733_ VGND VGND VPWR VPWR _03734_ sky130_fd_sc_hd__a211oi_4
XTAP_TAPCELL_ROW_19_501 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_25_43 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XTAP_TAPCELL_ROW_47_854 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_86_531 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_25_65 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_25_87 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_46_406 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XTAP_TAPCELL_ROW_63_1045 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_18_119 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_46_439 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
X_07230_ _00297_ net27 net42 VGND VGND VPWR VPWR _00689_ sky130_fd_sc_hd__and3_1
XFILLER_0_109_390 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
X_07161_ _00612_ VGND VGND VPWR VPWR _00614_ sky130_fd_sc_hd__clkbuf_4
XFILLER_0_14_325 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
X_06112_ _04705_ _01552_ _04770_ _04781_ VGND VGND VPWR VPWR _04792_ sky130_fd_sc_hd__nand4_1
XFILLER_0_42_645 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_112_533 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_112_522 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_07092_ _00529_ _00538_ VGND VGND VPWR VPWR _00539_ sky130_fd_sc_hd__xor2_1
XFILLER_0_41_166 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
X_06043_ _03179_ _03168_ VGND VGND VPWR VPWR _04041_ sky130_fd_sc_hd__or2b_1
XFILLER_0_10_531 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
X_09802_ _03494_ _03495_ _03488_ VGND VGND VPWR VPWR _03498_ sky130_fd_sc_hd__a21o_1
XTAP_TAPCELL_ROW_74_1185 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
X_07994_ _01520_ _01521_ _01506_ _01507_ VGND VGND VPWR VPWR _01523_ sky130_fd_sc_hd__o211a_1
X_09733_ _01762_ _02104_ _00914_ VGND VGND VPWR VPWR _03422_ sky130_fd_sc_hd__and3_1
XFILLER_0_66_83 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
X_06945_ _00341_ _00376_ _00377_ VGND VGND VPWR VPWR _00378_ sky130_fd_sc_hd__nor3_1
X_09664_ _02646_ _01606_ _03344_ _03345_ VGND VGND VPWR VPWR _03347_ sky130_fd_sc_hd__nand4_1
X_06876_ _00548_ _00197_ _00301_ _00526_ VGND VGND VPWR VPWR _00303_ sky130_fd_sc_hd__a22o_1
X_09595_ _03110_ _03112_ _03269_ _03270_ VGND VGND VPWR VPWR _03271_ sky130_fd_sc_hd__a211o_1
X_05827_ _01640_ _01672_ VGND VGND VPWR VPWR _01683_ sky130_fd_sc_hd__xor2_2
X_08615_ _02199_ _02200_ _02158_ _02001_ VGND VGND VPWR VPWR _02202_ sky130_fd_sc_hd__a211o_2
XFILLER_0_89_380 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_82_82 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XFILLER_0_65_715 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
X_05758_ _00886_ _00897_ _00919_ VGND VGND VPWR VPWR _00930_ sky130_fd_sc_hd__and3_1
X_08546_ _02123_ _02124_ _01960_ _01962_ VGND VGND VPWR VPWR _02126_ sky130_fd_sc_hd__o211ai_2
XFILLER_0_49_266 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
X_08477_ _02048_ _02049_ VGND VGND VPWR VPWR _02050_ sky130_fd_sc_hd__nor2_2
XFILLER_0_64_225 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_64_214 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_119_165 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_0_92_545 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
X_07428_ _00786_ _00789_ _00904_ VGND VGND VPWR VPWR _00905_ sky130_fd_sc_hd__a21oi_2
XFILLER_0_92_589 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_18_664 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
X_07359_ _00430_ VGND VGND VPWR VPWR _00830_ sky130_fd_sc_hd__clkbuf_4
XFILLER_0_60_431 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XFILLER_0_17_196 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_32_133 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_0_33_656 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
X_10370_ _04004_ _04006_ _04115_ _04116_ VGND VGND VPWR VPWR _04117_ sky130_fd_sc_hd__a211o_2
XFILLER_0_20_306 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XFILLER_0_32_155 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
X_09029_ _02650_ _02651_ _02652_ VGND VGND VPWR VPWR _02653_ sky130_fd_sc_hd__nand3_1
XFILLER_0_20_339 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_13_391 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XTAP_TAPCELL_ROW_44_813 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_55_225 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_0_28_428 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
X_10706_ _04479_ _04480_ _04457_ _04393_ VGND VGND VPWR VPWR _04482_ sky130_fd_sc_hd__a211o_1
XFILLER_0_36_472 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
X_10637_ _04300_ _04301_ VGND VGND VPWR VPWR _04408_ sky130_fd_sc_hd__and2b_1
X_10568_ _04330_ _04331_ _04295_ VGND VGND VPWR VPWR _04333_ sky130_fd_sc_hd__o21ai_2
XPHY_EDGE_ROW_116_Right_116 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
X_10499_ _05541_ _05637_ _02862_ VGND VGND VPWR VPWR _04257_ sky130_fd_sc_hd__and3_1
XFILLER_0_121_385 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_0_121_363 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XTAP_TAPCELL_ROW_110_1639 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
Xinput5 mcand[13] VGND VGND VPWR VPWR net5 sky130_fd_sc_hd__buf_4
X_06730_ _00155_ _00156_ VGND VGND VPWR VPWR _00157_ sky130_fd_sc_hd__xnor2_2
X_06661_ _05502_ VGND VGND VPWR VPWR _00089_ sky130_fd_sc_hd__clkbuf_4
X_08400_ _01788_ _01789_ VGND VGND VPWR VPWR _01966_ sky130_fd_sc_hd__nand2_1
X_09380_ _02869_ _03033_ _03035_ VGND VGND VPWR VPWR _03036_ sky130_fd_sc_hd__nand3_1
X_06592_ _00018_ _00019_ _05633_ VGND VGND VPWR VPWR _00021_ sky130_fd_sc_hd__o21a_1
X_08331_ _01751_ _01753_ net145 _01890_ VGND VGND VPWR VPWR _01892_ sky130_fd_sc_hd__a211oi_2
XFILLER_0_19_417 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XTAP_TAPCELL_ROW_121_1779 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_117_636 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
X_08262_ _01813_ _01814_ _01816_ VGND VGND VPWR VPWR _01817_ sky130_fd_sc_hd__nand3_4
X_07213_ _00653_ _00654_ _00669_ VGND VGND VPWR VPWR _00671_ sky130_fd_sc_hd__nor3_1
XFILLER_0_27_494 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_08193_ _01735_ _01739_ _01740_ VGND VGND VPWR VPWR _01741_ sky130_fd_sc_hd__nand3_1
XTAP_TAPCELL_ROW_76_1214 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
X_07144_ _00594_ _00595_ VGND VGND VPWR VPWR _00596_ sky130_fd_sc_hd__xnor2_2
XFILLER_0_72_3 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
X_07075_ _00398_ _00399_ VGND VGND VPWR VPWR _00520_ sky130_fd_sc_hd__and2_1
XFILLER_0_112_363 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_100_514 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
X_06026_ net34 VGND VGND VPWR VPWR _03856_ sky130_fd_sc_hd__clkbuf_4
XFILLER_0_100_536 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_10_372 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
X_07977_ _01337_ _01347_ VGND VGND VPWR VPWR _01504_ sky130_fd_sc_hd__or2b_1
X_09716_ _00269_ _02692_ VGND VGND VPWR VPWR _03403_ sky130_fd_sc_hd__and2_1
X_06928_ _00240_ _00358_ VGND VGND VPWR VPWR _00359_ sky130_fd_sc_hd__xnor2_1
XFILLER_0_93_92 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XTAP_TAPCELL_ROW_87_1354 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
X_09647_ _03326_ _03327_ VGND VGND VPWR VPWR _03328_ sky130_fd_sc_hd__xor2_1
XTAP_TAPCELL_ROW_2_287 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
X_06859_ _00188_ _00190_ _00191_ VGND VGND VPWR VPWR _00285_ sky130_fd_sc_hd__o21ba_2
X_09578_ _03249_ _03251_ VGND VGND VPWR VPWR _03252_ sky130_fd_sc_hd__xnor2_4
XFILLER_0_38_704 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
X_08529_ _05540_ _00556_ _00038_ _00421_ VGND VGND VPWR VPWR _02107_ sky130_fd_sc_hd__a22o_1
XFILLER_0_37_225 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_0_107_124 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_0_107_113 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_0_80_526 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XTAP_TAPCELL_ROW_98_1483 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
X_10422_ _02626_ _02850_ _04067_ _04068_ VGND VGND VPWR VPWR _04174_ sky130_fd_sc_hd__and4_1
X_10353_ _01221_ _01849_ _03988_ _04098_ VGND VGND VPWR VPWR _04099_ sky130_fd_sc_hd__a31o_1
XFILLER_0_20_125 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
X_10284_ _03926_ _03927_ _04022_ _04023_ VGND VGND VPWR VPWR _04024_ sky130_fd_sc_hd__o211a_2
XFILLER_0_73_29 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XTAP_TAPCELL_ROW_57_971 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_87_158 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_96_681 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_56_501 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XPHY_EDGE_ROW_1_Left_123 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XTAP_TAPCELL_ROW_60_1015 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_113_57 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_56_589 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_44_718 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XFILLER_0_114_617 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_98_15 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_113_105 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_0_24_464 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_0_51_272 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_121_160 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_51_294 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_12_659 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_11_169 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XPHY_EDGE_ROW_47_Left_169 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XTAP_TAPCELL_ROW_71_1144 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
X_08880_ _02344_ _02354_ _02353_ VGND VGND VPWR VPWR _02490_ sky130_fd_sc_hd__a21o_1
X_07900_ _01419_ _01420_ VGND VGND VPWR VPWR _01421_ sky130_fd_sc_hd__nor2_2
XTAP_TAPCELL_ROW_71_1155 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
X_07831_ _01339_ _01344_ VGND VGND VPWR VPWR _01346_ sky130_fd_sc_hd__xor2_2
X_09501_ _03024_ _03025_ _03043_ _03044_ VGND VGND VPWR VPWR _03169_ sky130_fd_sc_hd__or4_1
X_07762_ _01268_ _01270_ net31 _00195_ VGND VGND VPWR VPWR _01271_ sky130_fd_sc_hd__and4bb_1
XFILLER_0_63_40 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_06713_ _00493_ _00450_ _00138_ _00139_ VGND VGND VPWR VPWR _00140_ sky130_fd_sc_hd__nand4_2
XFILLER_0_2_65 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
X_07693_ _01182_ _01194_ VGND VGND VPWR VPWR _01195_ sky130_fd_sc_hd__xnor2_1
X_09432_ _03090_ _03092_ VGND VGND VPWR VPWR _03093_ sky130_fd_sc_hd__xnor2_4
XFILLER_0_66_309 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XPHY_EDGE_ROW_56_Left_178 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
X_06644_ _00069_ _00070_ _05665_ _05667_ VGND VGND VPWR VPWR _00072_ sky130_fd_sc_hd__o211a_1
X_09363_ _02848_ _02849_ _03016_ _03017_ VGND VGND VPWR VPWR _03018_ sky130_fd_sc_hd__a211o_1
XFILLER_0_19_203 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_0_19_214 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_06575_ _00001_ _00002_ _05691_ VGND VGND VPWR VPWR _00004_ sky130_fd_sc_hd__a21o_1
X_08314_ _05327_ _00893_ _01185_ _03780_ VGND VGND VPWR VPWR _01873_ sky130_fd_sc_hd__a22o_1
XTAP_TAPCELL_ROW_35_698 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XANTENNA_10 _01980_ VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XTAP_TAPCELL_ROW_82_1284 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
X_09294_ _00893_ VGND VGND VPWR VPWR _02943_ sky130_fd_sc_hd__clkbuf_8
XFILLER_0_62_504 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XANTENNA_32 net86 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XANTENNA_21 _05307_ VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_0_105_617 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_7_653 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_6_141 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XANTENNA_43 net120 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_0_34_228 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
X_08245_ _00991_ VGND VGND VPWR VPWR _01798_ sky130_fd_sc_hd__clkbuf_4
XANTENNA_54 net3 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
X_08176_ _04976_ net13 VGND VGND VPWR VPWR _01722_ sky130_fd_sc_hd__and2_1
XFILLER_0_7_697 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_104_138 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
X_07127_ _00574_ _00575_ _00576_ VGND VGND VPWR VPWR _00577_ sky130_fd_sc_hd__nand3_4
XFILLER_0_70_592 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XPHY_EDGE_ROW_65_Left_187 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_0_30_434 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XFILLER_0_88_92 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_0_2_391 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
X_07058_ _00832_ _01508_ net7 net8 VGND VGND VPWR VPWR _00501_ sky130_fd_sc_hd__and4_1
XTAP_TAPCELL_ROW_7_346 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
X_06009_ _00559_ _02197_ _03124_ _00581_ VGND VGND VPWR VPWR _03671_ sky130_fd_sc_hd__a22oi_1
X_10971_ _04767_ _04768_ _04685_ _04687_ VGND VGND VPWR VPWR _04771_ sky130_fd_sc_hd__o211ai_1
XPHY_EDGE_ROW_74_Left_196 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_0_97_467 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_69_169 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_0_85_629 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XTAP_TAPCELL_ROW_54_941 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_38_523 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_65_320 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XFILLER_0_38_545 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_0_93_673 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_92_161 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_0_38_578 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XFILLER_0_38_589 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_25_217 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_0_53_559 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
X_11454_ _00635_ _01356_ VGND VGND VPWR VPWR _05288_ sky130_fd_sc_hd__and2_2
XFILLER_0_40_209 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
X_10405_ _02640_ _02641_ _03171_ _02868_ VGND VGND VPWR VPWR _04155_ sky130_fd_sc_hd__nand4_2
X_11385_ _05178_ _05179_ VGND VGND VPWR VPWR _05218_ sky130_fd_sc_hd__nand2_1
XFILLER_0_104_661 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_0_317 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_21_445 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
X_10336_ _03950_ _03969_ _04078_ _04079_ VGND VGND VPWR VPWR _04080_ sky130_fd_sc_hd__o211a_2
X_10267_ _04002_ _04003_ _03817_ _03819_ VGND VGND VPWR VPWR _04005_ sky130_fd_sc_hd__o211ai_2
X_10198_ _05320_ _05388_ _02868_ _02865_ VGND VGND VPWR VPWR _03929_ sky130_fd_sc_hd__nand4_4
XTAP_TAPCELL_ROW_109_1630 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_17_55 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_17_77 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XFILLER_0_119_709 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_0_33_76 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XTAP_TAPCELL_ROW_32_657 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
X_06360_ _05489_ _05490_ VGND VGND VPWR VPWR _05491_ sky130_fd_sc_hd__or2_2
XFILLER_0_4_601 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
X_06291_ net37 VGND VGND VPWR VPWR _05423_ sky130_fd_sc_hd__buf_4
XTAP_TAPCELL_ROW_32_668 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
Xinput30 mcand[7] VGND VGND VPWR VPWR net30 sky130_fd_sc_hd__clkbuf_2
XFILLER_0_114_403 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_0_3_111 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
X_08030_ _01559_ _01560_ _01412_ _01413_ VGND VGND VPWR VPWR _01562_ sky130_fd_sc_hd__o211ai_1
Xinput63 mplier[8] VGND VGND VPWR VPWR net63 sky130_fd_sc_hd__buf_2
XFILLER_0_114_469 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
Xinput52 mplier[27] VGND VGND VPWR VPWR net52 sky130_fd_sc_hd__clkbuf_4
XFILLER_0_4_645 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
Xinput41 mplier[17] VGND VGND VPWR VPWR net41 sky130_fd_sc_hd__buf_2
XFILLER_0_12_434 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XFILLER_0_110_620 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
X_09981_ _03689_ _03691_ VGND VGND VPWR VPWR _03693_ sky130_fd_sc_hd__nand2_1
XFILLER_0_110_664 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
X_08932_ _02371_ _02373_ VGND VGND VPWR VPWR _02548_ sky130_fd_sc_hd__and2b_1
X_08863_ _02108_ _02110_ _01588_ _02104_ VGND VGND VPWR VPWR _02472_ sky130_fd_sc_hd__nand4_2
XTAP_TAPCELL_ROW_4_316 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_35_3 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
X_08794_ _02223_ _02027_ _02397_ VGND VGND VPWR VPWR _02398_ sky130_fd_sc_hd__a21oi_1
X_07814_ _01325_ _01323_ _01326_ VGND VGND VPWR VPWR _01327_ sky130_fd_sc_hd__o21a_1
XFILLER_0_74_72 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
X_07745_ _01248_ _01251_ VGND VGND VPWR VPWR _01252_ sky130_fd_sc_hd__nor2_2
XTAP_TAPCELL_ROW_84_1313 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
X_09415_ _03074_ _02400_ VGND VGND VPWR VPWR _03075_ sky130_fd_sc_hd__or2b_1
XFILLER_0_67_629 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XFILLER_0_66_106 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
X_07676_ _01172_ _01173_ VGND VGND VPWR VPWR _01176_ sky130_fd_sc_hd__nor2_2
X_06627_ _00515_ _05468_ VGND VGND VPWR VPWR _00055_ sky130_fd_sc_hd__nand2_2
XTAP_TAPCELL_ROW_51_900 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_47_331 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XFILLER_0_90_93 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_75_673 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
X_09346_ _02996_ _02997_ _02981_ VGND VGND VPWR VPWR _02999_ sky130_fd_sc_hd__a21oi_2
X_06558_ _00985_ _05343_ _05686_ _00974_ VGND VGND VPWR VPWR _05687_ sky130_fd_sc_hd__a22oi_2
X_09277_ _01850_ _02922_ _02923_ VGND VGND VPWR VPWR _02924_ sky130_fd_sc_hd__a21bo_1
X_06489_ _05456_ _05618_ VGND VGND VPWR VPWR _05619_ sky130_fd_sc_hd__xnor2_1
XFILLER_0_35_559 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
X_08228_ _01776_ _01777_ _01758_ VGND VGND VPWR VPWR _01779_ sky130_fd_sc_hd__a21o_1
XFILLER_0_31_710 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XTAP_TAPCELL_ROW_95_1453 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
X_08159_ _01515_ _01689_ _01701_ net162 VGND VGND VPWR VPWR _01703_ sky130_fd_sc_hd__a211oi_4
X_11170_ _04941_ _04923_ _04985_ VGND VGND VPWR VPWR _04986_ sky130_fd_sc_hd__o21ai_1
XFILLER_0_100_130 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_10121_ _03719_ _03726_ _03724_ VGND VGND VPWR VPWR _03846_ sky130_fd_sc_hd__a21bo_1
XFILLER_0_101_697 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
X_10052_ _03767_ _03768_ _03762_ VGND VGND VPWR VPWR _03771_ sky130_fd_sc_hd__a21o_1
XPHY_EDGE_ROW_82_Left_204 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
X_10954_ _04749_ _04751_ VGND VGND VPWR VPWR _04752_ sky130_fd_sc_hd__xnor2_1
XFILLER_0_57_106 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XTAP_TAPCELL_ROW_104_1560 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
X_10885_ _04561_ _04570_ _04569_ VGND VGND VPWR VPWR _04677_ sky130_fd_sc_hd__a21o_1
XFILLER_0_57_128 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_93_481 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XPHY_EDGE_ROW_91_Left_213 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_0_65_183 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_0_65_161 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_53_312 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_0_108_285 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XFILLER_0_80_186 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_11437_ _05272_ _05253_ VGND VGND VPWR VPWR _05273_ sky130_fd_sc_hd__nor2_1
XFILLER_0_1_615 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_21_231 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_111_439 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_11368_ _05197_ _05198_ VGND VGND VPWR VPWR _05199_ sky130_fd_sc_hd__xnor2_1
XFILLER_0_21_264 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
X_10319_ _01606_ _00753_ _04059_ _04060_ VGND VGND VPWR VPWR _04061_ sky130_fd_sc_hd__a22o_1
XFILLER_0_0_169 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XFILLER_0_0_147 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
X_11299_ _05123_ _05124_ VGND VGND VPWR VPWR _05125_ sky130_fd_sc_hd__xnor2_1
XFILLER_0_28_65 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
X_05860_ _01989_ _02022_ _01519_ _01541_ VGND VGND VPWR VPWR _02043_ sky130_fd_sc_hd__o211ai_2
X_05791_ _01258_ _01280_ VGND VGND VPWR VPWR _01291_ sky130_fd_sc_hd__or2_1
XFILLER_0_88_242 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
X_07530_ _01014_ _01015_ _00909_ _00860_ VGND VGND VPWR VPWR _01017_ sky130_fd_sc_hd__a211o_1
XTAP_TAPCELL_ROW_37_727 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_66_1087 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_17_473 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
X_07461_ _00937_ _00938_ _00939_ VGND VGND VPWR VPWR _00942_ sky130_fd_sc_hd__a21o_1
X_09200_ _02163_ VGND VGND VPWR VPWR _02840_ sky130_fd_sc_hd__buf_4
X_06412_ _00406_ _05468_ _05466_ _05465_ VGND VGND VPWR VPWR _05542_ sky130_fd_sc_hd__a31o_1
XFILLER_0_57_673 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_07392_ _00720_ _00722_ _00864_ _00866_ VGND VGND VPWR VPWR _00867_ sky130_fd_sc_hd__o211ai_4
XFILLER_0_29_364 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
X_09131_ _02752_ _02754_ _02763_ VGND VGND VPWR VPWR _02765_ sky130_fd_sc_hd__and3_1
XFILLER_0_57_695 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
X_06343_ _00504_ _04585_ _05471_ _05472_ VGND VGND VPWR VPWR _05474_ sky130_fd_sc_hd__and4_1
XFILLER_0_60_85 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
X_09062_ _02527_ _02528_ _02530_ VGND VGND VPWR VPWR _02690_ sky130_fd_sc_hd__a21bo_1
XFILLER_0_17_559 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_44_356 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_72_698 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
X_06274_ _03627_ _04737_ _05337_ _05336_ VGND VGND VPWR VPWR _05406_ sky130_fd_sc_hd__a31o_1
XFILLER_0_44_378 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
X_08013_ _03856_ _05416_ net11 VGND VGND VPWR VPWR _01544_ sky130_fd_sc_hd__and3_1
XFILLER_0_8_53 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_102_439 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_8_97 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_110_461 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
X_09964_ _03615_ _03618_ VGND VGND VPWR VPWR _03674_ sky130_fd_sc_hd__nand2_2
XFILLER_0_0_681 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
X_09895_ _03560_ _03597_ _03598_ VGND VGND VPWR VPWR _03599_ sky130_fd_sc_hd__and3b_1
XTAP_TAPCELL_ROW_90_1383 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
X_08915_ net54 VGND VGND VPWR VPWR _02529_ sky130_fd_sc_hd__clkbuf_4
X_08846_ _01898_ _02451_ _02452_ VGND VGND VPWR VPWR _02453_ sky130_fd_sc_hd__a21bo_1
XFILLER_0_79_220 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
X_08777_ _02129_ _02206_ _02205_ VGND VGND VPWR VPWR _02379_ sky130_fd_sc_hd__a21boi_4
X_05989_ _03277_ _03430_ _03441_ VGND VGND VPWR VPWR _03452_ sky130_fd_sc_hd__nand3_1
X_07728_ _01230_ _01231_ _01232_ VGND VGND VPWR VPWR _01233_ sky130_fd_sc_hd__and3_1
X_07659_ _01008_ _01096_ _01156_ _01157_ VGND VGND VPWR VPWR _01158_ sky130_fd_sc_hd__a211o_1
X_10670_ _04440_ _04441_ _04361_ _04362_ VGND VGND VPWR VPWR _04443_ sky130_fd_sc_hd__a211o_1
XFILLER_0_75_470 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
X_09329_ _02978_ _02979_ VGND VGND VPWR VPWR _02980_ sky130_fd_sc_hd__or2b_1
XFILLER_0_35_301 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_118_572 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_0_106_701 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_50_304 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_90_495 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
X_11222_ _05020_ _05040_ VGND VGND VPWR VPWR _05043_ sky130_fd_sc_hd__nor2_1
X_11153_ _04966_ _04967_ VGND VGND VPWR VPWR _04968_ sky130_fd_sc_hd__xnor2_1
XFILLER_0_101_494 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_11084_ _04891_ _04892_ VGND VGND VPWR VPWR _04893_ sky130_fd_sc_hd__or2_1
X_10104_ _02667_ VGND VGND VPWR VPWR _03827_ sky130_fd_sc_hd__clkbuf_4
X_10035_ _00409_ _03247_ VGND VGND VPWR VPWR _03752_ sky130_fd_sc_hd__nand2_1
XFILLER_0_86_713 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
X_10937_ _00754_ _04732_ VGND VGND VPWR VPWR _04733_ sky130_fd_sc_hd__nand2_1
XFILLER_0_39_662 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_10868_ _04573_ _04656_ VGND VGND VPWR VPWR _04658_ sky130_fd_sc_hd__or2_1
XTAP_TAPCELL_ROW_14_432 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_14_443 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_39_673 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_121_13 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
X_10799_ _01850_ _04581_ _04582_ VGND VGND VPWR VPWR _04583_ sky130_fd_sc_hd__a21bo_1
XTAP_TAPCELL_ROW_42_785 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_121_57 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XFILLER_0_54_698 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XFILLER_0_26_389 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_53_186 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_0_41_337 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_111_225 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_0_10_713 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_0_1_467 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_0_22_595 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
X_06961_ _03856_ _04542_ _05341_ _04520_ VGND VGND VPWR VPWR _00396_ sky130_fd_sc_hd__a22o_1
X_09680_ _03208_ _03282_ _03362_ _03363_ VGND VGND VPWR VPWR _03364_ sky130_fd_sc_hd__a211o_2
X_08700_ _02292_ _02293_ VGND VGND VPWR VPWR _02294_ sky130_fd_sc_hd__or2b_1
X_05912_ _02535_ _02546_ _02600_ VGND VGND VPWR VPWR _02611_ sky130_fd_sc_hd__nand3_2
X_08631_ _02216_ _02217_ _02016_ _02029_ VGND VGND VPWR VPWR _02220_ sky130_fd_sc_hd__a211oi_4
X_06892_ _00280_ _00281_ _00317_ _00318_ VGND VGND VPWR VPWR _00321_ sky130_fd_sc_hd__o22ai_2
XTAP_TAPCELL_ROW_68_1116 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
X_05843_ _01476_ _01116_ _01837_ _01847_ VGND VGND VPWR VPWR _01858_ sky130_fd_sc_hd__o211ai_4
XFILLER_0_89_573 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
X_08562_ _03026_ _04552_ _01949_ _01441_ VGND VGND VPWR VPWR _02144_ sky130_fd_sc_hd__nand4_4
X_05774_ _01083_ _00744_ _00788_ VGND VGND VPWR VPWR _01105_ sky130_fd_sc_hd__nand3_1
X_08493_ _02063_ _02066_ _02058_ VGND VGND VPWR VPWR _02068_ sky130_fd_sc_hd__a21o_1
XFILLER_0_49_437 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
X_07513_ _00994_ _00995_ _00997_ VGND VGND VPWR VPWR _00999_ sky130_fd_sc_hd__a21o_1
XFILLER_0_49_459 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
X_07444_ _03255_ _00355_ _00920_ _00921_ VGND VGND VPWR VPWR _00923_ sky130_fd_sc_hd__o2bb2a_1
XFILLER_0_91_237 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_57_470 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
X_07375_ _00693_ _00703_ _00702_ VGND VGND VPWR VPWR _00848_ sky130_fd_sc_hd__a21bo_1
XFILLER_0_45_632 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
X_09114_ _02615_ _02576_ VGND VGND VPWR VPWR _02746_ sky130_fd_sc_hd__and2b_1
XFILLER_0_17_389 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
X_06326_ _05391_ _05401_ _05403_ VGND VGND VPWR VPWR _05457_ sky130_fd_sc_hd__or3_1
XFILLER_0_45_698 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_0_115_564 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XTAP_TAPCELL_ROW_79_1245 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
X_09045_ _02665_ _02670_ VGND VGND VPWR VPWR _02671_ sky130_fd_sc_hd__xor2_1
XFILLER_0_60_635 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_06257_ _00373_ _05320_ _05388_ _00395_ VGND VGND VPWR VPWR _05389_ sky130_fd_sc_hd__a22o_1
XFILLER_0_102_214 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XTAP_TAPCELL_ROW_92_1412 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_4_283 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_32_359 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
X_06188_ _01171_ _05320_ VGND VGND VPWR VPWR _05321_ sky130_fd_sc_hd__nand2_1
Xmax_cap160 _03561_ VGND VGND VPWR VPWR net160 sky130_fd_sc_hd__buf_1
XFILLER_0_96_81 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
X_09947_ _03653_ _03654_ _03516_ _03519_ VGND VGND VPWR VPWR _03656_ sky130_fd_sc_hd__a211o_1
XFILLER_0_99_337 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_0_99_315 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
X_09878_ _03444_ _03446_ VGND VGND VPWR VPWR _03580_ sky130_fd_sc_hd__nand2_1
X_08829_ _02429_ _02432_ _02433_ VGND VGND VPWR VPWR _02434_ sky130_fd_sc_hd__nand3_2
XFILLER_0_68_713 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_0_95_521 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_0_67_223 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_67_212 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
X_10722_ _03827_ _02840_ _00896_ _01042_ _04420_ VGND VGND VPWR VPWR _04500_ sky130_fd_sc_hd__a41o_1
XTAP_TAPCELL_ROW_101_1530 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
X_10653_ _04415_ _04423_ _04424_ VGND VGND VPWR VPWR _04425_ sky130_fd_sc_hd__and3_2
XFILLER_0_82_248 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_63_440 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XTAP_TAPCELL_ROW_11_402 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_36_643 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
X_10584_ _04143_ _04245_ VGND VGND VPWR VPWR _04351_ sky130_fd_sc_hd__nand2_1
XFILLER_0_35_164 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_121_523 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_106_597 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_121_589 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_11205_ _04883_ _01355_ _01500_ VGND VGND VPWR VPWR _05024_ sky130_fd_sc_hd__and3_1
X_11136_ _04876_ _04947_ _04948_ VGND VGND VPWR VPWR _04949_ sky130_fd_sc_hd__nor3_1
X_11067_ _00754_ _04040_ _04873_ _00614_ VGND VGND VPWR VPWR _04874_ sky130_fd_sc_hd__a22o_1
X_10018_ _03730_ _03731_ _03718_ VGND VGND VPWR VPWR _03733_ sky130_fd_sc_hd__a21oi_2
XTAP_TAPCELL_ROW_19_502 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_47_844 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_47_855 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_86_510 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_0_25_55 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_25_77 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_0_25_99 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_86_587 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_73_215 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XTAP_TAPCELL_ROW_63_1046 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_46_418 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XFILLER_0_116_306 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
X_07160_ _00611_ VGND VGND VPWR VPWR _00612_ sky130_fd_sc_hd__clkbuf_4
XFILLER_0_81_281 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
X_07091_ _00535_ _00536_ VGND VGND VPWR VPWR _00538_ sky130_fd_sc_hd__xor2_1
XFILLER_0_26_175 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
X_06111_ _03649_ VGND VGND VPWR VPWR _04781_ sky130_fd_sc_hd__buf_4
XFILLER_0_74_7 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_06042_ _03070_ _03157_ VGND VGND VPWR VPWR _04031_ sky130_fd_sc_hd__or2b_1
XFILLER_0_1_231 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XFILLER_0_112_589 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
X_09801_ _03488_ _03494_ _03495_ VGND VGND VPWR VPWR _03497_ sky130_fd_sc_hd__nand3_2
XTAP_TAPCELL_ROW_74_1186 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
X_09732_ _03181_ _03305_ _03306_ VGND VGND VPWR VPWR _03421_ sky130_fd_sc_hd__and3_1
XFILLER_0_66_62 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_10_598 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
X_07993_ _01506_ _01507_ _01520_ _01521_ VGND VGND VPWR VPWR _01522_ sky130_fd_sc_hd__a211oi_2
X_06944_ _00374_ _00375_ _00278_ _00342_ VGND VGND VPWR VPWR _00377_ sky130_fd_sc_hd__o211a_1
X_09663_ _00034_ _01606_ _03344_ _03345_ VGND VGND VPWR VPWR _03346_ sky130_fd_sc_hd__a22o_1
X_06875_ _03310_ _03365_ _00195_ _00301_ VGND VGND VPWR VPWR _00302_ sky130_fd_sc_hd__nand4_1
X_09594_ _03267_ _03268_ _03257_ VGND VGND VPWR VPWR _03270_ sky130_fd_sc_hd__a21oi_2
X_05826_ _00362_ _01662_ VGND VGND VPWR VPWR _01672_ sky130_fd_sc_hd__nand2_1
X_08614_ _02158_ _02001_ _02199_ _02200_ VGND VGND VPWR VPWR _02201_ sky130_fd_sc_hd__o211ai_2
XFILLER_0_49_223 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
X_08545_ _01960_ _01962_ _02123_ _02124_ VGND VGND VPWR VPWR _02125_ sky130_fd_sc_hd__a211o_1
XFILLER_0_119_111 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_77_554 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
X_05757_ _00439_ _00690_ _00592_ _00570_ _00908_ VGND VGND VPWR VPWR _00919_ sky130_fd_sc_hd__a32o_1
XFILLER_0_77_598 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
X_08476_ _02034_ _01863_ _02047_ VGND VGND VPWR VPWR _02049_ sky130_fd_sc_hd__a21oi_1
XFILLER_0_49_278 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XFILLER_0_119_177 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_64_237 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
X_07427_ _00738_ _00903_ VGND VGND VPWR VPWR _00904_ sky130_fd_sc_hd__xnor2_1
XFILLER_0_17_120 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_92_579 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_80_719 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_18_676 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
X_07358_ _01039_ _00558_ VGND VGND VPWR VPWR _00829_ sky130_fd_sc_hd__nand2_1
X_06309_ _05403_ _05404_ _05439_ _05440_ VGND VGND VPWR VPWR _05441_ sky130_fd_sc_hd__nor4_1
X_07289_ net16 VGND VGND VPWR VPWR _00753_ sky130_fd_sc_hd__buf_4
XFILLER_0_60_465 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_33_668 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
X_09028_ _02468_ _02476_ _02475_ VGND VGND VPWR VPWR _02652_ sky130_fd_sc_hd__a21bo_1
XFILLER_0_32_167 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_68_521 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XTAP_TAPCELL_ROW_44_814 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_68_565 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XFILLER_0_68_554 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XFILLER_0_28_407 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
X_10705_ _04457_ _04393_ _04479_ _04480_ VGND VGND VPWR VPWR _04481_ sky130_fd_sc_hd__o211ai_4
XFILLER_0_83_568 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XTAP_TAPCELL_ROW_24_560 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
X_10636_ _04405_ _04406_ VGND VGND VPWR VPWR _04407_ sky130_fd_sc_hd__xnor2_1
XFILLER_0_102_37 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_102_15 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_102_59 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_11_57 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
X_10567_ _04295_ _04330_ _04331_ VGND VGND VPWR VPWR _04332_ sky130_fd_sc_hd__or3_2
XFILLER_0_106_383 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
X_10498_ _04166_ _04182_ VGND VGND VPWR VPWR _04256_ sky130_fd_sc_hd__nor2_1
XFILLER_0_23_167 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
X_11119_ _02838_ _03675_ _04842_ _04841_ VGND VGND VPWR VPWR _04931_ sky130_fd_sc_hd__a31oi_2
Xinput6 mcand[14] VGND VGND VPWR VPWR net6 sky130_fd_sc_hd__buf_4
XFILLER_0_78_307 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
X_06660_ _00340_ _05686_ _00087_ _00319_ VGND VGND VPWR VPWR _00088_ sky130_fd_sc_hd__a22oi_2
X_06591_ _05633_ _00018_ _00019_ VGND VGND VPWR VPWR _00020_ sky130_fd_sc_hd__nor3_2
XFILLER_0_59_598 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
X_08330_ _01887_ _01888_ _01867_ VGND VGND VPWR VPWR _01890_ sky130_fd_sc_hd__o21a_1
XFILLER_0_19_429 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_0_46_215 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XTAP_TAPCELL_ROW_121_1769 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
X_08261_ _01625_ _01634_ _01633_ VGND VGND VPWR VPWR _01816_ sky130_fd_sc_hd__a21bo_1
XFILLER_0_46_259 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_117_648 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_62_719 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_6_334 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_07212_ _00653_ _00654_ _00669_ VGND VGND VPWR VPWR _00670_ sky130_fd_sc_hd__o21a_2
XFILLER_0_116_169 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_0_104_309 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_42_421 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
X_08192_ _00802_ _00033_ _01736_ _01737_ VGND VGND VPWR VPWR _01740_ sky130_fd_sc_hd__nand4_2
XTAP_TAPCELL_ROW_76_1215 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
X_07143_ _00455_ _00457_ VGND VGND VPWR VPWR _00595_ sky130_fd_sc_hd__or2b_1
X_07074_ _00404_ _00405_ _00446_ _00447_ VGND VGND VPWR VPWR _00519_ sky130_fd_sc_hd__nor4_1
XFILLER_0_65_3 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
X_06025_ _03310_ _03321_ _03834_ _03343_ VGND VGND VPWR VPWR _03845_ sky130_fd_sc_hd__nand4_2
XFILLER_0_100_548 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
X_07976_ _00384_ _00406_ _01355_ _01500_ VGND VGND VPWR VPWR _01503_ sky130_fd_sc_hd__and4_4
X_09715_ _03026_ _04552_ _03030_ _02868_ VGND VGND VPWR VPWR _03402_ sky130_fd_sc_hd__nand4_1
X_06927_ _00353_ _00357_ VGND VGND VPWR VPWR _00358_ sky130_fd_sc_hd__xnor2_4
XTAP_TAPCELL_ROW_87_1344 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
X_09646_ _02302_ _00751_ VGND VGND VPWR VPWR _03327_ sky130_fd_sc_hd__nand2_1
XFILLER_0_96_126 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XTAP_TAPCELL_ROW_87_1355 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_2_288 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
X_06858_ _03583_ _00283_ _00182_ _00181_ VGND VGND VPWR VPWR _00284_ sky130_fd_sc_hd__a31o_1
X_09577_ _04748_ _01849_ _03093_ _03250_ VGND VGND VPWR VPWR _03251_ sky130_fd_sc_hd__a31o_2
XFILLER_0_77_351 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
X_05809_ _00854_ VGND VGND VPWR VPWR _01486_ sky130_fd_sc_hd__clkbuf_4
X_06789_ _00213_ _00214_ _00109_ net149 VGND VGND VPWR VPWR _00216_ sky130_fd_sc_hd__a211o_1
X_08528_ _05467_ _01582_ _01945_ _01944_ _02105_ VGND VGND VPWR VPWR _02106_ sky130_fd_sc_hd__a32o_1
XFILLER_0_38_716 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
X_08459_ _01892_ _01894_ VGND VGND VPWR VPWR _02030_ sky130_fd_sc_hd__or2_2
XPHY_EDGE_ROW_14_Right_14 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XTAP_TAPCELL_ROW_21_530 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_18_484 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
X_10421_ _00152_ _00237_ _03341_ _02174_ VGND VGND VPWR VPWR _04173_ sky130_fd_sc_hd__and4_1
X_10352_ _03985_ _03986_ VGND VGND VPWR VPWR _04098_ sky130_fd_sc_hd__and2b_1
XTAP_TAPCELL_ROW_98_1484 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
X_10283_ _03978_ _03979_ _04019_ _04021_ VGND VGND VPWR VPWR _04023_ sky130_fd_sc_hd__o22ai_2
XPHY_EDGE_ROW_23_Right_23 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XTAP_TAPCELL_ROW_29_630 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_57_972 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_87_148 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_96_693 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_0_56_513 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XPHY_EDGE_ROW_32_Right_32 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XTAP_TAPCELL_ROW_60_1016 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_113_69 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_71_505 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_0_24_421 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_36_281 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_0_98_27 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
X_10619_ _04385_ _04386_ _04381_ _04382_ VGND VGND VPWR VPWR _04388_ sky130_fd_sc_hd__a211o_1
XFILLER_0_3_337 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_24_498 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_20_671 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XPHY_EDGE_ROW_41_Right_41 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XPHY_EDGE_ROW_102_Left_224 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XTAP_TAPCELL_ROW_71_1145 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
X_07830_ _01342_ _01343_ VGND VGND VPWR VPWR _01344_ sky130_fd_sc_hd__or2_2
X_07761_ _02699_ _02208_ net43 net45 VGND VGND VPWR VPWR _01270_ sky130_fd_sc_hd__and4_1
X_09500_ _03043_ VGND VGND VPWR VPWR _03167_ sky130_fd_sc_hd__inv_2
X_06712_ net8 VGND VGND VPWR VPWR _00139_ sky130_fd_sc_hd__buf_4
X_07692_ _01044_ _01193_ VGND VGND VPWR VPWR _01194_ sky130_fd_sc_hd__xnor2_2
X_09431_ _04748_ _02041_ _02923_ _02922_ _01354_ VGND VGND VPWR VPWR _03092_ sky130_fd_sc_hd__a32o_2
XPHY_EDGE_ROW_50_Right_50 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_0_2_77 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
X_06643_ _05665_ _05667_ _00069_ _00070_ VGND VGND VPWR VPWR _00071_ sky130_fd_sc_hd__a211oi_2
XPHY_EDGE_ROW_111_Left_233 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_0_93_118 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
X_09362_ _00269_ _02516_ _03013_ _03014_ VGND VGND VPWR VPWR _03017_ sky130_fd_sc_hd__and4_2
X_06574_ _05691_ _00001_ _00002_ VGND VGND VPWR VPWR _00003_ sky130_fd_sc_hd__nand3_1
X_08313_ _04889_ net16 _01718_ _01717_ _00495_ VGND VGND VPWR VPWR _01872_ sky130_fd_sc_hd__a32o_1
XTAP_TAPCELL_ROW_35_699 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_47_535 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XANTENNA_11 _02051_ VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XTAP_TAPCELL_ROW_82_1285 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
X_09293_ _00802_ _00894_ _02061_ _00408_ VGND VGND VPWR VPWR _02942_ sky130_fd_sc_hd__a22o_1
XANTENNA_22 _05467_ VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_0_62_549 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_0_55_590 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XANTENNA_55 net18 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_0_7_665 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_0_6_153 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XANTENNA_44 net120 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XANTENNA_33 net92 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
X_08244_ _00963_ _01607_ _01114_ net51 VGND VGND VPWR VPWR _01797_ sky130_fd_sc_hd__and4_1
XFILLER_0_104_106 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
X_08175_ _01719_ _01720_ VGND VGND VPWR VPWR _01721_ sky130_fd_sc_hd__xor2_2
X_07126_ _00427_ _00437_ _00436_ VGND VGND VPWR VPWR _00576_ sky130_fd_sc_hd__a21bo_1
XPHY_EDGE_ROW_120_Left_242 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_0_113_673 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_100_334 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
X_07057_ _00363_ _00365_ VGND VGND VPWR VPWR _00500_ sky130_fd_sc_hd__or2_1
XFILLER_0_11_671 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XTAP_TAPCELL_ROW_7_347 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
X_06008_ _00854_ net58 _02699_ _03649_ VGND VGND VPWR VPWR _03660_ sky130_fd_sc_hd__and4_1
X_07959_ _01328_ _01484_ VGND VGND VPWR VPWR _01485_ sky130_fd_sc_hd__xnor2_2
X_10970_ _04685_ _04687_ _04767_ _04768_ VGND VGND VPWR VPWR _04769_ sky130_fd_sc_hd__a211o_1
XFILLER_0_85_608 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_09629_ _03305_ _03306_ _03181_ VGND VGND VPWR VPWR _03308_ sky130_fd_sc_hd__a21o_1
XTAP_TAPCELL_ROW_54_931 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_97_479 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XTAP_TAPCELL_ROW_54_942 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_93_641 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_65_310 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_0_93_685 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_53_505 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_26_719 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_108_467 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_80_335 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
X_11453_ _05287_ VGND VGND VPWR VPWR net128 sky130_fd_sc_hd__clkbuf_1
X_10404_ _02641_ _03030_ _02868_ _02108_ VGND VGND VPWR VPWR _04154_ sky130_fd_sc_hd__a22o_1
X_11384_ _05215_ _05216_ VGND VGND VPWR VPWR _05217_ sky130_fd_sc_hd__xnor2_1
XFILLER_0_110_109 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_0_104_673 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_33_295 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
X_10335_ net161 _04077_ _03935_ VGND VGND VPWR VPWR _04079_ sky130_fd_sc_hd__o21ai_1
XFILLER_0_0_329 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
X_10266_ _03817_ _03819_ _04002_ _04003_ VGND VGND VPWR VPWR _04004_ sky130_fd_sc_hd__a211o_2
XFILLER_0_84_29 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
X_10197_ _05553_ _02705_ _02185_ _05464_ VGND VGND VPWR VPWR _03928_ sky130_fd_sc_hd__a22o_1
XTAP_TAPCELL_ROW_109_1620 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_88_446 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_76_608 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_29_546 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_84_652 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
X_06290_ _01978_ net35 VGND VGND VPWR VPWR _05422_ sky130_fd_sc_hd__and2_1
XTAP_TAPCELL_ROW_32_658 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
Xinput20 mcand[27] VGND VGND VPWR VPWR net20 sky130_fd_sc_hd__buf_2
XFILLER_0_4_613 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
Xinput31 mcand[8] VGND VGND VPWR VPWR net31 sky130_fd_sc_hd__buf_4
XFILLER_0_71_379 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_0_12_413 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XFILLER_0_4_657 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
Xinput64 mplier[9] VGND VGND VPWR VPWR net64 sky130_fd_sc_hd__clkbuf_4
Xinput53 mplier[28] VGND VGND VPWR VPWR net53 sky130_fd_sc_hd__clkbuf_4
Xinput42 mplier[18] VGND VGND VPWR VPWR net42 sky130_fd_sc_hd__clkbuf_2
XFILLER_0_3_167 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
X_09980_ _05320_ _05388_ _03690_ _03171_ VGND VGND VPWR VPWR _03691_ sky130_fd_sc_hd__nand4_1
XFILLER_0_110_676 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
X_08931_ _02514_ _02545_ VGND VGND VPWR VPWR _02547_ sky130_fd_sc_hd__xnor2_4
X_08862_ _00038_ _00686_ _02104_ _05540_ VGND VGND VPWR VPWR _02471_ sky130_fd_sc_hd__a22o_1
XTAP_TAPCELL_ROW_4_306 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_4_317 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
X_07813_ _01176_ _01319_ VGND VGND VPWR VPWR _01326_ sky130_fd_sc_hd__nand2_1
X_08793_ _02221_ _02222_ VGND VGND VPWR VPWR _02397_ sky130_fd_sc_hd__nand2_1
XFILLER_0_74_95 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_0_28_3 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
X_07744_ _01249_ _05467_ _01246_ _01250_ VGND VGND VPWR VPWR _01251_ sky130_fd_sc_hd__a22oi_1
XTAP_TAPCELL_ROW_84_1314 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
X_07675_ _01031_ _01175_ VGND VGND VPWR VPWR net82 sky130_fd_sc_hd__xnor2_1
X_09414_ _02737_ _03072_ _03071_ _02740_ VGND VGND VPWR VPWR _03074_ sky130_fd_sc_hd__or4bb_2
X_06626_ _05674_ _05682_ _05681_ VGND VGND VPWR VPWR _00054_ sky130_fd_sc_hd__a21o_1
XFILLER_0_59_181 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XTAP_TAPCELL_ROW_51_901 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_47_310 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
X_09345_ _02981_ _02996_ _02997_ VGND VGND VPWR VPWR _02998_ sky130_fd_sc_hd__and3_2
X_06557_ _05425_ VGND VGND VPWR VPWR _05686_ sky130_fd_sc_hd__clkbuf_4
X_09276_ _00392_ _02036_ _01675_ _05676_ VGND VGND VPWR VPWR _02923_ sky130_fd_sc_hd__a22o_1
XFILLER_0_75_685 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
X_06488_ _05616_ _05617_ VGND VGND VPWR VPWR _05618_ sky130_fd_sc_hd__xor2_1
XFILLER_0_117_264 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_74_195 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_62_357 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
X_08227_ _01758_ _01776_ _01777_ VGND VGND VPWR VPWR _01778_ sky130_fd_sc_hd__nand3_4
XFILLER_0_99_81 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_0_90_699 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XTAP_TAPCELL_ROW_95_1454 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
X_08158_ _01690_ _01550_ _01700_ VGND VGND VPWR VPWR _01702_ sky130_fd_sc_hd__nor3_1
X_08089_ _00799_ _00548_ _01449_ net53 VGND VGND VPWR VPWR _01627_ sky130_fd_sc_hd__nand4_1
XFILLER_0_30_265 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
X_07109_ _01662_ _00556_ VGND VGND VPWR VPWR _00557_ sky130_fd_sc_hd__nand2_1
XFILLER_0_101_654 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
X_10120_ _03841_ _03842_ _03835_ VGND VGND VPWR VPWR _03844_ sky130_fd_sc_hd__a21o_1
X_10051_ _03762_ _03767_ _03768_ VGND VGND VPWR VPWR _03770_ sky130_fd_sc_hd__nand3_2
XFILLER_0_100_197 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
X_10953_ _03574_ _02236_ _04667_ _04750_ VGND VGND VPWR VPWR _04751_ sky130_fd_sc_hd__a31o_1
XFILLER_0_97_221 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
X_10884_ _04507_ _04510_ _04610_ _04611_ VGND VGND VPWR VPWR _04676_ sky130_fd_sc_hd__a211oi_1
XTAP_TAPCELL_ROW_104_1561 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_38_365 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XFILLER_0_19_590 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_110_15 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
X_11436_ _05249_ _05251_ VGND VGND VPWR VPWR _05272_ sky130_fd_sc_hd__and2_1
XFILLER_0_111_418 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
X_11367_ _04800_ _05022_ _05158_ _05157_ _01501_ VGND VGND VPWR VPWR _05198_ sky130_fd_sc_hd__a32o_1
XFILLER_0_0_126 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XFILLER_0_1_649 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
X_10318_ _03323_ _02667_ _00914_ _02843_ VGND VGND VPWR VPWR _04060_ sky130_fd_sc_hd__nand4_4
X_11298_ _05066_ _05068_ VGND VGND VPWR VPWR _05124_ sky130_fd_sc_hd__nor2_1
XFILLER_0_119_57 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
X_10249_ _03983_ _03984_ VGND VGND VPWR VPWR _03985_ sky130_fd_sc_hd__or2_1
X_05790_ _01258_ _01269_ _00439_ _00406_ VGND VGND VPWR VPWR _01280_ sky130_fd_sc_hd__and4bb_1
XFILLER_0_88_221 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XTAP_TAPCELL_ROW_37_728 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
X_07460_ _00937_ _00938_ _00939_ VGND VGND VPWR VPWR _00940_ sky130_fd_sc_hd__nand3_2
XFILLER_0_44_98 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_0_91_419 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
X_06411_ _05540_ VGND VGND VPWR VPWR _05541_ sky130_fd_sc_hd__buf_4
XTAP_TAPCELL_ROW_66_1088 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
X_07391_ _00862_ _00863_ _00743_ VGND VGND VPWR VPWR _00866_ sky130_fd_sc_hd__a21o_1
XTAP_TAPCELL_ROW_17_474 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
X_09130_ _02761_ _02762_ VGND VGND VPWR VPWR _02763_ sky130_fd_sc_hd__xor2_1
X_06342_ _00504_ _05311_ _05471_ _05472_ VGND VGND VPWR VPWR _05473_ sky130_fd_sc_hd__a22oi_2
XFILLER_0_115_713 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_72_666 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_60_75 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_09061_ _02518_ _02519_ VGND VGND VPWR VPWR _02689_ sky130_fd_sc_hd__nand2_1
X_08012_ _05419_ _00354_ VGND VGND VPWR VPWR _01543_ sky130_fd_sc_hd__nand2_1
XFILLER_0_4_421 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
X_06273_ _05329_ _05331_ VGND VGND VPWR VPWR _05405_ sky130_fd_sc_hd__or2_2
XFILLER_0_71_198 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_0_8_65 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_4_454 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
X_09963_ _03663_ _03672_ _03661_ VGND VGND VPWR VPWR _03673_ sky130_fd_sc_hd__o21ba_1
XPHY_EDGE_ROW_4_Right_4 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_0_0_671 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
X_08914_ _02065_ _01805_ net56 _00308_ VGND VGND VPWR VPWR _02528_ sky130_fd_sc_hd__a22o_1
X_09894_ _03595_ _03596_ _03562_ _03413_ VGND VGND VPWR VPWR _03598_ sky130_fd_sc_hd__a211o_1
XTAP_TAPCELL_ROW_90_1384 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_99_519 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_0_85_83 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
X_08845_ _00802_ _00609_ _01060_ _05689_ VGND VGND VPWR VPWR _02452_ sky130_fd_sc_hd__a22o_1
X_08776_ _02318_ _02377_ VGND VGND VPWR VPWR _02378_ sky130_fd_sc_hd__xnor2_4
XFILLER_0_79_243 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
X_07727_ _01075_ _01082_ _01081_ VGND VGND VPWR VPWR _01232_ sky130_fd_sc_hd__a21bo_1
X_05988_ _03397_ _03408_ _03419_ VGND VGND VPWR VPWR _03441_ sky130_fd_sc_hd__a21o_1
XFILLER_0_67_416 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_67_449 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
X_07658_ _01131_ _01132_ _01155_ VGND VGND VPWR VPWR _01157_ sky130_fd_sc_hd__o21ba_1
XFILLER_0_94_257 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_82_419 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
X_06609_ _00036_ VGND VGND VPWR VPWR _00037_ sky130_fd_sc_hd__inv_2
X_07589_ _01076_ _01079_ _01080_ VGND VGND VPWR VPWR _01081_ sky130_fd_sc_hd__nand3_1
X_09328_ _02975_ _02977_ _02971_ _02972_ VGND VGND VPWR VPWR _02979_ sky130_fd_sc_hd__a211o_1
XFILLER_0_106_713 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_0_62_121 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_0_35_335 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_47_184 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XFILLER_0_105_223 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
X_09259_ _02573_ _02728_ _02904_ VGND VGND VPWR VPWR _02905_ sky130_fd_sc_hd__a21boi_4
XFILLER_0_50_327 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_105_289 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_0_105_278 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
X_11221_ _05020_ _05040_ VGND VGND VPWR VPWR _05042_ sky130_fd_sc_hd__and2_1
XFILLER_0_43_390 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
X_11152_ _04901_ _04904_ VGND VGND VPWR VPWR _04967_ sky130_fd_sc_hd__or2_1
XFILLER_0_31_596 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
X_10103_ _02626_ _02813_ _03824_ _03825_ VGND VGND VPWR VPWR _03826_ sky130_fd_sc_hd__a22o_1
X_11083_ _04817_ _04819_ VGND VGND VPWR VPWR _04892_ sky130_fd_sc_hd__and2_1
X_10034_ _03749_ _03750_ VGND VGND VPWR VPWR _03751_ sky130_fd_sc_hd__xnor2_2
XFILLER_0_105_15 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_98_552 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_0_85_202 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
X_10936_ _04157_ VGND VGND VPWR VPWR _04732_ sky130_fd_sc_hd__clkbuf_4
XFILLER_0_58_427 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
X_10867_ _04573_ _04656_ VGND VGND VPWR VPWR _04657_ sky130_fd_sc_hd__nand2_1
XTAP_TAPCELL_ROW_14_433 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_39_685 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
X_10798_ _02812_ _03237_ _01853_ _01605_ VGND VGND VPWR VPWR _04582_ sky130_fd_sc_hd__a22o_1
XFILLER_0_54_633 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_0_53_110 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XFILLER_0_38_184 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XTAP_TAPCELL_ROW_42_786 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_14_519 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_0_30_45 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XTAP_TAPCELL_ROW_117_1730 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_41_349 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
X_11419_ _05252_ _05225_ _05227_ VGND VGND VPWR VPWR _05254_ sky130_fd_sc_hd__and3_1
XFILLER_0_111_204 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_1_479 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
X_06960_ _03834_ _03015_ _04074_ _05341_ VGND VGND VPWR VPWR _00394_ sky130_fd_sc_hd__nand4_1
XFILLER_0_39_76 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
X_06891_ _00280_ _00281_ _00317_ _00318_ VGND VGND VPWR VPWR _00320_ sky130_fd_sc_hd__or4_1
X_05911_ _02578_ _02589_ VGND VGND VPWR VPWR _02600_ sky130_fd_sc_hd__nor2_2
X_05842_ _01727_ _01738_ _01815_ VGND VGND VPWR VPWR _01847_ sky130_fd_sc_hd__o21ai_2
XFILLER_0_55_53 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_0_55_31 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
X_08630_ _02016_ _02029_ _02216_ _02217_ VGND VGND VPWR VPWR _02218_ sky130_fd_sc_hd__o211a_1
XTAP_TAPCELL_ROW_68_1117 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_68_1106 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_55_64 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
X_05773_ _00744_ _00788_ _01083_ VGND VGND VPWR VPWR _01094_ sky130_fd_sc_hd__a21o_1
X_08561_ _05308_ _01949_ _01441_ _04531_ VGND VGND VPWR VPWR _02143_ sky130_fd_sc_hd__a22o_1
XFILLER_0_89_585 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_0_76_224 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
X_08492_ _02058_ _02063_ _02066_ VGND VGND VPWR VPWR _02067_ sky130_fd_sc_hd__nand3_2
X_07512_ _00994_ _00995_ _00997_ VGND VGND VPWR VPWR _00998_ sky130_fd_sc_hd__nand3_1
XFILLER_0_71_52 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
X_07443_ _00920_ _00921_ _03605_ _00354_ VGND VGND VPWR VPWR _00922_ sky130_fd_sc_hd__and4bb_1
XFILLER_0_119_337 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_76_279 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_9_568 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
X_09113_ _00515_ _02230_ _02592_ _02591_ VGND VGND VPWR VPWR _02745_ sky130_fd_sc_hd__a31o_2
XFILLER_0_17_335 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
X_07374_ _00844_ _00845_ _00835_ VGND VGND VPWR VPWR _00847_ sky130_fd_sc_hd__a21o_1
X_06325_ _05401_ _05403_ _05391_ VGND VGND VPWR VPWR _05456_ sky130_fd_sc_hd__o21ai_2
XTAP_TAPCELL_ROW_79_1246 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_72_485 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
X_09044_ _02667_ _02668_ _02669_ VGND VGND VPWR VPWR _02670_ sky130_fd_sc_hd__a21bo_1
X_06256_ _05387_ VGND VGND VPWR VPWR _05388_ sky130_fd_sc_hd__clkbuf_8
XFILLER_0_4_251 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_32_316 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_32_327 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_4_262 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
Xmax_cap161 _04076_ VGND VGND VPWR VPWR net161 sky130_fd_sc_hd__buf_1
XTAP_TAPCELL_ROW_92_1413 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
X_06187_ _05319_ VGND VGND VPWR VPWR _05320_ sky130_fd_sc_hd__clkbuf_8
Xmax_cap150 net151 VGND VGND VPWR VPWR net150 sky130_fd_sc_hd__clkbuf_1
XFILLER_0_96_93 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
X_09946_ _03516_ _03519_ _03653_ _03654_ VGND VGND VPWR VPWR _03655_ sky130_fd_sc_hd__o211ai_4
X_09877_ _03567_ _03578_ VGND VGND VPWR VPWR _03579_ sky130_fd_sc_hd__xnor2_2
XPHY_EDGE_ROW_79_Right_79 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
X_08828_ _04737_ _01187_ _02430_ _02431_ VGND VGND VPWR VPWR _02433_ sky130_fd_sc_hd__nand4_2
XFILLER_0_95_500 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
X_08759_ _02357_ _02358_ _01039_ _02160_ VGND VGND VPWR VPWR _02359_ sky130_fd_sc_hd__and4bb_1
X_10721_ _04380_ _04388_ _04387_ VGND VGND VPWR VPWR _04499_ sky130_fd_sc_hd__a21o_1
XFILLER_0_83_717 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XTAP_TAPCELL_ROW_101_1520 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_82_205 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_10652_ _04421_ _04422_ _04416_ VGND VGND VPWR VPWR _04424_ sky130_fd_sc_hd__a21o_1
XTAP_TAPCELL_ROW_11_403 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
X_10583_ _04348_ _04349_ VGND VGND VPWR VPWR _04350_ sky130_fd_sc_hd__xnor2_4
XPHY_EDGE_ROW_88_Right_88 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_0_36_699 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_121_502 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
X_11204_ _03396_ _05022_ _04962_ _04961_ _01357_ VGND VGND VPWR VPWR _05023_ sky130_fd_sc_hd__a32o_1
XFILLER_0_31_393 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XTAP_TAPCELL_ROW_112_1660 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
X_11135_ _04505_ _04157_ _04945_ _04946_ VGND VGND VPWR VPWR _04948_ sky130_fd_sc_hd__and4_1
X_11066_ _04042_ VGND VGND VPWR VPWR _04873_ sky130_fd_sc_hd__clkbuf_4
X_10017_ _03718_ _03730_ _03731_ VGND VGND VPWR VPWR _03732_ sky130_fd_sc_hd__and3_2
XPHY_EDGE_ROW_97_Right_97 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XTAP_TAPCELL_ROW_19_503 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_47_845 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
X_10919_ _04711_ _04713_ VGND VGND VPWR VPWR _04714_ sky130_fd_sc_hd__xor2_2
XTAP_TAPCELL_ROW_63_1047 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_41_55 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_109_370 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_54_474 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XFILLER_0_26_187 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
X_07090_ _00393_ _00397_ _00394_ VGND VGND VPWR VPWR _00536_ sky130_fd_sc_hd__o21ai_1
XFILLER_0_41_113 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_41_124 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
X_06110_ _02197_ VGND VGND VPWR VPWR _04770_ sky130_fd_sc_hd__buf_4
XFILLER_0_41_135 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
X_06041_ _03987_ _03998_ _03485_ _03507_ VGND VGND VPWR VPWR _04020_ sky130_fd_sc_hd__a211oi_2
XFILLER_0_10_511 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_100_719 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
X_09800_ _01221_ _03489_ _03492_ _03493_ VGND VGND VPWR VPWR _03495_ sky130_fd_sc_hd__nand4_2
XTAP_TAPCELL_ROW_74_1187 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
X_07992_ _01509_ _01383_ _01518_ VGND VGND VPWR VPWR _01521_ sky130_fd_sc_hd__nor3_2
X_09731_ _03350_ _03351_ _03352_ VGND VGND VPWR VPWR _03420_ sky130_fd_sc_hd__and3_1
X_06943_ _00278_ _00342_ _00374_ _00375_ VGND VGND VPWR VPWR _00376_ sky130_fd_sc_hd__a211oi_2
XFILLER_0_5_55 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_66_85 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_0_66_74 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
X_09662_ _02640_ _02110_ _02812_ _02843_ VGND VGND VPWR VPWR _03345_ sky130_fd_sc_hd__nand4_2
X_06874_ net43 VGND VGND VPWR VPWR _00301_ sky130_fd_sc_hd__buf_2
X_09593_ _03257_ _03267_ _03268_ VGND VGND VPWR VPWR _03269_ sky130_fd_sc_hd__and3_2
X_05825_ _01651_ VGND VGND VPWR VPWR _01662_ sky130_fd_sc_hd__buf_4
X_08613_ _02196_ _02198_ _02172_ VGND VGND VPWR VPWR _02200_ sky130_fd_sc_hd__a21o_1
XFILLER_0_89_393 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_82_73 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_0_82_51 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
X_08544_ _02121_ _02122_ _02102_ VGND VGND VPWR VPWR _02124_ sky130_fd_sc_hd__a21oi_1
X_05756_ _00581_ VGND VGND VPWR VPWR _00908_ sky130_fd_sc_hd__clkbuf_4
XFILLER_0_10_3 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
X_08475_ _02034_ _01863_ _02047_ VGND VGND VPWR VPWR _02048_ sky130_fd_sc_hd__and3_1
X_07426_ _00901_ _00902_ VGND VGND VPWR VPWR _00903_ sky130_fd_sc_hd__nor2_2
XFILLER_0_17_110 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XFILLER_0_18_688 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
X_07357_ _00818_ _00827_ VGND VGND VPWR VPWR _00828_ sky130_fd_sc_hd__xor2_2
XFILLER_0_33_614 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
X_06308_ _05437_ _05438_ _05355_ _05357_ VGND VGND VPWR VPWR _05440_ sky130_fd_sc_hd__o211a_1
XFILLER_0_33_625 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
X_09027_ _02648_ _02649_ _02637_ VGND VGND VPWR VPWR _02651_ sky130_fd_sc_hd__a21o_1
X_07288_ _00746_ _00749_ _01760_ _00751_ VGND VGND VPWR VPWR _00752_ sky130_fd_sc_hd__and4b_1
XFILLER_0_60_477 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
X_06239_ _05294_ _05371_ VGND VGND VPWR VPWR _05372_ sky130_fd_sc_hd__nor2_1
XFILLER_0_13_393 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
X_09929_ _03633_ _03634_ _03623_ VGND VGND VPWR VPWR _03636_ sky130_fd_sc_hd__a21oi_1
XTAP_TAPCELL_ROW_44_815 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_28_419 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
X_10704_ _04460_ _04478_ VGND VGND VPWR VPWR _04480_ sky130_fd_sc_hd__nand2_2
XFILLER_0_83_558 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XTAP_TAPCELL_ROW_24_561 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
X_10635_ _02645_ _03247_ VGND VGND VPWR VPWR _04406_ sky130_fd_sc_hd__nand2_1
XFILLER_0_102_27 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_71_709 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_70_208 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_0_36_441 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_51_422 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_0_23_113 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_36_485 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
X_10566_ _04328_ _04329_ _04310_ VGND VGND VPWR VPWR _04331_ sky130_fd_sc_hd__o21a_1
XFILLER_0_106_362 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XFILLER_0_11_69 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_121_343 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
X_10497_ _04164_ _04165_ VGND VGND VPWR VPWR _04255_ sky130_fd_sc_hd__and2b_1
XFILLER_0_51_477 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_11118_ _04928_ _04929_ VGND VGND VPWR VPWR _04930_ sky130_fd_sc_hd__nand2_1
Xinput7 mcand[15] VGND VGND VPWR VPWR net7 sky130_fd_sc_hd__buf_2
X_11049_ _04783_ _04785_ _04854_ VGND VGND VPWR VPWR _04855_ sky130_fd_sc_hd__a21oi_1
X_06590_ _00016_ _00017_ _05612_ _05614_ VGND VGND VPWR VPWR _00019_ sky130_fd_sc_hd__a211oi_2
XFILLER_0_86_352 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_59_588 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
X_08260_ _01811_ _01812_ _01802_ VGND VGND VPWR VPWR _01814_ sky130_fd_sc_hd__a21o_1
X_07211_ _00660_ _00667_ VGND VGND VPWR VPWR _00669_ sky130_fd_sc_hd__xor2_1
X_08191_ _05585_ net9 _01736_ _01737_ VGND VGND VPWR VPWR _01739_ sky130_fd_sc_hd__a22o_1
XFILLER_0_116_148 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
X_07142_ _00479_ _00593_ VGND VGND VPWR VPWR _00594_ sky130_fd_sc_hd__xnor2_2
XFILLER_0_112_321 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XTAP_TAPCELL_ROW_76_1216 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
X_07073_ _00514_ _00516_ _00480_ VGND VGND VPWR VPWR _00518_ sky130_fd_sc_hd__o21a_1
XFILLER_0_14_168 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_112_365 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
X_06024_ net34 VGND VGND VPWR VPWR _03834_ sky130_fd_sc_hd__clkbuf_4
XFILLER_0_77_40 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XFILLER_0_58_3 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_0_77_84 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
X_07975_ _01192_ _01357_ _01501_ _01356_ VGND VGND VPWR VPWR _01502_ sky130_fd_sc_hd__a22oi_4
X_09714_ _04552_ _02529_ _02705_ _04531_ VGND VGND VPWR VPWR _03401_ sky130_fd_sc_hd__a22o_1
X_06926_ _00395_ _00356_ VGND VGND VPWR VPWR _00357_ sky130_fd_sc_hd__nand2_2
XFILLER_0_97_617 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XFILLER_0_97_606 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
X_09645_ _00496_ _03322_ _03325_ VGND VGND VPWR VPWR _03326_ sky130_fd_sc_hd__a21bo_1
X_06857_ _05589_ VGND VGND VPWR VPWR _00283_ sky130_fd_sc_hd__buf_4
XTAP_TAPCELL_ROW_87_1345 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
X_05808_ _00744_ _00788_ _01083_ VGND VGND VPWR VPWR _01476_ sky130_fd_sc_hd__a21oi_2
XTAP_TAPCELL_ROW_2_289 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_96_138 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
X_09576_ _03090_ _03092_ VGND VGND VPWR VPWR _03250_ sky130_fd_sc_hd__and2b_1
X_06788_ _00109_ net149 _00213_ _00214_ VGND VGND VPWR VPWR _00215_ sky130_fd_sc_hd__o211ai_4
XFILLER_0_65_503 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
X_05739_ _00701_ _00712_ _00439_ _00373_ VGND VGND VPWR VPWR _00723_ sky130_fd_sc_hd__and4b_1
X_08527_ _02104_ VGND VGND VPWR VPWR _02105_ sky130_fd_sc_hd__clkbuf_4
XFILLER_0_65_558 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
X_08458_ _01845_ _02016_ _02017_ VGND VGND VPWR VPWR _02029_ sky130_fd_sc_hd__nor3_2
XFILLER_0_37_238 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_0_65_569 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
X_07409_ _00731_ _00873_ _00883_ VGND VGND VPWR VPWR _00884_ sky130_fd_sc_hd__or3_1
XTAP_TAPCELL_ROW_21_520 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_107_159 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
X_10420_ _04169_ _04170_ VGND VGND VPWR VPWR _04171_ sky130_fd_sc_hd__xnor2_2
XFILLER_0_18_496 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_45_260 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
X_08389_ _01767_ _01768_ _01769_ VGND VGND VPWR VPWR _01954_ sky130_fd_sc_hd__a21bo_1
X_10351_ _04094_ _04095_ VGND VGND VPWR VPWR _04097_ sky130_fd_sc_hd__xnor2_2
XTAP_TAPCELL_ROW_98_1485 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_21_617 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_33_466 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_10282_ _03978_ _03979_ _04019_ _04021_ VGND VGND VPWR VPWR _04022_ sky130_fd_sc_hd__or4_4
XFILLER_0_14_691 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_13_190 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XTAP_TAPCELL_ROW_29_620 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_87_116 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XTAP_TAPCELL_ROW_57_973 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_29_717 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_0_113_15 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XTAP_TAPCELL_ROW_60_1006 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_83_344 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XTAP_TAPCELL_ROW_60_1017 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_71_539 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_107_671 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
X_10618_ _04381_ _04382_ _04385_ _04386_ VGND VGND VPWR VPWR _04387_ sky130_fd_sc_hd__o211a_1
XFILLER_0_24_433 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_0_24_455 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
X_10549_ _03574_ _02838_ _00896_ _01042_ _04213_ VGND VGND VPWR VPWR _04312_ sky130_fd_sc_hd__a41o_1
XFILLER_0_11_105 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_0_3_349 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_121_184 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_20_683 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XTAP_TAPCELL_ROW_71_1146 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
X_07760_ _02732_ _00301_ _00430_ _02197_ VGND VGND VPWR VPWR _01268_ sky130_fd_sc_hd__a22oi_1
XFILLER_0_79_617 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_06711_ _00035_ VGND VGND VPWR VPWR _00138_ sky130_fd_sc_hd__buf_6
X_09430_ _03088_ _03089_ VGND VGND VPWR VPWR _03090_ sky130_fd_sc_hd__xnor2_4
XFILLER_0_78_105 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_07691_ _01190_ _01191_ VGND VGND VPWR VPWR _01193_ sky130_fd_sc_hd__and2b_1
XFILLER_0_78_149 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
X_06642_ _00067_ _00068_ _00054_ VGND VGND VPWR VPWR _00070_ sky130_fd_sc_hd__a21oi_1
X_09361_ _04585_ _03012_ _03013_ _03014_ VGND VGND VPWR VPWR _03016_ sky130_fd_sc_hd__a22oi_2
X_06573_ _05698_ _05699_ _00000_ VGND VGND VPWR VPWR _00002_ sky130_fd_sc_hd__a21o_1
X_09292_ net19 VGND VGND VPWR VPWR _02941_ sky130_fd_sc_hd__buf_4
X_08312_ _04716_ _03616_ _00895_ _01041_ _01696_ VGND VGND VPWR VPWR _01871_ sky130_fd_sc_hd__a41o_1
XFILLER_0_47_547 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XANTENNA_12 _02178_ VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XTAP_TAPCELL_ROW_82_1286 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XANTENNA_23 _05467_ VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
X_08243_ _00330_ _01114_ _01284_ _01007_ VGND VGND VPWR VPWR _01796_ sky130_fd_sc_hd__a22oi_2
XFILLER_0_117_446 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XANTENNA_56 net18 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_0_6_121 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XANTENNA_34 net98 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XANTENNA_45 _00428_ VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_0_104_118 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
X_08174_ _04889_ _00750_ VGND VGND VPWR VPWR _01720_ sky130_fd_sc_hd__nand2_1
XFILLER_0_6_165 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_70_561 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_15_477 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
X_07125_ _00572_ _00573_ _00563_ VGND VGND VPWR VPWR _00575_ sky130_fd_sc_hd__a21o_1
XFILLER_0_30_403 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
X_07056_ _00361_ _00369_ VGND VGND VPWR VPWR _00499_ sky130_fd_sc_hd__nand2_1
XFILLER_0_113_685 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_88_83 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
X_06007_ net30 VGND VGND VPWR VPWR _03649_ sky130_fd_sc_hd__buf_4
XFILLER_0_100_346 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XTAP_TAPCELL_ROW_7_348 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
X_07958_ _01482_ _01483_ VGND VGND VPWR VPWR _01484_ sky130_fd_sc_hd__nor2_1
X_06909_ _00232_ _00233_ _00255_ _00256_ VGND VGND VPWR VPWR _00338_ sky130_fd_sc_hd__o211ai_2
X_07889_ _01266_ _01274_ VGND VGND VPWR VPWR _01409_ sky130_fd_sc_hd__nand2_1
X_09628_ _03181_ _03305_ _03306_ VGND VGND VPWR VPWR _03307_ sky130_fd_sc_hd__nand3_1
X_09559_ _03230_ VGND VGND VPWR VPWR _03231_ sky130_fd_sc_hd__inv_2
XTAP_TAPCELL_ROW_54_943 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_54_932 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_77_182 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_65_333 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_0_93_653 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_92_141 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_92_130 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_93_697 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_80_314 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XFILLER_0_65_399 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XFILLER_0_53_517 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
X_11452_ _04368_ _04412_ _05286_ VGND VGND VPWR VPWR _05287_ sky130_fd_sc_hd__and3b_1
X_10403_ _05468_ _04042_ VGND VGND VPWR VPWR _04153_ sky130_fd_sc_hd__nand2_2
X_11383_ _05168_ _05172_ _05169_ VGND VGND VPWR VPWR _05216_ sky130_fd_sc_hd__o21ba_1
XFILLER_0_61_561 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
X_10334_ _03935_ net161 _04077_ VGND VGND VPWR VPWR _04078_ sky130_fd_sc_hd__or3_1
XFILLER_0_103_151 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_104_685 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
X_10265_ _02134_ _02064_ _04000_ _04001_ VGND VGND VPWR VPWR _04003_ sky130_fd_sc_hd__and4_1
X_10196_ _03858_ _03859_ _03899_ _03901_ VGND VGND VPWR VPWR _03927_ sky130_fd_sc_hd__and4_1
XFILLER_0_108_15 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XTAP_TAPCELL_ROW_109_1621 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_17_57 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_29_503 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_56_322 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_84_664 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_17_709 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_29_558 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XTAP_TAPCELL_ROW_32_659 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
Xinput10 mcand[18] VGND VGND VPWR VPWR net10 sky130_fd_sc_hd__buf_4
Xinput21 mcand[28] VGND VGND VPWR VPWR net21 sky130_fd_sc_hd__clkbuf_2
XFILLER_0_4_625 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_24_230 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
Xinput43 mplier[19] VGND VGND VPWR VPWR net43 sky130_fd_sc_hd__buf_4
Xinput32 mcand[9] VGND VGND VPWR VPWR net32 sky130_fd_sc_hd__clkbuf_2
XFILLER_0_52_572 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_52_561 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_3_113 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
Xinput54 mplier[29] VGND VGND VPWR VPWR net54 sky130_fd_sc_hd__dlymetal6s2s_1
XFILLER_0_24_241 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_40_701 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_0_4_669 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
X_08930_ _02542_ _02544_ VGND VGND VPWR VPWR _02545_ sky130_fd_sc_hd__xnor2_4
XFILLER_0_110_688 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
X_08861_ _05467_ _02105_ _02323_ _02322_ _02321_ VGND VGND VPWR VPWR _02470_ sky130_fd_sc_hd__a32o_1
XTAP_TAPCELL_ROW_4_318 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_4_307 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
X_07812_ _01176_ _01319_ VGND VGND VPWR VPWR _01325_ sky130_fd_sc_hd__nor2_1
XFILLER_0_74_41 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
X_08792_ _02224_ _02225_ _02024_ _02025_ VGND VGND VPWR VPWR _02396_ sky130_fd_sc_hd__a211oi_1
XFILLER_0_74_85 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
X_07743_ _01245_ VGND VGND VPWR VPWR _01250_ sky130_fd_sc_hd__inv_2
XTAP_TAPCELL_ROW_84_1315 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
X_07674_ _01032_ _01174_ VGND VGND VPWR VPWR _01175_ sky130_fd_sc_hd__xnor2_1
X_09413_ _02910_ _03071_ _03072_ VGND VGND VPWR VPWR _03073_ sky130_fd_sc_hd__a21oi_1
X_06625_ _05643_ _00052_ VGND VGND VPWR VPWR _00053_ sky130_fd_sc_hd__xor2_1
XTAP_TAPCELL_ROW_51_902 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
X_09344_ _02992_ _02994_ _02995_ VGND VGND VPWR VPWR _02997_ sky130_fd_sc_hd__a21o_1
X_06556_ _00308_ _02065_ _05345_ _05425_ VGND VGND VPWR VPWR _05685_ sky130_fd_sc_hd__and4_1
XFILLER_0_90_634 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
X_09275_ _05676_ _00392_ _01499_ VGND VGND VPWR VPWR _02922_ sky130_fd_sc_hd__and3_1
XFILLER_0_75_697 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_7_430 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
X_06487_ _05458_ _05521_ _05520_ VGND VGND VPWR VPWR _05617_ sky130_fd_sc_hd__a21bo_1
XFILLER_0_117_276 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_0_90_645 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_62_336 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XFILLER_0_28_580 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
X_08226_ _01774_ _01775_ _01766_ VGND VGND VPWR VPWR _01777_ sky130_fd_sc_hd__a21o_1
XFILLER_0_105_449 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_50_509 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XFILLER_0_43_561 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
X_08157_ _01690_ _01550_ _01700_ VGND VGND VPWR VPWR _01701_ sky130_fd_sc_hd__o21a_2
XTAP_TAPCELL_ROW_95_1455 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_95_1444 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_30_222 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
X_07108_ _05693_ VGND VGND VPWR VPWR _00556_ sky130_fd_sc_hd__clkbuf_4
X_08088_ _01978_ _01284_ VGND VGND VPWR VPWR _01626_ sky130_fd_sc_hd__and2_1
X_07039_ _00371_ _00374_ VGND VGND VPWR VPWR _00480_ sky130_fd_sc_hd__nor2_1
X_10050_ _03765_ _03766_ _03564_ _03566_ VGND VGND VPWR VPWR _03768_ sky130_fd_sc_hd__o211ai_2
XFILLER_0_100_154 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_0_98_701 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
X_10952_ _04665_ _04666_ VGND VGND VPWR VPWR _04750_ sky130_fd_sc_hd__and2b_1
X_10883_ _04673_ _04674_ VGND VGND VPWR VPWR _04675_ sky130_fd_sc_hd__xor2_1
XTAP_TAPCELL_ROW_104_1562 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_93_461 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XFILLER_0_22_701 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
X_11435_ _05269_ _05270_ VGND VGND VPWR VPWR _05271_ sky130_fd_sc_hd__and2b_1
XFILLER_0_110_27 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_1_617 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_34_583 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
X_11366_ _05195_ _05196_ VGND VGND VPWR VPWR _05197_ sky130_fd_sc_hd__or2_1
XFILLER_0_104_493 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
X_10317_ _02667_ _00748_ _02843_ _00747_ VGND VGND VPWR VPWR _04059_ sky130_fd_sc_hd__a22o_1
X_11297_ _05121_ _05122_ VGND VGND VPWR VPWR _05123_ sky130_fd_sc_hd__xnor2_1
XFILLER_0_0_138 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XFILLER_0_21_277 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
X_10248_ _03981_ _03982_ _01580_ net22 VGND VGND VPWR VPWR _03984_ sky130_fd_sc_hd__and4bb_1
XFILLER_0_119_69 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
X_10179_ _03906_ _03907_ _03787_ _03789_ VGND VGND VPWR VPWR _03909_ sky130_fd_sc_hd__a211o_1
XTAP_TAPCELL_ROW_37_729 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_44_33 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_76_406 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_88_288 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_69_491 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
X_06410_ _05539_ VGND VGND VPWR VPWR _05540_ sky130_fd_sc_hd__buf_4
XFILLER_0_9_717 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XTAP_TAPCELL_ROW_66_1089 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_57_642 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_0_56_141 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
X_07390_ _00743_ _00862_ _00863_ VGND VGND VPWR VPWR _00864_ sky130_fd_sc_hd__nand3_4
XTAP_TAPCELL_ROW_17_475 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
X_06341_ _04705_ _01552_ _05304_ _05305_ VGND VGND VPWR VPWR _05472_ sky130_fd_sc_hd__nand4_1
XFILLER_0_71_111 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
X_09060_ _02685_ _02686_ VGND VGND VPWR VPWR _02687_ sky130_fd_sc_hd__and2_2
XFILLER_0_56_185 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_06272_ _05401_ _05402_ _05383_ _05384_ VGND VGND VPWR VPWR _05404_ sky130_fd_sc_hd__o211a_1
XFILLER_0_44_325 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_0_72_678 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
X_08011_ _01539_ _01540_ VGND VGND VPWR VPWR _01542_ sky130_fd_sc_hd__and2_1
XFILLER_0_114_257 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_71_177 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_4_466 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_102_419 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_8_77 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_0_4_477 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
X_09962_ _03663_ _03672_ VGND VGND VPWR VPWR net99 sky130_fd_sc_hd__xor2_2
XFILLER_0_12_288 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XFILLER_0_12_277 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
X_08913_ _01651_ _02177_ VGND VGND VPWR VPWR _02527_ sky130_fd_sc_hd__and2_1
X_09893_ _03562_ _03413_ _03595_ _03596_ VGND VGND VPWR VPWR _03597_ sky130_fd_sc_hd__o211ai_1
XTAP_TAPCELL_ROW_90_1385 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_85_51 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_0_40_3 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_85_95 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_08844_ _05689_ _00802_ _01060_ VGND VGND VPWR VPWR _02451_ sky130_fd_sc_hd__and3_1
X_08775_ _02375_ _02376_ VGND VGND VPWR VPWR _02377_ sky130_fd_sc_hd__xnor2_4
X_05987_ _03397_ _03408_ _03419_ VGND VGND VPWR VPWR _03430_ sky130_fd_sc_hd__nand3_1
X_07726_ _01228_ _01229_ _01220_ VGND VGND VPWR VPWR _01231_ sky130_fd_sc_hd__a21o_1
XFILLER_0_94_214 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
X_07657_ _01131_ _01132_ _01155_ VGND VGND VPWR VPWR _01156_ sky130_fd_sc_hd__nor3b_2
X_06608_ _00679_ _00351_ _00035_ _05635_ VGND VGND VPWR VPWR _00036_ sky130_fd_sc_hd__and4_1
X_07588_ _05419_ _00143_ _01077_ _01078_ VGND VGND VPWR VPWR _01080_ sky130_fd_sc_hd__a22o_1
X_09327_ _02971_ _02972_ _02975_ _02977_ VGND VGND VPWR VPWR _02978_ sky130_fd_sc_hd__o211a_1
XFILLER_0_63_612 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
X_06539_ _05665_ _05666_ _05658_ VGND VGND VPWR VPWR _05668_ sky130_fd_sc_hd__a21o_1
XFILLER_0_47_163 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
X_09258_ _02727_ _02725_ VGND VGND VPWR VPWR _02904_ sky130_fd_sc_hd__or2b_1
X_09189_ _02825_ _02826_ _02810_ VGND VGND VPWR VPWR _02828_ sky130_fd_sc_hd__a21oi_1
X_08209_ _01608_ _01616_ _01615_ VGND VGND VPWR VPWR _01758_ sky130_fd_sc_hd__a21o_1
XFILLER_0_120_216 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
X_11220_ _05038_ _05039_ VGND VGND VPWR VPWR _05040_ sky130_fd_sc_hd__xor2_1
XFILLER_0_31_542 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
X_11151_ _04963_ _04964_ VGND VGND VPWR VPWR _04966_ sky130_fd_sc_hd__xnor2_1
X_10102_ _00151_ _02459_ _02843_ _01800_ VGND VGND VPWR VPWR _03825_ sky130_fd_sc_hd__nand4_1
X_11082_ _04888_ _04890_ VGND VGND VPWR VPWR _04891_ sky130_fd_sc_hd__nand2_1
X_10033_ _03608_ _03610_ VGND VGND VPWR VPWR _03750_ sky130_fd_sc_hd__or2_2
XFILLER_0_98_531 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_105_27 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_98_586 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
X_10935_ _02864_ _04729_ _04730_ VGND VGND VPWR VPWR _04731_ sky130_fd_sc_hd__a21bo_1
XFILLER_0_85_225 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
X_10866_ _04655_ VGND VGND VPWR VPWR _04656_ sky130_fd_sc_hd__inv_2
XFILLER_0_85_269 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XTAP_TAPCELL_ROW_14_434 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_26_303 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
X_10797_ _01605_ _02812_ _01853_ VGND VGND VPWR VPWR _04581_ sky130_fd_sc_hd__and3_1
XTAP_TAPCELL_ROW_42_787 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_121_37 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XTAP_TAPCELL_ROW_117_1720 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
X_11418_ _05225_ _05227_ _05252_ VGND VGND VPWR VPWR _05253_ sky130_fd_sc_hd__a21oi_2
XFILLER_0_111_216 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_22_531 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_1_447 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
X_11349_ _05091_ _05142_ VGND VGND VPWR VPWR _05179_ sky130_fd_sc_hd__and2_1
X_05910_ _02557_ _02568_ _00493_ _01651_ VGND VGND VPWR VPWR _02589_ sky130_fd_sc_hd__and4bb_1
X_06890_ _00315_ _00316_ _00207_ _00282_ VGND VGND VPWR VPWR _00318_ sky130_fd_sc_hd__o211a_1
X_05841_ _01826_ VGND VGND VPWR VPWR _01837_ sky130_fd_sc_hd__inv_2
XTAP_TAPCELL_ROW_68_1118 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_68_1107 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_55_76 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_77_715 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
X_08560_ _00830_ VGND VGND VPWR VPWR _02141_ sky130_fd_sc_hd__buf_4
X_05772_ _00952_ _01072_ VGND VGND VPWR VPWR _01083_ sky130_fd_sc_hd__xnor2_2
X_08491_ _04716_ _02064_ _02059_ _02062_ VGND VGND VPWR VPWR _02066_ sky130_fd_sc_hd__nand4_2
X_07511_ _00836_ _00839_ _00838_ VGND VGND VPWR VPWR _00997_ sky130_fd_sc_hd__a21bo_1
X_07442_ _05327_ _00150_ _00349_ _03780_ VGND VGND VPWR VPWR _00921_ sky130_fd_sc_hd__a22oi_1
X_07373_ _00835_ _00844_ _00845_ VGND VGND VPWR VPWR _00846_ sky130_fd_sc_hd__nand3_2
X_09112_ _02570_ _02733_ _02743_ VGND VGND VPWR VPWR _02744_ sky130_fd_sc_hd__a21oi_4
X_06324_ _05266_ _05369_ _05450_ VGND VGND VPWR VPWR _05455_ sky130_fd_sc_hd__or3_1
XFILLER_0_44_122 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_0_72_475 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_32_306 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XFILLER_0_103_717 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_0_88_3 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XTAP_TAPCELL_ROW_79_1247 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
X_09043_ _02136_ _01949_ _01441_ _05551_ VGND VGND VPWR VPWR _02669_ sky130_fd_sc_hd__a22o_1
XFILLER_0_60_626 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
X_06255_ net5 VGND VGND VPWR VPWR _05387_ sky130_fd_sc_hd__buf_4
XPHY_EDGE_ROW_111_Right_111 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_0_111_81 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_102_205 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
X_06186_ _05318_ VGND VGND VPWR VPWR _05319_ sky130_fd_sc_hd__buf_4
XFILLER_0_13_531 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_0_13_553 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XTAP_TAPCELL_ROW_92_1414 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
Xmax_cap140 _03514_ VGND VGND VPWR VPWR net140 sky130_fd_sc_hd__buf_1
Xmax_cap162 _01702_ VGND VGND VPWR VPWR net162 sky130_fd_sc_hd__buf_1
Xmax_cap151 _05441_ VGND VGND VPWR VPWR net151 sky130_fd_sc_hd__clkbuf_1
X_09945_ _03651_ _03652_ _03510_ _03512_ VGND VGND VPWR VPWR _03654_ sky130_fd_sc_hd__a211o_1
X_09876_ _03576_ _03577_ VGND VGND VPWR VPWR _03578_ sky130_fd_sc_hd__or2b_1
X_08827_ _04737_ _01187_ _02430_ _02431_ VGND VGND VPWR VPWR _02432_ sky130_fd_sc_hd__a22o_1
X_08758_ _00963_ _03201_ net53 _01805_ VGND VGND VPWR VPWR _02358_ sky130_fd_sc_hd__and4_1
X_08689_ _00076_ _02281_ VGND VGND VPWR VPWR _02282_ sky130_fd_sc_hd__nand2_1
X_07709_ _03376_ net10 net11 _03288_ VGND VGND VPWR VPWR _01212_ sky130_fd_sc_hd__a22o_1
X_10720_ _04495_ _04496_ VGND VGND VPWR VPWR _04497_ sky130_fd_sc_hd__xor2_1
XTAP_TAPCELL_ROW_101_1521 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_36_601 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
X_10651_ _04416_ _04421_ _04422_ VGND VGND VPWR VPWR _04423_ sky130_fd_sc_hd__nand3_2
XFILLER_0_82_228 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XTAP_TAPCELL_ROW_11_404 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_35_111 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_36_645 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
X_10582_ _04239_ _04241_ VGND VGND VPWR VPWR _04349_ sky130_fd_sc_hd__or2_2
XFILLER_0_106_533 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_35_144 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_0_90_294 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_121_569 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
X_11203_ _01673_ VGND VGND VPWR VPWR _05022_ sky130_fd_sc_hd__buf_2
XPHY_EDGE_ROW_79_Left_201 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XTAP_TAPCELL_ROW_112_1661 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
X_11134_ _04505_ _04157_ _04945_ _04946_ VGND VGND VPWR VPWR _04947_ sky130_fd_sc_hd__a22oi_2
X_11065_ _04852_ _04853_ VGND VGND VPWR VPWR _04872_ sky130_fd_sc_hd__or2b_1
XFILLER_0_101_293 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
X_10016_ _03727_ _03728_ _03729_ VGND VGND VPWR VPWR _03731_ sky130_fd_sc_hd__a21o_1
XTAP_TAPCELL_ROW_19_504 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_47_846 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XPHY_EDGE_ROW_88_Left_210 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_0_25_57 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
X_10918_ _04590_ _04592_ _04712_ VGND VGND VPWR VPWR _04713_ sky130_fd_sc_hd__a21o_1
XFILLER_0_58_236 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_86_589 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_73_206 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XTAP_TAPCELL_ROW_63_1048 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_27_612 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
X_10849_ _04544_ _04549_ VGND VGND VPWR VPWR _04638_ sky130_fd_sc_hd__nand2_1
XFILLER_0_66_291 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_27_634 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_0_27_645 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_39_483 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XFILLER_0_109_382 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_41_78 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_109_393 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_54_497 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XFILLER_0_14_317 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_2_701 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
X_06040_ _03485_ _03507_ _03987_ _03998_ VGND VGND VPWR VPWR _04009_ sky130_fd_sc_hd__o211a_2
XFILLER_0_1_222 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XFILLER_0_10_523 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_1_277 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_0_22_383 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XTAP_TAPCELL_ROW_74_1188 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
X_07991_ _01509_ _01383_ _01518_ VGND VGND VPWR VPWR _01520_ sky130_fd_sc_hd__o21a_2
X_09730_ _03312_ _03415_ _03416_ VGND VGND VPWR VPWR _03418_ sky130_fd_sc_hd__nand3_4
X_06942_ _00371_ _00372_ _00359_ VGND VGND VPWR VPWR _00375_ sky130_fd_sc_hd__o21a_1
XFILLER_0_10_589 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
X_09661_ _00038_ _01441_ _02843_ _05540_ VGND VGND VPWR VPWR _03344_ sky130_fd_sc_hd__a22o_1
X_06873_ _01978_ _00094_ VGND VGND VPWR VPWR _00300_ sky130_fd_sc_hd__and2_1
X_09592_ _03264_ _03265_ _03258_ VGND VGND VPWR VPWR _03268_ sky130_fd_sc_hd__a21o_1
X_05824_ net28 VGND VGND VPWR VPWR _01651_ sky130_fd_sc_hd__buf_4
X_08612_ _02172_ _02196_ _02198_ VGND VGND VPWR VPWR _02199_ sky130_fd_sc_hd__nand3_1
XFILLER_0_82_63 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
X_08543_ _02102_ _02121_ _02122_ VGND VGND VPWR VPWR _02123_ sky130_fd_sc_hd__and3_1
X_05755_ _00821_ _00865_ _00876_ VGND VGND VPWR VPWR _00897_ sky130_fd_sc_hd__a21o_1
XFILLER_0_82_96 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_0_82_85 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_0_119_113 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_92_526 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
X_08474_ _02044_ _02046_ VGND VGND VPWR VPWR _02047_ sky130_fd_sc_hd__xor2_1
X_07425_ _00891_ _00892_ _00900_ VGND VGND VPWR VPWR _00902_ sky130_fd_sc_hd__and3_1
XFILLER_0_18_645 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_0_72_250 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
X_07356_ _00825_ _00826_ VGND VGND VPWR VPWR _00827_ sky130_fd_sc_hd__and2b_1
XFILLER_0_45_453 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_115_341 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_72_261 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
X_07287_ _00750_ VGND VGND VPWR VPWR _00751_ sky130_fd_sc_hd__buf_4
X_06307_ _05355_ _05357_ _05437_ _05438_ VGND VGND VPWR VPWR _05439_ sky130_fd_sc_hd__a211oi_4
XFILLER_0_33_637 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_103_503 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
X_09026_ _02637_ _02648_ _02649_ VGND VGND VPWR VPWR _02650_ sky130_fd_sc_hd__nand3_1
X_06238_ _05369_ _05370_ VGND VGND VPWR VPWR _05371_ sky130_fd_sc_hd__xor2_1
XFILLER_0_103_558 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XFILLER_0_20_309 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
X_06169_ _04694_ _04857_ VGND VGND VPWR VPWR _05302_ sky130_fd_sc_hd__and2b_1
X_09928_ _03623_ _03633_ _03634_ VGND VGND VPWR VPWR _03635_ sky130_fd_sc_hd__and3_1
X_09859_ _03415_ _03558_ VGND VGND VPWR VPWR _03559_ sky130_fd_sc_hd__xnor2_1
XFILLER_0_99_169 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_0_68_501 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_95_342 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XTAP_TAPCELL_ROW_44_816 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_95_375 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
X_10703_ _04460_ _04478_ VGND VGND VPWR VPWR _04479_ sky130_fd_sc_hd__or2_2
XTAP_TAPCELL_ROW_24_562 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
X_10634_ _04403_ _04404_ VGND VGND VPWR VPWR _04405_ sky130_fd_sc_hd__xnor2_1
XFILLER_0_11_15 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_23_103 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
X_10565_ _04310_ _04328_ _04329_ VGND VGND VPWR VPWR _04330_ sky130_fd_sc_hd__nor3_2
XFILLER_0_23_125 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_24_659 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
X_10496_ _04153_ _04186_ VGND VGND VPWR VPWR _04254_ sky130_fd_sc_hd__or2b_1
XFILLER_0_23_169 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_121_355 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_121_399 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
X_11117_ _04850_ _04872_ _04927_ VGND VGND VPWR VPWR _04929_ sky130_fd_sc_hd__nand3_1
X_11048_ _04852_ _04853_ VGND VGND VPWR VPWR _04854_ sky130_fd_sc_hd__xor2_1
Xinput8 mcand[16] VGND VGND VPWR VPWR net8 sky130_fd_sc_hd__clkbuf_2
XFILLER_0_78_309 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_74_515 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XFILLER_0_15_604 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
X_07210_ _00665_ _00666_ VGND VGND VPWR VPWR _00667_ sky130_fd_sc_hd__xnor2_1
X_08190_ _05423_ _05502_ _05539_ _00139_ VGND VGND VPWR VPWR _01737_ sky130_fd_sc_hd__nand4_2
X_07141_ _00590_ _00591_ VGND VGND VPWR VPWR _00593_ sky130_fd_sc_hd__or2b_1
XTAP_TAPCELL_ROW_76_1206 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_76_1217 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
X_07072_ _00480_ _00514_ _00516_ VGND VGND VPWR VPWR _00517_ sky130_fd_sc_hd__nor3_1
XFILLER_0_2_531 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_30_629 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XFILLER_0_100_506 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
X_06023_ _01497_ _03376_ VGND VGND VPWR VPWR _03823_ sky130_fd_sc_hd__and2_1
XFILLER_0_112_377 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_77_96 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_77_74 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
X_07974_ _01500_ VGND VGND VPWR VPWR _01501_ sky130_fd_sc_hd__clkbuf_4
XFILLER_0_93_51 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
X_06925_ _00355_ VGND VGND VPWR VPWR _00356_ sky130_fd_sc_hd__buf_4
X_09713_ _04596_ _03297_ _03298_ _03300_ VGND VGND VPWR VPWR _03400_ sky130_fd_sc_hd__nand4_1
XFILLER_0_93_73 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
X_09644_ _01762_ _03323_ _03324_ _00411_ VGND VGND VPWR VPWR _03325_ sky130_fd_sc_hd__a22o_1
X_06856_ _00186_ _00207_ _00208_ VGND VGND VPWR VPWR _00282_ sky130_fd_sc_hd__nand3_2
XTAP_TAPCELL_ROW_87_1346 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
X_05807_ _01138_ _01455_ VGND VGND VPWR VPWR net120 sky130_fd_sc_hd__xnor2_4
X_09575_ _03246_ _03248_ VGND VGND VPWR VPWR _03249_ sky130_fd_sc_hd__xor2_4
X_06787_ _00176_ _00177_ _00211_ _00212_ VGND VGND VPWR VPWR _00214_ sky130_fd_sc_hd__o22ai_4
X_05738_ _00635_ _00668_ _00690_ _00657_ VGND VGND VPWR VPWR _00712_ sky130_fd_sc_hd__a22o_1
X_08526_ _00195_ VGND VGND VPWR VPWR _02104_ sky130_fd_sc_hd__buf_4
XFILLER_0_77_386 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
X_08457_ _02024_ _02026_ _02027_ VGND VGND VPWR VPWR _02028_ sky130_fd_sc_hd__o21ai_4
XFILLER_0_92_345 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
X_07408_ _00599_ _00475_ _00732_ VGND VGND VPWR VPWR _00883_ sky130_fd_sc_hd__o21ba_1
XFILLER_0_9_185 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XFILLER_0_9_174 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XTAP_TAPCELL_ROW_21_521 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
X_08388_ _01950_ _01951_ _01948_ VGND VGND VPWR VPWR _01953_ sky130_fd_sc_hd__a21o_1
XFILLER_0_18_475 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_116_661 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
X_07339_ _00803_ _00663_ _00806_ _00807_ VGND VGND VPWR VPWR _00808_ sky130_fd_sc_hd__o211ai_4
X_10350_ _02113_ _02045_ VGND VGND VPWR VPWR _04095_ sky130_fd_sc_hd__nand2_1
XFILLER_0_103_322 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XTAP_TAPCELL_ROW_98_1486 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_60_253 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_0_5_391 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
X_10281_ _04017_ _04018_ _03893_ _03980_ VGND VGND VPWR VPWR _04021_ sky130_fd_sc_hd__a211oi_1
X_09009_ _02456_ _02457_ _02460_ VGND VGND VPWR VPWR _02631_ sky130_fd_sc_hd__a21bo_1
XTAP_TAPCELL_ROW_29_621 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_57_974 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_113_27 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_83_301 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XTAP_TAPCELL_ROW_60_1007 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_28_217 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XTAP_TAPCELL_ROW_120_1760 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_60_1018 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_83_389 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_0_36_250 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
X_10617_ _00356_ _04275_ _04383_ _04384_ VGND VGND VPWR VPWR _04386_ sky130_fd_sc_hd__nand4_1
X_10548_ _04171_ _04180_ _04179_ VGND VGND VPWR VPWR _04311_ sky130_fd_sc_hd__o21bai_2
XFILLER_0_121_141 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
X_10479_ _04124_ _04126_ _04234_ _04235_ VGND VGND VPWR VPWR _04236_ sky130_fd_sc_hd__a211oi_4
XFILLER_0_20_695 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XTAP_TAPCELL_ROW_71_1147 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_47_55 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XPHY_EDGE_ROW_16_Left_138 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_0_37_9 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
X_06710_ _00515_ _05656_ _00057_ _00056_ VGND VGND VPWR VPWR _00137_ sky130_fd_sc_hd__a31o_1
XFILLER_0_63_32 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
X_07690_ _01188_ _01189_ _01183_ VGND VGND VPWR VPWR _01191_ sky130_fd_sc_hd__o21ai_2
X_06641_ _00054_ _00067_ _00068_ VGND VGND VPWR VPWR _00069_ sky130_fd_sc_hd__and3_1
XFILLER_0_93_109 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_0_87_673 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_63_87 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_59_364 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
X_09360_ _05304_ _05305_ _02173_ _01449_ VGND VGND VPWR VPWR _03014_ sky130_fd_sc_hd__nand4_4
X_06572_ _05698_ _05699_ _00000_ VGND VGND VPWR VPWR _00001_ sky130_fd_sc_hd__nand3_1
X_09291_ _01249_ _00753_ _02795_ _02794_ _01898_ VGND VGND VPWR VPWR _02940_ sky130_fd_sc_hd__a32o_1
X_08311_ _01721_ _01730_ _01729_ VGND VGND VPWR VPWR _01870_ sky130_fd_sc_hd__a21oi_1
XFILLER_0_19_239 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XANTENNA_13 _02812_ VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XTAP_TAPCELL_ROW_82_1287 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_74_334 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
X_08242_ _01785_ _01794_ VGND VGND VPWR VPWR _01795_ sky130_fd_sc_hd__xnor2_2
XFILLER_0_47_559 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XANTENNA_57 net22 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_0_74_389 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_74_378 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_6_133 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XANTENNA_35 net98 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XPHY_EDGE_ROW_25_Left_147 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XANTENNA_46 _00646_ VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XANTENNA_24 net1 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
X_08173_ _00495_ _01717_ _01718_ VGND VGND VPWR VPWR _01719_ sky130_fd_sc_hd__a21bo_1
XFILLER_0_6_177 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_113_631 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_70_573 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
X_07124_ _00563_ _00572_ _00573_ VGND VGND VPWR VPWR _00574_ sky130_fd_sc_hd__nand3_2
XFILLER_0_42_253 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_88_73 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_0_70_3 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
X_07055_ _00492_ _00497_ VGND VGND VPWR VPWR _00498_ sky130_fd_sc_hd__xnor2_2
XFILLER_0_113_697 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_112_174 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
Xoutput120 net120 VGND VGND VPWR VPWR product[5] sky130_fd_sc_hd__clkbuf_4
X_06006_ _03616_ _03627_ _03233_ _03212_ VGND VGND VPWR VPWR _03638_ sky130_fd_sc_hd__a31oi_2
XFILLER_0_11_673 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XTAP_TAPCELL_ROW_7_349 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XPHY_EDGE_ROW_34_Left_156 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
X_07957_ _01480_ _01481_ _01314_ _01316_ VGND VGND VPWR VPWR _01483_ sky130_fd_sc_hd__a211oi_1
X_06908_ _00335_ _00337_ VGND VGND VPWR VPWR net75 sky130_fd_sc_hd__xnor2_1
X_07888_ _01267_ _01271_ _01272_ VGND VGND VPWR VPWR _01408_ sky130_fd_sc_hd__or3_2
X_09627_ _03303_ _03304_ _03296_ VGND VGND VPWR VPWR _03306_ sky130_fd_sc_hd__a21o_1
X_06839_ _03288_ _05550_ _05552_ _04878_ VGND VGND VPWR VPWR _00265_ sky130_fd_sc_hd__a22o_1
X_09558_ _04900_ _02228_ _03098_ _03229_ VGND VGND VPWR VPWR _03230_ sky130_fd_sc_hd__a31o_1
XTAP_TAPCELL_ROW_54_933 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
X_08509_ _01938_ _02007_ _02008_ VGND VGND VPWR VPWR _02085_ sky130_fd_sc_hd__nor3_1
XFILLER_0_38_515 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XPHY_EDGE_ROW_43_Left_165 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_0_93_665 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
X_09489_ _03147_ _03153_ _03154_ VGND VGND VPWR VPWR _03155_ sky130_fd_sc_hd__nand3_1
XFILLER_0_77_194 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XTAP_TAPCELL_ROW_34_690 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_80_348 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
X_11451_ _04357_ _02950_ _02928_ VGND VGND VPWR VPWR _05286_ sky130_fd_sc_hd__or3b_1
X_10402_ _01221_ _02230_ _04100_ VGND VGND VPWR VPWR _04152_ sky130_fd_sc_hd__nand3_1
X_11382_ _05193_ _05214_ VGND VGND VPWR VPWR _05215_ sky130_fd_sc_hd__xor2_1
XFILLER_0_61_573 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_21_404 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_33_231 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
X_10333_ _04057_ _04058_ _04075_ VGND VGND VPWR VPWR _04077_ sky130_fd_sc_hd__o21ba_1
XFILLER_0_0_309 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XFILLER_0_104_697 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
X_10264_ _02645_ _02947_ _04000_ _04001_ VGND VGND VPWR VPWR _04002_ sky130_fd_sc_hd__a22oi_2
XPHY_EDGE_ROW_52_Left_174 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
X_10195_ _03859_ VGND VGND VPWR VPWR _03926_ sky130_fd_sc_hd__inv_2
XFILLER_0_108_27 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XTAP_TAPCELL_ROW_109_1622 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_88_404 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_0_17_69 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_69_673 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XPHY_EDGE_ROW_61_Left_183 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_0_96_481 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_68_183 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_84_643 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_68_194 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XFILLER_0_56_334 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_84_676 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_71_304 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_56_389 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_56_378 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
Xinput11 mcand[19] VGND VGND VPWR VPWR net11 sky130_fd_sc_hd__buf_4
XFILLER_0_71_337 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
Xinput22 mcand[29] VGND VGND VPWR VPWR net22 sky130_fd_sc_hd__buf_4
Xinput55 mplier[2] VGND VGND VPWR VPWR net55 sky130_fd_sc_hd__buf_4
XFILLER_0_109_3 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
Xinput33 mplier[0] VGND VGND VPWR VPWR net33 sky130_fd_sc_hd__clkbuf_4
XFILLER_0_52_540 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_0_4_637 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_0_3_125 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
Xinput44 mplier[1] VGND VGND VPWR VPWR net44 sky130_fd_sc_hd__buf_2
XFILLER_0_24_253 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_3_169 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_24_275 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XFILLER_0_110_601 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XPHY_EDGE_ROW_70_Left_192 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_0_12_459 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
X_08860_ _02300_ _02303_ VGND VGND VPWR VPWR _02468_ sky130_fd_sc_hd__nand2_1
X_07811_ _01320_ _01323_ VGND VGND VPWR VPWR net83 sky130_fd_sc_hd__xnor2_4
XTAP_TAPCELL_ROW_4_308 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
X_08791_ _00887_ _01487_ net130 VGND VGND VPWR VPWR _02395_ sky130_fd_sc_hd__and3_1
X_07742_ _00802_ VGND VGND VPWR VPWR _01249_ sky130_fd_sc_hd__buf_4
XTAP_TAPCELL_ROW_84_1316 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
X_07673_ _01172_ _01173_ VGND VGND VPWR VPWR _01174_ sky130_fd_sc_hd__xor2_1
X_09412_ _02744_ _02908_ VGND VGND VPWR VPWR _03072_ sky130_fd_sc_hd__nor2_1
X_06624_ _00032_ _00051_ VGND VGND VPWR VPWR _00052_ sky130_fd_sc_hd__xnor2_1
X_09343_ _02992_ _02994_ _02995_ VGND VGND VPWR VPWR _02996_ sky130_fd_sc_hd__nand3_1
XTAP_TAPCELL_ROW_51_903 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_118_701 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_90_85 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_06555_ _05674_ _05683_ VGND VGND VPWR VPWR _05684_ sky130_fd_sc_hd__xnor2_2
XFILLER_0_47_356 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_117_222 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
X_09274_ _04716_ _02236_ _02761_ VGND VGND VPWR VPWR _02921_ sky130_fd_sc_hd__nand3_1
XFILLER_0_74_175 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
X_06486_ _05614_ _05615_ VGND VGND VPWR VPWR _05616_ sky130_fd_sc_hd__or2b_1
XFILLER_0_28_570 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_0_35_518 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_47_389 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_0_90_657 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_74_197 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_62_348 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
X_08225_ _01766_ _01774_ _01775_ VGND VGND VPWR VPWR _01776_ sky130_fd_sc_hd__nand3_2
XFILLER_0_105_428 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_99_61 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
X_08156_ _01691_ _01699_ VGND VGND VPWR VPWR _01700_ sky130_fd_sc_hd__xnor2_1
XFILLER_0_99_94 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XTAP_TAPCELL_ROW_95_1445 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_15_275 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
X_07107_ _00545_ _00554_ VGND VGND VPWR VPWR _00555_ sky130_fd_sc_hd__xnor2_2
XFILLER_0_43_573 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_101_623 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_30_234 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
X_08087_ _01621_ _01624_ VGND VGND VPWR VPWR _01625_ sky130_fd_sc_hd__xnor2_2
X_07038_ _00477_ _00478_ VGND VGND VPWR VPWR _00479_ sky130_fd_sc_hd__and2_1
X_08989_ _02434_ _02437_ _02607_ _02608_ VGND VGND VPWR VPWR _02609_ sky130_fd_sc_hd__a211oi_1
XFILLER_0_98_713 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_0_97_201 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
X_10951_ _04746_ _04747_ VGND VGND VPWR VPWR _04749_ sky130_fd_sc_hd__xor2_1
X_10882_ _03433_ _02051_ VGND VGND VPWR VPWR _04674_ sky130_fd_sc_hd__nand2_1
XFILLER_0_97_278 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XFILLER_0_85_429 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XTAP_TAPCELL_ROW_104_1563 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_66_643 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_65_153 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_53_337 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
X_11434_ _05246_ _05256_ _05268_ VGND VGND VPWR VPWR _05270_ sky130_fd_sc_hd__nand3_1
XFILLER_0_108_277 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_34_562 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_0_22_713 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
X_11365_ _05022_ _04040_ _04873_ _01501_ VGND VGND VPWR VPWR _05196_ sky130_fd_sc_hd__a22oi_1
XFILLER_0_1_629 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
X_10316_ _04054_ _04055_ _04056_ VGND VGND VPWR VPWR _04058_ sky130_fd_sc_hd__a21oi_1
X_11296_ _04732_ _05022_ VGND VGND VPWR VPWR _05122_ sky130_fd_sc_hd__nand2_1
XFILLER_0_21_256 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_119_15 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
X_10247_ _01580_ _01680_ _03981_ _03982_ VGND VGND VPWR VPWR _03983_ sky130_fd_sc_hd__o2bb2a_1
X_10178_ _03787_ _03789_ _03906_ _03907_ VGND VGND VPWR VPWR _03908_ sky130_fd_sc_hd__o211ai_4
XFILLER_0_28_79 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XTAP_TAPCELL_ROW_37_719 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_119_509 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_76_418 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XTAP_TAPCELL_ROW_17_476 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_57_665 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_0_56_164 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_17_518 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_0_29_389 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
X_06340_ _02513_ _03015_ _04074_ _01486_ VGND VGND VPWR VPWR _05471_ sky130_fd_sc_hd__a22o_1
X_06271_ _05383_ _05384_ _05401_ _05402_ VGND VGND VPWR VPWR _05403_ sky130_fd_sc_hd__a211oi_2
XFILLER_0_44_348 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_08010_ _04716_ _00750_ _01537_ _01538_ VGND VGND VPWR VPWR _01540_ sky130_fd_sc_hd__a22o_1
XFILLER_0_25_540 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_114_269 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_40_521 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_0_12_223 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
X_09961_ _02400_ _03665_ _03670_ VGND VGND VPWR VPWR _03672_ sky130_fd_sc_hd__a21oi_4
XFILLER_0_110_453 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
X_08912_ _02523_ _02525_ VGND VGND VPWR VPWR _02526_ sky130_fd_sc_hd__or2_2
XFILLER_0_0_673 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_09892_ _03592_ _03593_ _03579_ VGND VGND VPWR VPWR _03596_ sky130_fd_sc_hd__a21o_1
XTAP_TAPCELL_ROW_90_1386 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
X_08843_ _02307_ _02308_ _02309_ _02312_ VGND VGND VPWR VPWR _02450_ sky130_fd_sc_hd__a31o_1
XFILLER_0_109_81 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XPHY_EDGE_ROW_108_Left_230 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_0_33_3 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
X_08774_ _02157_ _02202_ _02201_ VGND VGND VPWR VPWR _02376_ sky130_fd_sc_hd__a21boi_4
X_05986_ _02436_ _02480_ _02469_ VGND VGND VPWR VPWR _03419_ sky130_fd_sc_hd__a21bo_1
X_07725_ _01220_ _01228_ _01229_ VGND VGND VPWR VPWR _01230_ sky130_fd_sc_hd__nand3_2
X_07656_ _01153_ _01154_ VGND VGND VPWR VPWR _01155_ sky130_fd_sc_hd__and2_1
X_06607_ net7 VGND VGND VPWR VPWR _00035_ sky130_fd_sc_hd__clkbuf_4
X_07587_ _05419_ _00041_ _01077_ _01078_ VGND VGND VPWR VPWR _01079_ sky130_fd_sc_hd__nand4_2
XFILLER_0_48_643 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
X_09326_ _02976_ _02626_ _02973_ _02974_ VGND VGND VPWR VPWR _02977_ sky130_fd_sc_hd__nand4_1
X_06538_ _05658_ _05665_ _05666_ VGND VGND VPWR VPWR _05667_ sky130_fd_sc_hd__nand3_2
XFILLER_0_48_676 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_0_90_421 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
X_09257_ _02748_ _02902_ VGND VGND VPWR VPWR _02903_ sky130_fd_sc_hd__xnor2_4
XFILLER_0_63_635 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_35_337 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_118_597 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_0_118_586 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XFILLER_0_62_167 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_62_145 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
X_06469_ _05596_ _05597_ _05598_ VGND VGND VPWR VPWR _05599_ sky130_fd_sc_hd__nand3_1
X_08208_ _01587_ _01595_ VGND VGND VPWR VPWR _01757_ sky130_fd_sc_hd__and2_1
X_09188_ _02810_ _02825_ _02826_ VGND VGND VPWR VPWR _02827_ sky130_fd_sc_hd__and3_2
X_08139_ _01677_ _01680_ _00395_ _01676_ VGND VGND VPWR VPWR _01681_ sky130_fd_sc_hd__and4b_1
X_11150_ _03396_ _01673_ VGND VGND VPWR VPWR _04964_ sky130_fd_sc_hd__nand2_1
XFILLER_0_31_576 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
X_10101_ _00345_ _01620_ _01800_ _00343_ VGND VGND VPWR VPWR _03824_ sky130_fd_sc_hd__a22o_1
X_11081_ _04886_ _04887_ VGND VGND VPWR VPWR _04890_ sky130_fd_sc_hd__nand2_1
X_10032_ _03746_ _03748_ VGND VGND VPWR VPWR _03749_ sky130_fd_sc_hd__or2_2
XFILLER_0_105_39 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
X_10934_ _03324_ _03171_ _02862_ _00495_ VGND VGND VPWR VPWR _04730_ sky130_fd_sc_hd__a22o_1
XFILLER_0_58_418 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XFILLER_0_14_15 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
X_10865_ _04648_ _04654_ VGND VGND VPWR VPWR _04655_ sky130_fd_sc_hd__xnor2_1
XFILLER_0_38_131 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_39_643 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XTAP_TAPCELL_ROW_14_435 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_121_27 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
X_10796_ _04516_ _04518_ VGND VGND VPWR VPWR _04580_ sky130_fd_sc_hd__or2b_1
XFILLER_0_109_564 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_109_553 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_93_292 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_38_175 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XTAP_TAPCELL_ROW_42_788 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_53_156 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XTAP_TAPCELL_ROW_117_1721 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_53_178 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
X_11417_ _05249_ _05251_ VGND VGND VPWR VPWR _05252_ sky130_fd_sc_hd__xnor2_1
X_11348_ _05176_ _05177_ VGND VGND VPWR VPWR _05178_ sky130_fd_sc_hd__and2_1
X_11279_ _05000_ _05102_ VGND VGND VPWR VPWR _05104_ sky130_fd_sc_hd__or2_1
X_05840_ _01727_ _01738_ _01815_ VGND VGND VPWR VPWR _01826_ sky130_fd_sc_hd__nor3_1
XTAP_TAPCELL_ROW_68_1108 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_89_554 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_0_89_543 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
X_05771_ _01029_ _01061_ VGND VGND VPWR VPWR _01072_ sky130_fd_sc_hd__xnor2_2
X_07510_ _00992_ _00993_ _00990_ VGND VGND VPWR VPWR _00995_ sky130_fd_sc_hd__a21o_1
X_08490_ net19 VGND VGND VPWR VPWR _02064_ sky130_fd_sc_hd__buf_4
XFILLER_0_49_429 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_07441_ _00810_ _03223_ net10 _00235_ VGND VGND VPWR VPWR _00920_ sky130_fd_sc_hd__and4_1
XFILLER_0_92_719 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_9_559 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
X_07372_ _00840_ _00841_ _00842_ VGND VGND VPWR VPWR _00845_ sky130_fd_sc_hd__a21o_1
XFILLER_0_29_131 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_29_164 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
X_09111_ _02729_ _02731_ VGND VGND VPWR VPWR _02743_ sky130_fd_sc_hd__nor2_1
XFILLER_0_57_495 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XFILLER_0_17_337 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
X_06323_ _05376_ _05454_ VGND VGND VPWR VPWR net69 sky130_fd_sc_hd__xor2_4
XFILLER_0_115_512 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_115_501 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_0_45_679 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XTAP_TAPCELL_ROW_79_1248 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
X_09042_ _05551_ _02136_ _01949_ VGND VGND VPWR VPWR _02668_ sky130_fd_sc_hd__and3_1
X_06254_ _05325_ _05333_ VGND VGND VPWR VPWR _05386_ sky130_fd_sc_hd__or2b_1
X_06185_ net4 VGND VGND VPWR VPWR _05318_ sky130_fd_sc_hd__clkbuf_4
XFILLER_0_4_253 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_0_13_521 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_0_111_93 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XTAP_TAPCELL_ROW_92_1415 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
Xmax_cap152 _03045_ VGND VGND VPWR VPWR net152 sky130_fd_sc_hd__clkbuf_1
Xmax_cap141 _01712_ VGND VGND VPWR VPWR net141 sky130_fd_sc_hd__buf_1
XFILLER_0_13_576 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_40_351 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
Xmax_cap163 _01568_ VGND VGND VPWR VPWR net163 sky130_fd_sc_hd__clkbuf_2
XFILLER_0_13_598 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_96_73 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_09944_ _03510_ _03512_ _03651_ _03652_ VGND VGND VPWR VPWR _03653_ sky130_fd_sc_hd__o211ai_4
X_09875_ _03573_ _03575_ _03568_ _03569_ VGND VGND VPWR VPWR _03577_ sky130_fd_sc_hd__a211o_1
X_08826_ _04922_ _00392_ _02060_ _01040_ VGND VGND VPWR VPWR _02431_ sky130_fd_sc_hd__nand4_2
X_08757_ _00985_ _02177_ _01805_ _00308_ VGND VGND VPWR VPWR _02357_ sky130_fd_sc_hd__a22oi_1
X_05969_ _00832_ _00330_ _03223_ _01007_ VGND VGND VPWR VPWR _03233_ sky130_fd_sc_hd__a22o_1
X_08688_ net16 VGND VGND VPWR VPWR _02281_ sky130_fd_sc_hd__buf_4
XFILLER_0_67_204 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_07708_ _03288_ _03332_ _00485_ _00235_ VGND VGND VPWR VPWR _01211_ sky130_fd_sc_hd__nand4_1
X_07639_ _05343_ _05550_ _00387_ VGND VGND VPWR VPWR _01136_ sky130_fd_sc_hd__and3_1
XTAP_TAPCELL_ROW_101_1522 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
X_10650_ _04419_ _04420_ _04271_ _04273_ VGND VGND VPWR VPWR _04422_ sky130_fd_sc_hd__o211ai_2
X_09309_ _02956_ _02957_ _02782_ _02784_ VGND VGND VPWR VPWR _02959_ sky130_fd_sc_hd__a211oi_1
XTAP_TAPCELL_ROW_11_405 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_48_473 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_0_48_484 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_0_48_495 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
X_10581_ _04345_ _04346_ VGND VGND VPWR VPWR _04348_ sky130_fd_sc_hd__nand2_2
XFILLER_0_90_251 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_8_581 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_0_36_657 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_50_137 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_0_121_559 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
X_11202_ _04966_ _04967_ VGND VGND VPWR VPWR _05021_ sky130_fd_sc_hd__or2b_1
XFILLER_0_50_159 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XTAP_TAPCELL_ROW_112_1662 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
X_11133_ _00895_ _01042_ _03172_ _02864_ VGND VGND VPWR VPWR _04946_ sky130_fd_sc_hd__nand4_2
X_11064_ _04864_ _04871_ VGND VGND VPWR VPWR net112 sky130_fd_sc_hd__xor2_1
X_10015_ _03727_ _03728_ _03729_ VGND VGND VPWR VPWR _03730_ sky130_fd_sc_hd__nand3_2
XTAP_TAPCELL_ROW_19_505 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_116_27 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XTAP_TAPCELL_ROW_47_847 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_86_502 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XFILLER_0_58_215 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
X_10917_ _02325_ _03675_ _04593_ VGND VGND VPWR VPWR _04712_ sky130_fd_sc_hd__and3_1
XFILLER_0_74_719 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XTAP_TAPCELL_ROW_63_1049 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_41_13 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
X_10848_ _04635_ _04636_ VGND VGND VPWR VPWR _04637_ sky130_fd_sc_hd__nor2_2
XFILLER_0_54_421 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_0_41_57 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
X_10779_ _04559_ _04560_ VGND VGND VPWR VPWR _04561_ sky130_fd_sc_hd__xor2_1
XFILLER_0_54_454 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XFILLER_0_26_156 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_0_27_657 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_0_27_668 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_0_1_201 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_2_713 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_0_112_559 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_0_22_351 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_0_67_9 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_50_682 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_22_395 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XTAP_TAPCELL_ROW_74_1189 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
X_07990_ _01510_ _01517_ VGND VGND VPWR VPWR _01518_ sky130_fd_sc_hd__xnor2_1
X_06941_ _00359_ _00371_ _00372_ VGND VGND VPWR VPWR _00374_ sky130_fd_sc_hd__nor3_1
XFILLER_0_5_57 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
X_09660_ _00798_ _02163_ _03187_ _03186_ _03341_ VGND VGND VPWR VPWR _03342_ sky130_fd_sc_hd__a32o_1
X_06872_ _00293_ _00298_ VGND VGND VPWR VPWR _00299_ sky130_fd_sc_hd__xor2_2
X_08611_ _02193_ _02194_ _02195_ VGND VGND VPWR VPWR _02198_ sky130_fd_sc_hd__a21o_1
X_09591_ _03258_ _03264_ _03265_ VGND VGND VPWR VPWR _03267_ sky130_fd_sc_hd__nand3_2
X_05823_ _00974_ _01618_ _01629_ VGND VGND VPWR VPWR _01640_ sky130_fd_sc_hd__a21bo_1
X_05754_ _00821_ _00865_ _00876_ VGND VGND VPWR VPWR _00886_ sky130_fd_sc_hd__nand3_1
X_08542_ _02117_ _02118_ _02119_ VGND VGND VPWR VPWR _02122_ sky130_fd_sc_hd__a21o_1
X_08473_ _00384_ _02045_ VGND VGND VPWR VPWR _02046_ sky130_fd_sc_hd__nand2_1
XFILLER_0_119_125 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_9_312 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
X_07424_ _00891_ _00892_ _00900_ VGND VGND VPWR VPWR _00901_ sky130_fd_sc_hd__a21oi_1
XFILLER_0_15_91 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_57_281 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
X_07355_ _00823_ _00824_ _00819_ VGND VGND VPWR VPWR _00826_ sky130_fd_sc_hd__a21o_1
X_07286_ net16 VGND VGND VPWR VPWR _00750_ sky130_fd_sc_hd__clkbuf_4
XFILLER_0_17_167 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
X_06306_ _05435_ _05436_ _05414_ VGND VGND VPWR VPWR _05438_ sky130_fd_sc_hd__o21a_1
XFILLER_0_32_104 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_0_115_375 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
X_09025_ _02643_ _02647_ _02638_ VGND VGND VPWR VPWR _02649_ sky130_fd_sc_hd__a21o_1
XFILLER_0_33_649 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
X_06237_ _05266_ _05291_ VGND VGND VPWR VPWR _05370_ sky130_fd_sc_hd__nand2_1
XFILLER_0_13_362 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_0_41_660 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XFILLER_0_41_671 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_13_373 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
X_06168_ _04824_ VGND VGND VPWR VPWR _05301_ sky130_fd_sc_hd__inv_2
X_06099_ _04498_ _04509_ _04640_ VGND VGND VPWR VPWR _04650_ sky130_fd_sc_hd__a21oi_2
X_09927_ _03631_ _03632_ _03624_ VGND VGND VPWR VPWR _03634_ sky130_fd_sc_hd__a21o_1
X_09858_ _03556_ _03557_ VGND VGND VPWR VPWR _03558_ sky130_fd_sc_hd__xnor2_1
XFILLER_0_99_159 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
X_09789_ _03481_ _03482_ VGND VGND VPWR VPWR _03483_ sky130_fd_sc_hd__xor2_4
X_08809_ _04878_ net20 _01852_ _03780_ VGND VGND VPWR VPWR _02412_ sky130_fd_sc_hd__a22o_1
XFILLER_0_68_513 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XTAP_TAPCELL_ROW_44_806 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_44_817 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
X_10702_ _04466_ _04477_ VGND VGND VPWR VPWR _04478_ sky130_fd_sc_hd__xnor2_2
XFILLER_0_55_229 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XTAP_TAPCELL_ROW_24_563 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_36_410 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XFILLER_0_48_281 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_119_670 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
X_10633_ _04297_ _04299_ VGND VGND VPWR VPWR _04404_ sky130_fd_sc_hd__or2_1
X_10564_ _04326_ _04327_ _04219_ _04221_ VGND VGND VPWR VPWR _04329_ sky130_fd_sc_hd__a211oi_2
XFILLER_0_102_29 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_51_413 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_0_11_27 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_121_301 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_0_51_457 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_0_51_446 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
X_10495_ net144 _04187_ VGND VGND VPWR VPWR _04253_ sky130_fd_sc_hd__nand2_1
X_11116_ _04850_ _04872_ _04927_ VGND VGND VPWR VPWR _04928_ sky130_fd_sc_hd__a21o_1
X_11047_ _04776_ _04778_ VGND VGND VPWR VPWR _04853_ sky130_fd_sc_hd__nand2_1
Xinput9 mcand[17] VGND VGND VPWR VPWR net9 sky130_fd_sc_hd__clkbuf_4
XFILLER_0_99_671 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_59_524 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_86_365 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_47_719 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_27_443 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_0_39_281 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_0_82_571 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_0_54_262 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XFILLER_0_54_251 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
X_07140_ net142 _00589_ _00451_ _00453_ VGND VGND VPWR VPWR _00591_ sky130_fd_sc_hd__o211ai_2
XFILLER_0_6_359 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_0_27_476 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_42_435 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XTAP_TAPCELL_ROW_76_1218 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_76_1207 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
X_07071_ _00512_ _00513_ _00402_ _00481_ VGND VGND VPWR VPWR _00516_ sky130_fd_sc_hd__o211a_1
XFILLER_0_23_660 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
X_06022_ _03769_ _03801_ VGND VGND VPWR VPWR _03812_ sky130_fd_sc_hd__xor2_2
XFILLER_0_112_389 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_50_490 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_0_2_587 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
X_09712_ _03395_ _03398_ VGND VGND VPWR VPWR _03399_ sky130_fd_sc_hd__xor2_1
X_07973_ _01499_ VGND VGND VPWR VPWR _01500_ sky130_fd_sc_hd__buf_4
X_06924_ _00354_ VGND VGND VPWR VPWR _00355_ sky130_fd_sc_hd__clkbuf_4
X_09643_ _00612_ VGND VGND VPWR VPWR _03324_ sky130_fd_sc_hd__buf_4
X_06855_ _00278_ _00279_ _00260_ _00261_ VGND VGND VPWR VPWR _00281_ sky130_fd_sc_hd__a211oi_2
XFILLER_0_117_81 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XTAP_TAPCELL_ROW_87_1347 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
X_09574_ _05574_ _03247_ VGND VGND VPWR VPWR _03248_ sky130_fd_sc_hd__nand2_2
X_05806_ _01334_ _01444_ VGND VGND VPWR VPWR _01455_ sky130_fd_sc_hd__nand2_2
XFILLER_0_89_181 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
X_08525_ _01920_ _01922_ VGND VGND VPWR VPWR _02103_ sky130_fd_sc_hd__nand2_1
X_06786_ _00176_ _00177_ _00211_ _00212_ VGND VGND VPWR VPWR _00213_ sky130_fd_sc_hd__or4_2
X_05737_ _00635_ _00657_ _00668_ _00690_ VGND VGND VPWR VPWR _00701_ sky130_fd_sc_hd__and4_1
X_08456_ _01840_ _02020_ _02021_ VGND VGND VPWR VPWR _02027_ sky130_fd_sc_hd__or3_2
XFILLER_0_37_229 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_92_368 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
X_08387_ _01948_ _01950_ _01951_ VGND VGND VPWR VPWR _01952_ sky130_fd_sc_hd__nand3_1
X_07407_ _00881_ _05627_ _05622_ _00467_ VGND VGND VPWR VPWR _00882_ sky130_fd_sc_hd__and4b_2
XFILLER_0_9_197 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XTAP_TAPCELL_ROW_21_522 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
X_07338_ _04585_ _00084_ _00804_ _00805_ VGND VGND VPWR VPWR _00807_ sky130_fd_sc_hd__a22o_1
XFILLER_0_116_673 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_33_424 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_115_161 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XTAP_TAPCELL_ROW_98_1487 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
X_07269_ _00597_ _00596_ _00462_ _00331_ VGND VGND VPWR VPWR _00732_ sky130_fd_sc_hd__and4bb_1
XFILLER_0_115_194 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
X_10280_ _03893_ _03980_ _04017_ _04018_ VGND VGND VPWR VPWR _04019_ sky130_fd_sc_hd__o211a_2
XFILLER_0_103_345 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_0_103_334 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
X_09008_ _01580_ _00355_ _02627_ _02628_ VGND VGND VPWR VPWR _02630_ sky130_fd_sc_hd__a22o_1
XFILLER_0_103_389 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XTAP_TAPCELL_ROW_29_622 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_57_975 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_107_1594 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_68_365 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_68_343 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XTAP_TAPCELL_ROW_1_280 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_68_387 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_22_15 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XTAP_TAPCELL_ROW_120_1761 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_113_39 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_83_357 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XTAP_TAPCELL_ROW_60_1008 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
X_10616_ _00356_ _04275_ _04383_ _04384_ VGND VGND VPWR VPWR _04385_ sky130_fd_sc_hd__a22o_1
XFILLER_0_83_379 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_0_64_571 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_52_711 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_0_107_673 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_107_651 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
X_10547_ _04308_ _04309_ VGND VGND VPWR VPWR _04310_ sky130_fd_sc_hd__xor2_1
X_10478_ _04232_ _04233_ _04086_ _04128_ VGND VGND VPWR VPWR _04235_ sky130_fd_sc_hd__a211oi_2
XFILLER_0_11_129 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_0_121_153 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_0_121_197 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XTAP_TAPCELL_ROW_71_1148 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_9_380 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XPHY_EDGE_ROW_10_Right_10 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
X_06640_ _00065_ _00066_ _00059_ VGND VGND VPWR VPWR _00068_ sky130_fd_sc_hd__a21o_1
XFILLER_0_59_332 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
X_06571_ _05592_ _05594_ _05595_ VGND VGND VPWR VPWR _00000_ sky130_fd_sc_hd__a21bo_1
XFILLER_0_87_685 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
X_09290_ _02774_ _02777_ VGND VGND VPWR VPWR _02938_ sky130_fd_sc_hd__nand2_1
X_08310_ _01691_ _01699_ VGND VGND VPWR VPWR _01868_ sky130_fd_sc_hd__or2b_1
XANTENNA_14 _02813_ VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XTAP_TAPCELL_ROW_82_1288 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
X_08241_ _01791_ _01792_ VGND VGND VPWR VPWR _01794_ sky130_fd_sc_hd__or2b_1
XANTENNA_25 net7 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XANTENNA_36 net108 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_0_15_402 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XANTENNA_47 _00802_ VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_0_103_94 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
X_08172_ _03332_ _00494_ _00612_ _04726_ VGND VGND VPWR VPWR _01718_ sky130_fd_sc_hd__a22o_1
XFILLER_0_15_446 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XANTENNA_58 net100 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_0_6_189 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
X_07123_ _00568_ _00569_ _00571_ VGND VGND VPWR VPWR _00573_ sky130_fd_sc_hd__a21o_1
Xoutput110 net110 VGND VGND VPWR VPWR product[50] sky130_fd_sc_hd__buf_2
XFILLER_0_113_643 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
X_07054_ _01171_ _00496_ VGND VGND VPWR VPWR _00497_ sky130_fd_sc_hd__nand2_1
Xoutput121 net121 VGND VGND VPWR VPWR product[60] sky130_fd_sc_hd__buf_2
XFILLER_0_63_3 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
X_06005_ _01662_ VGND VGND VPWR VPWR _03627_ sky130_fd_sc_hd__buf_4
XFILLER_0_11_641 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_0_2_362 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XFILLER_0_23_490 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_30_449 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_0_112_197 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_11_685 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
X_07956_ _01314_ _01316_ _01480_ _01481_ VGND VGND VPWR VPWR _01482_ sky130_fd_sc_hd__o211a_1
X_06907_ _00228_ _00336_ VGND VGND VPWR VPWR _00337_ sky130_fd_sc_hd__nor2_1
XPHY_EDGE_ROW_106_Right_106 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
X_07887_ _01252_ _01260_ VGND VGND VPWR VPWR _01407_ sky130_fd_sc_hd__and2_2
XFILLER_0_97_449 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
X_09626_ _03296_ _03303_ _03304_ VGND VGND VPWR VPWR _03305_ sky130_fd_sc_hd__nand3_1
X_06838_ _05327_ _04726_ _05463_ _05552_ VGND VGND VPWR VPWR _00264_ sky130_fd_sc_hd__nand4_4
X_09557_ _03095_ _03097_ VGND VGND VPWR VPWR _03229_ sky130_fd_sc_hd__and2b_1
XTAP_TAPCELL_ROW_54_934 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
X_06769_ _03310_ _03321_ _00094_ _00195_ VGND VGND VPWR VPWR _00196_ sky130_fd_sc_hd__nand4_1
X_09488_ _03151_ _03152_ _03148_ VGND VGND VPWR VPWR _03154_ sky130_fd_sc_hd__a21o_1
XFILLER_0_65_324 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
X_08508_ _02081_ _02082_ _02033_ VGND VGND VPWR VPWR _02084_ sky130_fd_sc_hd__o21a_1
XFILLER_0_108_404 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
X_08439_ _01938_ _02007_ _02008_ VGND VGND VPWR VPWR _02009_ sky130_fd_sc_hd__or3_1
XTAP_TAPCELL_ROW_34_691 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
X_11450_ _05284_ VGND VGND VPWR VPWR net124 sky130_fd_sc_hd__clkbuf_1
X_10401_ _04097_ _04099_ VGND VGND VPWR VPWR _04151_ sky130_fd_sc_hd__nand2_1
X_11381_ _05209_ _05212_ VGND VGND VPWR VPWR _05214_ sky130_fd_sc_hd__xnor2_1
X_10332_ _04057_ _04058_ _04075_ VGND VGND VPWR VPWR _04076_ sky130_fd_sc_hd__nor3b_1
XFILLER_0_61_585 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_0_21_416 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_33_287 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_21_449 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
X_10263_ _01943_ _01603_ _00894_ _02061_ VGND VGND VPWR VPWR _04001_ sky130_fd_sc_hd__nand4_1
X_10194_ _00409_ _03675_ _03873_ VGND VGND VPWR VPWR _03925_ sky130_fd_sc_hd__nand3_2
XFILLER_0_17_15 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XTAP_TAPCELL_ROW_109_1623 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_69_685 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_29_505 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_0_33_47 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_84_688 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_37_571 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_44_519 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
Xinput12 mcand[1] VGND VGND VPWR VPWR net12 sky130_fd_sc_hd__buf_2
XFILLER_0_114_429 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
Xinput34 mplier[10] VGND VGND VPWR VPWR net34 sky130_fd_sc_hd__buf_4
Xinput45 mplier[20] VGND VGND VPWR VPWR net45 sky130_fd_sc_hd__clkbuf_2
Xinput23 mcand[2] VGND VGND VPWR VPWR net23 sky130_fd_sc_hd__buf_1
Xinput56 mplier[30] VGND VGND VPWR VPWR net56 sky130_fd_sc_hd__buf_2
XFILLER_0_3_137 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_24_265 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_0_110_624 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
X_08790_ _01487_ net130 VGND VGND VPWR VPWR _02393_ sky130_fd_sc_hd__and2_1
XTAP_TAPCELL_ROW_4_309 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
X_07810_ _00888_ _01321_ _01322_ VGND VGND VPWR VPWR _01323_ sky130_fd_sc_hd__o21ba_2
X_07741_ _01245_ net6 _05585_ _01246_ VGND VGND VPWR VPWR _01248_ sky130_fd_sc_hd__and4b_1
XFILLER_0_74_54 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XTAP_TAPCELL_ROW_84_1317 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_84_1306 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
X_07672_ _01021_ _01023_ VGND VGND VPWR VPWR _01173_ sky130_fd_sc_hd__nor2_1
X_09411_ _02744_ _02908_ VGND VGND VPWR VPWR _03071_ sky130_fd_sc_hd__nand2_1
X_06623_ _00048_ _00050_ VGND VGND VPWR VPWR _00051_ sky130_fd_sc_hd__xnor2_1
XFILLER_0_90_64 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_75_600 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
X_09342_ _02811_ _02821_ _02820_ VGND VGND VPWR VPWR _02995_ sky130_fd_sc_hd__a21bo_1
XTAP_TAPCELL_ROW_51_904 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
X_06554_ _05681_ _05682_ VGND VGND VPWR VPWR _05683_ sky130_fd_sc_hd__and2b_1
XFILLER_0_47_302 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_118_713 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_0_74_132 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_90_614 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
X_09273_ _02759_ _02760_ VGND VGND VPWR VPWR _02920_ sky130_fd_sc_hd__or2b_1
XFILLER_0_62_305 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
X_06485_ _05612_ _05613_ _05546_ VGND VGND VPWR VPWR _05615_ sky130_fd_sc_hd__o21ai_1
XFILLER_0_47_368 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XTAP_TAPCELL_ROW_31_650 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
X_08224_ _01770_ _01772_ _01773_ VGND VGND VPWR VPWR _01775_ sky130_fd_sc_hd__a21o_1
XFILLER_0_90_669 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
X_08155_ _01697_ _01698_ VGND VGND VPWR VPWR _01699_ sky130_fd_sc_hd__and2_1
XFILLER_0_43_541 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XTAP_TAPCELL_ROW_95_1446 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
X_07106_ _00547_ _00553_ VGND VGND VPWR VPWR _00554_ sky130_fd_sc_hd__xnor2_2
XFILLER_0_43_585 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_113_462 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XFILLER_0_3_671 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
X_08086_ _01622_ _01623_ VGND VGND VPWR VPWR _01624_ sky130_fd_sc_hd__and2b_1
XFILLER_0_101_635 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
X_07037_ _00240_ _00358_ _00476_ VGND VGND VPWR VPWR _00478_ sky130_fd_sc_hd__o21ai_1
XFILLER_0_11_482 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
X_08988_ _02605_ _02606_ _02595_ VGND VGND VPWR VPWR _02608_ sky130_fd_sc_hd__a21boi_1
X_07939_ _01461_ _01462_ _01440_ VGND VGND VPWR VPWR _01464_ sky130_fd_sc_hd__a21oi_2
X_10950_ _02838_ _03247_ VGND VGND VPWR VPWR _04747_ sky130_fd_sc_hd__nand2_1
XFILLER_0_97_235 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_97_213 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XTAP_TAPCELL_ROW_39_750 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
X_10881_ _04669_ _04671_ VGND VGND VPWR VPWR _04673_ sky130_fd_sc_hd__xor2_1
X_09609_ _03283_ _03284_ _03285_ VGND VGND VPWR VPWR _03286_ sky130_fd_sc_hd__and3_1
XTAP_TAPCELL_ROW_104_1564 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_66_655 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_65_121 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XFILLER_0_38_335 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XFILLER_0_108_201 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XFILLER_0_66_699 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_53_305 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_108_256 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_81_625 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_19_582 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
X_11433_ _05246_ _05256_ _05268_ VGND VGND VPWR VPWR _05269_ sky130_fd_sc_hd__a21oi_1
XFILLER_0_34_541 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XFILLER_0_110_29 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
X_11364_ _01501_ _05022_ _04040_ _04042_ VGND VGND VPWR VPWR _05195_ sky130_fd_sc_hd__and4_1
XFILLER_0_0_118 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
X_10315_ _04054_ _04055_ _04056_ VGND VGND VPWR VPWR _04057_ sky130_fd_sc_hd__and3_1
X_11295_ _05119_ _05120_ VGND VGND VPWR VPWR _05121_ sky130_fd_sc_hd__nor2_1
XFILLER_0_119_27 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
X_10246_ _00421_ _00294_ _02036_ _01852_ VGND VGND VPWR VPWR _03982_ sky130_fd_sc_hd__and4_1
X_10177_ _03904_ _03905_ _03799_ _03783_ VGND VGND VPWR VPWR _03907_ sky130_fd_sc_hd__a211o_1
XFILLER_0_100_690 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_88_246 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_44_57 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_0_57_622 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XTAP_TAPCELL_ROW_17_477 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_84_463 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_84_485 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XFILLER_0_72_636 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_06270_ _05385_ _05386_ _05400_ VGND VGND VPWR VPWR _05402_ sky130_fd_sc_hd__and3_1
XFILLER_0_114_215 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XFILLER_0_25_552 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_37_390 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XFILLER_0_52_371 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_80_691 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_69_54 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XFILLER_0_110_421 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
X_09960_ _03381_ _03383_ _03527_ _03666_ _03669_ VGND VGND VPWR VPWR _03670_ sky130_fd_sc_hd__o311ai_4
X_08911_ _02521_ _02522_ _02515_ VGND VGND VPWR VPWR _02525_ sky130_fd_sc_hd__a21oi_1
X_09891_ _03579_ _03592_ _03593_ VGND VGND VPWR VPWR _03595_ sky130_fd_sc_hd__nand3_4
XTAP_TAPCELL_ROW_90_1387 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
X_08842_ _02407_ _02448_ VGND VGND VPWR VPWR _02449_ sky130_fd_sc_hd__xnor2_4
XFILLER_0_109_93 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
X_08773_ _02343_ _02374_ VGND VGND VPWR VPWR _02375_ sky130_fd_sc_hd__xor2_4
X_05985_ _03354_ _03386_ _03299_ VGND VGND VPWR VPWR _03408_ sky130_fd_sc_hd__a21o_1
XFILLER_0_26_3 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
X_07724_ _01226_ _01227_ _01222_ VGND VGND VPWR VPWR _01229_ sky130_fd_sc_hd__a21bo_1
XFILLER_0_95_717 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_0_79_235 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_07655_ _01151_ _01152_ _01133_ VGND VGND VPWR VPWR _01154_ sky130_fd_sc_hd__a21o_1
X_06606_ _00033_ VGND VGND VPWR VPWR _00034_ sky130_fd_sc_hd__buf_4
XFILLER_0_48_611 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_75_430 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
X_07586_ _03834_ _05539_ _00139_ _04976_ VGND VGND VPWR VPWR _01078_ sky130_fd_sc_hd__a22o_1
XFILLER_0_47_110 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
X_09325_ _00411_ VGND VGND VPWR VPWR _02976_ sky130_fd_sc_hd__clkbuf_4
X_06537_ _05663_ _05664_ _05562_ _05564_ VGND VGND VPWR VPWR _05666_ sky130_fd_sc_hd__o211ai_2
XFILLER_0_90_411 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_09256_ _02899_ _02901_ VGND VGND VPWR VPWR _02902_ sky130_fd_sc_hd__xnor2_4
XFILLER_0_63_647 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
X_06468_ _05500_ _05501_ _05503_ VGND VGND VPWR VPWR _05598_ sky130_fd_sc_hd__a21bo_1
XFILLER_0_35_327 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_105_215 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_08207_ _01593_ _01594_ VGND VGND VPWR VPWR _01756_ sky130_fd_sc_hd__and2_1
XFILLER_0_90_477 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
X_09187_ _02822_ _02823_ _02824_ VGND VGND VPWR VPWR _02826_ sky130_fd_sc_hd__a21o_1
XFILLER_0_50_319 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_06399_ _05451_ _05450_ _05448_ VGND VGND VPWR VPWR _05530_ sky130_fd_sc_hd__o21a_1
X_08138_ net22 VGND VGND VPWR VPWR _01680_ sky130_fd_sc_hd__clkbuf_4
X_08069_ _00983_ VGND VGND VPWR VPWR _01605_ sky130_fd_sc_hd__buf_4
XFILLER_0_3_490 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_31_588 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_11080_ _04886_ _04887_ VGND VGND VPWR VPWR _04888_ sky130_fd_sc_hd__or2_1
X_10100_ _02626_ _01606_ _03710_ _03711_ VGND VGND VPWR VPWR _03822_ sky130_fd_sc_hd__and4_1
X_10031_ _03744_ _03745_ _00084_ _01680_ VGND VGND VPWR VPWR _03748_ sky130_fd_sc_hd__and4bb_1
XFILLER_0_98_533 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_0_98_566 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
X_10933_ _00496_ _00614_ _03172_ VGND VGND VPWR VPWR _04729_ sky130_fd_sc_hd__and3_1
XFILLER_0_14_27 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
X_10864_ _04652_ _04653_ VGND VGND VPWR VPWR _04654_ sky130_fd_sc_hd__and2_1
XFILLER_0_85_238 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XFILLER_0_38_121 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
X_10795_ _04577_ _04578_ VGND VGND VPWR VPWR _04579_ sky130_fd_sc_hd__or2_1
XTAP_TAPCELL_ROW_65_1080 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_14_436 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_53_113 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XTAP_TAPCELL_ROW_42_789 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_109_587 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_0_30_15 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XTAP_TAPCELL_ROW_117_1722 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_112_719 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
X_11416_ _05140_ _05178_ _05214_ _05250_ VGND VGND VPWR VPWR _05251_ sky130_fd_sc_hd__a31o_1
XFILLER_0_22_533 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
X_11347_ _05174_ _05175_ VGND VGND VPWR VPWR _05177_ sky130_fd_sc_hd__or2_1
XFILLER_0_1_449 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_0_39_35 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
X_11278_ _04544_ _04549_ _04867_ _04999_ _05102_ VGND VGND VPWR VPWR _05103_ sky130_fd_sc_hd__a2111o_1
X_10229_ _00356_ _02984_ _03960_ _03961_ VGND VGND VPWR VPWR _03963_ sky130_fd_sc_hd__nand4_1
XFILLER_0_55_23 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XTAP_TAPCELL_ROW_68_1109 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_55_45 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_05770_ _01050_ net33 VGND VGND VPWR VPWR _01061_ sky130_fd_sc_hd__nand2_1
XFILLER_0_76_205 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_49_408 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_76_249 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
X_07440_ _00916_ _00917_ VGND VGND VPWR VPWR _00918_ sky130_fd_sc_hd__or2_2
XPHY_EDGE_ROW_8_Right_8 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_0_9_538 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
X_07371_ _00840_ _00841_ _00842_ VGND VGND VPWR VPWR _00844_ sky130_fd_sc_hd__nand3_1
XFILLER_0_29_154 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
X_09110_ _02737_ _02741_ VGND VGND VPWR VPWR net92 sky130_fd_sc_hd__xor2_2
X_06322_ _05377_ _05453_ VGND VGND VPWR VPWR _05454_ sky130_fd_sc_hd__xnor2_4
X_09041_ _01109_ VGND VGND VPWR VPWR _02667_ sky130_fd_sc_hd__buf_4
XFILLER_0_17_349 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_115_535 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XTAP_TAPCELL_ROW_79_1249 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_72_477 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_4_210 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
X_06253_ _05326_ _05332_ VGND VGND VPWR VPWR _05385_ sky130_fd_sc_hd__or2_1
X_06184_ _05315_ _05316_ VGND VGND VPWR VPWR _05317_ sky130_fd_sc_hd__xnor2_2
XFILLER_0_4_243 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XTAP_TAPCELL_ROW_92_1416 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
Xmax_cap142 _00588_ VGND VGND VPWR VPWR net142 sky130_fd_sc_hd__buf_1
Xmax_cap131 _01492_ VGND VGND VPWR VPWR net131 sky130_fd_sc_hd__buf_1
Xmax_cap153 net154 VGND VGND VPWR VPWR net153 sky130_fd_sc_hd__clkbuf_1
XFILLER_0_40_363 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_110_240 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
Xmax_cap164 _00671_ VGND VGND VPWR VPWR net164 sky130_fd_sc_hd__buf_1
XFILLER_0_110_251 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_96_85 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_09943_ net139 _03650_ _03533_ _03534_ VGND VGND VPWR VPWR _03652_ sky130_fd_sc_hd__o211ai_4
XPHY_EDGE_ROW_39_Right_39 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
X_09874_ _03568_ _03569_ _03573_ _03575_ VGND VGND VPWR VPWR _03576_ sky130_fd_sc_hd__o211a_1
X_08825_ _04976_ _00893_ _01185_ _05676_ VGND VGND VPWR VPWR _02430_ sky130_fd_sc_hd__a22o_1
X_08756_ _02344_ _02355_ VGND VGND VPWR VPWR _02356_ sky130_fd_sc_hd__xnor2_4
X_05968_ _01508_ VGND VGND VPWR VPWR _03223_ sky130_fd_sc_hd__clkbuf_4
X_08687_ _00610_ _02278_ _02279_ VGND VGND VPWR VPWR _02280_ sky130_fd_sc_hd__a21bo_1
X_07707_ _01206_ _01209_ VGND VGND VPWR VPWR _01210_ sky130_fd_sc_hd__xor2_4
X_05899_ _02447_ _00646_ _02000_ _02458_ VGND VGND VPWR VPWR _02469_ sky130_fd_sc_hd__nand4_2
X_07638_ _00408_ _05557_ VGND VGND VPWR VPWR _01135_ sky130_fd_sc_hd__nand2_1
XFILLER_0_48_430 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XTAP_TAPCELL_ROW_101_1523 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_83_709 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_07569_ _00690_ net16 VGND VGND VPWR VPWR _01059_ sky130_fd_sc_hd__and2_1
XPHY_EDGE_ROW_48_Right_48 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_0_118_340 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
X_09308_ _02782_ _02784_ _02956_ _02957_ VGND VGND VPWR VPWR _02958_ sky130_fd_sc_hd__o211a_2
XFILLER_0_0_91 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_35_102 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_0_35_113 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
X_10580_ _04343_ _04344_ _04250_ _04251_ VGND VGND VPWR VPWR _04346_ sky130_fd_sc_hd__a211o_1
X_09239_ _02880_ _02881_ _02870_ VGND VGND VPWR VPWR _02883_ sky130_fd_sc_hd__a21oi_1
XFILLER_0_51_628 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_51_617 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_0_16_371 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_11201_ _04957_ _05018_ VGND VGND VPWR VPWR _05020_ sky130_fd_sc_hd__xor2_1
X_11132_ _01041_ _03172_ _02864_ _00895_ VGND VGND VPWR VPWR _04945_ sky130_fd_sc_hd__a22o_1
XPHY_EDGE_ROW_57_Right_57 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
X_11063_ _04550_ _04867_ _04870_ VGND VGND VPWR VPWR _04871_ sky130_fd_sc_hd__o21a_2
XTAP_TAPCELL_ROW_112_1663 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
X_10014_ _03580_ _03588_ _03587_ VGND VGND VPWR VPWR _03729_ sky130_fd_sc_hd__a21bo_1
XTAP_TAPCELL_ROW_47_848 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
X_10916_ _04709_ _04710_ VGND VGND VPWR VPWR _04711_ sky130_fd_sc_hd__xnor2_2
XPHY_EDGE_ROW_66_Right_66 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XTAP_TAPCELL_ROW_27_594 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_27_603 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_39_463 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
X_10847_ _04551_ _04553_ _04634_ VGND VGND VPWR VPWR _04636_ sky130_fd_sc_hd__and3_1
XFILLER_0_41_25 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_109_351 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
X_10778_ _00751_ _03440_ VGND VGND VPWR VPWR _04560_ sky130_fd_sc_hd__nand2_1
XFILLER_0_81_263 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XFILLER_0_41_105 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XPHY_EDGE_ROW_75_Right_75 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_0_50_661 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_0_34_190 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_0_50_694 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_0_50_672 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_0_66_22 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_0_5_69 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
X_06940_ _00248_ _00360_ _00370_ VGND VGND VPWR VPWR _00372_ sky130_fd_sc_hd__and3_1
X_06871_ _00294_ _00295_ _00296_ VGND VGND VPWR VPWR _00298_ sky130_fd_sc_hd__a21bo_1
X_08610_ _02193_ _02194_ _02195_ VGND VGND VPWR VPWR _02196_ sky130_fd_sc_hd__nand3_1
X_05822_ net58 _00963_ _01607_ net55 VGND VGND VPWR VPWR _01629_ sky130_fd_sc_hd__a22o_1
XPHY_EDGE_ROW_84_Right_84 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
X_09590_ _03262_ _03263_ _03259_ VGND VGND VPWR VPWR _03265_ sky130_fd_sc_hd__a21o_1
X_08541_ _02117_ _02118_ _02119_ VGND VGND VPWR VPWR _02121_ sky130_fd_sc_hd__nand3_1
X_05753_ _00428_ _00581_ VGND VGND VPWR VPWR _00876_ sky130_fd_sc_hd__and2_1
X_08472_ net24 VGND VGND VPWR VPWR _02045_ sky130_fd_sc_hd__buf_4
XFILLER_0_92_506 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_77_569 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_65_709 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
X_07423_ _00898_ _00899_ VGND VGND VPWR VPWR _00900_ sky130_fd_sc_hd__or2_4
XFILLER_0_119_137 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_9_335 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_45_400 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_72_230 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
X_07354_ _00819_ _00823_ _00824_ VGND VGND VPWR VPWR _00825_ sky130_fd_sc_hd__and3_1
XFILLER_0_93_3 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
X_07285_ _02666_ _00747_ _00748_ _00362_ VGND VGND VPWR VPWR _00749_ sky130_fd_sc_hd__a22o_1
X_06305_ _05414_ _05435_ _05436_ VGND VGND VPWR VPWR _05437_ sky130_fd_sc_hd__nor3_4
XFILLER_0_103_505 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XPHY_EDGE_ROW_93_Right_93 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_0_72_296 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
X_09024_ _02638_ _02643_ _02647_ VGND VGND VPWR VPWR _02648_ sky130_fd_sc_hd__nand3_1
XFILLER_0_60_436 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_26_680 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_31_91 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_32_127 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
X_06236_ _05367_ _05368_ VGND VGND VPWR VPWR _05369_ sky130_fd_sc_hd__xnor2_2
XFILLER_0_5_596 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
X_06167_ _04107_ _04629_ VGND VGND VPWR VPWR _05300_ sky130_fd_sc_hd__and2_1
XFILLER_0_13_385 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
X_06098_ _04107_ _04629_ VGND VGND VPWR VPWR _04640_ sky130_fd_sc_hd__xnor2_1
XFILLER_0_1_9 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
X_09926_ _03624_ _03631_ _03632_ VGND VGND VPWR VPWR _03633_ sky130_fd_sc_hd__nand3_4
X_09857_ _03406_ _03409_ VGND VGND VPWR VPWR _03557_ sky130_fd_sc_hd__and2_1
XFILLER_0_99_138 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
X_09788_ _05574_ _02052_ VGND VGND VPWR VPWR _03482_ sky130_fd_sc_hd__nand2_2
X_08808_ _03780_ _04878_ _01852_ VGND VGND VPWR VPWR _02411_ sky130_fd_sc_hd__and3_1
X_08739_ _02334_ _02335_ _02327_ VGND VGND VPWR VPWR _02337_ sky130_fd_sc_hd__a21o_1
XTAP_TAPCELL_ROW_44_807 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_44_818 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
X_10701_ _04474_ _04475_ VGND VGND VPWR VPWR _04477_ sky130_fd_sc_hd__or2b_1
X_10632_ _04400_ _04402_ VGND VGND VPWR VPWR _04403_ sky130_fd_sc_hd__or2_1
XTAP_TAPCELL_ROW_24_564 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_36_433 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_10563_ _04219_ _04221_ _04326_ _04327_ VGND VGND VPWR VPWR _04328_ sky130_fd_sc_hd__o211a_2
XFILLER_0_91_561 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_11_39 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_36_477 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_106_365 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_0_106_343 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
X_10494_ _04190_ _04080_ _04225_ _04226_ VGND VGND VPWR VPWR _04252_ sky130_fd_sc_hd__o211a_1
XFILLER_0_23_149 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XFILLER_0_121_335 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_121_379 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
X_11115_ _04925_ _04926_ VGND VGND VPWR VPWR _04927_ sky130_fd_sc_hd__xor2_1
X_11046_ _04850_ _04851_ VGND VGND VPWR VPWR _04852_ sky130_fd_sc_hd__nand2_1
XFILLER_0_59_503 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_59_569 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_52_35 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_86_388 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_86_377 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_0_46_208 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_6_316 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_6_305 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_0_70_701 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_15_617 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_82_583 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_0_14_138 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
X_07070_ _00402_ _00481_ _00512_ _00513_ VGND VGND VPWR VPWR _00514_ sky130_fd_sc_hd__a211oi_2
XFILLER_0_42_447 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XTAP_TAPCELL_ROW_76_1208 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_2_533 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
X_06021_ _03791_ _01050_ VGND VGND VPWR VPWR _03801_ sky130_fd_sc_hd__nand2_1
X_09711_ _05468_ _03396_ VGND VGND VPWR VPWR _03398_ sky130_fd_sc_hd__nand2_1
X_07972_ net21 VGND VGND VPWR VPWR _01499_ sky130_fd_sc_hd__clkbuf_4
X_06923_ net13 VGND VGND VPWR VPWR _00354_ sky130_fd_sc_hd__clkbuf_4
X_09642_ _00494_ VGND VGND VPWR VPWR _03323_ sky130_fd_sc_hd__buf_4
X_06854_ _00260_ _00261_ _00278_ _00279_ VGND VGND VPWR VPWR _00280_ sky130_fd_sc_hd__o211a_1
X_09573_ net24 VGND VGND VPWR VPWR _03247_ sky130_fd_sc_hd__buf_4
XTAP_TAPCELL_ROW_87_1348 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
X_05805_ _01345_ _01433_ VGND VGND VPWR VPWR _01444_ sky130_fd_sc_hd__nand2_1
X_06785_ _00209_ _00210_ _00105_ _00107_ VGND VGND VPWR VPWR _00212_ sky130_fd_sc_hd__o211a_1
XFILLER_0_117_93 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_77_311 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
X_08524_ _02092_ _02101_ VGND VGND VPWR VPWR _02102_ sky130_fd_sc_hd__xnor2_2
X_05736_ _00679_ VGND VGND VPWR VPWR _00690_ sky130_fd_sc_hd__clkbuf_4
XFILLER_0_89_193 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_0_92_325 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_65_539 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XFILLER_0_65_517 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
X_08455_ _02024_ _02026_ VGND VGND VPWR VPWR net88 sky130_fd_sc_hd__xor2_2
XFILLER_0_18_411 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_08386_ _04531_ _04552_ _01610_ _01949_ VGND VGND VPWR VPWR _01951_ sky130_fd_sc_hd__nand4_2
X_07406_ _00465_ _00599_ _00731_ _00873_ VGND VGND VPWR VPWR _00881_ sky130_fd_sc_hd__or4_2
XFILLER_0_116_630 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XTAP_TAPCELL_ROW_21_523 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
X_07337_ _04585_ _00802_ _00804_ _00805_ VGND VGND VPWR VPWR _00806_ sky130_fd_sc_hd__nand4_4
XFILLER_0_60_211 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_33_436 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_0_116_685 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XTAP_TAPCELL_ROW_98_1488 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
X_07268_ _00728_ _00730_ VGND VGND VPWR VPWR _00731_ sky130_fd_sc_hd__xnor2_4
XFILLER_0_5_371 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
X_09007_ _02113_ _02626_ _02627_ _02628_ VGND VGND VPWR VPWR _02629_ sky130_fd_sc_hd__nand4_1
XFILLER_0_60_299 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
X_06219_ _05339_ _05350_ _05351_ VGND VGND VPWR VPWR _05352_ sky130_fd_sc_hd__nand3_2
X_07199_ _03856_ _03343_ _05550_ _00387_ VGND VGND VPWR VPWR _00655_ sky130_fd_sc_hd__and4_1
X_09909_ _00283_ _03247_ VGND VGND VPWR VPWR _03614_ sky130_fd_sc_hd__nand2_1
XFILLER_0_87_108 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XTAP_TAPCELL_ROW_29_623 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_57_976 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_1_270 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_107_1595 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_29_709 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_83_325 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_68_399 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_0_68_377 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XFILLER_0_56_517 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XTAP_TAPCELL_ROW_120_1762 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_60_1009 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_22_27 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
X_10615_ _00348_ _00350_ _03690_ _03171_ VGND VGND VPWR VPWR _04384_ sky130_fd_sc_hd__nand4_1
XFILLER_0_71_509 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_107_663 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_91_391 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_64_583 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_0_51_222 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
X_10546_ _02302_ _02227_ VGND VGND VPWR VPWR _04309_ sky130_fd_sc_hd__nand2_1
XFILLER_0_107_685 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
X_10477_ _04086_ _04128_ _04232_ _04233_ VGND VGND VPWR VPWR _04234_ sky130_fd_sc_hd__o211a_2
XTAP_TAPCELL_ROW_9_370 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_71_1149 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_47_57 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
X_11029_ _02840_ _01673_ VGND VGND VPWR VPWR _04833_ sky130_fd_sc_hd__nand2_1
XFILLER_0_2_15 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_99_491 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_86_141 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_59_355 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
X_06570_ _05694_ _05697_ _05692_ VGND VGND VPWR VPWR _05699_ sky130_fd_sc_hd__a21o_1
XFILLER_0_87_697 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XTAP_TAPCELL_ROW_82_1289 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
X_08240_ _01789_ _01790_ _01622_ _01786_ VGND VGND VPWR VPWR _01792_ sky130_fd_sc_hd__a211o_1
XFILLER_0_117_449 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XANTENNA_15 _03294_ VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XANTENNA_26 net10 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
X_08171_ _04726_ _03332_ _00611_ VGND VGND VPWR VPWR _01717_ sky130_fd_sc_hd__and3_1
XANTENNA_37 net108 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XANTENNA_48 _01935_ VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
X_07122_ _00568_ _00569_ _00571_ VGND VGND VPWR VPWR _00572_ sky130_fd_sc_hd__nand3_1
XFILLER_0_113_611 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XFILLER_0_70_553 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_42_244 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_113_655 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
X_07053_ _00495_ VGND VGND VPWR VPWR _00496_ sky130_fd_sc_hd__buf_4
Xoutput100 net100 VGND VGND VPWR VPWR product[41] sky130_fd_sc_hd__clkbuf_4
Xoutput122 net122 VGND VGND VPWR VPWR product[61] sky130_fd_sc_hd__clkbuf_4
XFILLER_0_112_165 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
X_06004_ _03605_ VGND VGND VPWR VPWR _03616_ sky130_fd_sc_hd__buf_4
Xoutput111 net111 VGND VGND VPWR VPWR product[51] sky130_fd_sc_hd__clkbuf_4
XFILLER_0_10_152 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_11_697 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_10_185 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
X_07955_ _01478_ _01479_ _01330_ VGND VGND VPWR VPWR _01481_ sky130_fd_sc_hd__o21ai_1
X_06906_ _00124_ _00123_ _00225_ VGND VGND VPWR VPWR _00336_ sky130_fd_sc_hd__and3_1
XFILLER_0_97_417 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_0_97_406 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
X_09625_ _03301_ _03302_ _03194_ _03196_ VGND VGND VPWR VPWR _03304_ sky130_fd_sc_hd__o211ai_2
X_07886_ _01259_ _01257_ VGND VGND VPWR VPWR _01406_ sky130_fd_sc_hd__and2b_2
X_06837_ _00178_ _00185_ VGND VGND VPWR VPWR _00263_ sky130_fd_sc_hd__nand2_1
X_09556_ _03226_ _03228_ VGND VGND VPWR VPWR net95 sky130_fd_sc_hd__xor2_1
XFILLER_0_77_141 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XTAP_TAPCELL_ROW_54_935 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
X_06768_ net42 VGND VGND VPWR VPWR _00195_ sky130_fd_sc_hd__clkbuf_4
X_09487_ _03148_ _03151_ _03152_ VGND VGND VPWR VPWR _03153_ sky130_fd_sc_hd__nand3_1
XFILLER_0_78_697 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
X_05719_ _00493_ VGND VGND VPWR VPWR _00504_ sky130_fd_sc_hd__buf_4
X_06699_ _05622_ _05627_ _00030_ _00026_ _00028_ VGND VGND VPWR VPWR _00127_ sky130_fd_sc_hd__a32o_2
X_08507_ _02033_ _02081_ _02082_ VGND VGND VPWR VPWR _02083_ sky130_fd_sc_hd__nor3_1
XFILLER_0_108_416 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
X_08438_ _02005_ _02006_ _01821_ _01939_ VGND VGND VPWR VPWR _02008_ sky130_fd_sc_hd__a211oi_2
XFILLER_0_108_449 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_65_369 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XTAP_TAPCELL_ROW_34_681 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_34_692 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_34_701 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
X_08369_ _01778_ _01780_ _01931_ _01932_ VGND VGND VPWR VPWR _01933_ sky130_fd_sc_hd__a211o_2
X_10400_ _04143_ _04149_ VGND VGND VPWR VPWR net103 sky130_fd_sc_hd__xnor2_1
X_11380_ _05211_ _05176_ VGND VGND VPWR VPWR _05212_ sky130_fd_sc_hd__nand2_1
XFILLER_0_73_391 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
X_10331_ _04064_ _04073_ VGND VGND VPWR VPWR _04075_ sky130_fd_sc_hd__xnor2_1
XFILLER_0_21_428 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XFILLER_0_33_277 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_0_103_165 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
X_10262_ _00987_ _02060_ _01040_ _02104_ VGND VGND VPWR VPWR _04000_ sky130_fd_sc_hd__a22o_1
XFILLER_0_103_176 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
X_10193_ _03870_ _03872_ VGND VGND VPWR VPWR _03924_ sky130_fd_sc_hd__nand2_1
XTAP_TAPCELL_ROW_6_340 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_108_29 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_17_27 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XTAP_TAPCELL_ROW_109_1624 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_88_428 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_33_15 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_69_697 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_68_141 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_83_111 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_83_155 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XFILLER_0_71_328 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
Xinput13 mcand[20] VGND VGND VPWR VPWR net13 sky130_fd_sc_hd__buf_4
XFILLER_0_24_211 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
Xinput24 mcand[30] VGND VGND VPWR VPWR net24 sky130_fd_sc_hd__buf_1
Xinput46 mplier[21] VGND VGND VPWR VPWR net46 sky130_fd_sc_hd__clkbuf_4
XFILLER_0_114_419 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_3_105 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
Xinput35 mplier[11] VGND VGND VPWR VPWR net35 sky130_fd_sc_hd__clkbuf_4
X_10529_ _04288_ _04289_ VGND VGND VPWR VPWR _04290_ sky130_fd_sc_hd__nand2_1
Xinput57 mplier[31] VGND VGND VPWR VPWR net57 sky130_fd_sc_hd__clkbuf_2
XFILLER_0_3_149 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
X_07740_ net37 net5 net38 _05318_ VGND VGND VPWR VPWR _01246_ sky130_fd_sc_hd__a22o_1
XTAP_TAPCELL_ROW_84_1307 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
X_07671_ _01169_ _01170_ VGND VGND VPWR VPWR _01172_ sky130_fd_sc_hd__or2_1
XTAP_TAPCELL_ROW_84_1318 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
X_09410_ _02566_ _02737_ _02909_ _02739_ VGND VGND VPWR VPWR _03069_ sky130_fd_sc_hd__or4b_1
X_06622_ _00049_ _05640_ VGND VGND VPWR VPWR _00050_ sky130_fd_sc_hd__nor2_1
XFILLER_0_87_461 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_09341_ _02990_ _02991_ _02983_ VGND VGND VPWR VPWR _02994_ sky130_fd_sc_hd__a21o_1
XTAP_TAPCELL_ROW_51_905 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
X_06553_ _05679_ _05680_ _05675_ VGND VGND VPWR VPWR _05682_ sky130_fd_sc_hd__a21o_1
XFILLER_0_90_76 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_117_202 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_114_83 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
X_09272_ _02793_ _02831_ _02829_ VGND VGND VPWR VPWR _02919_ sky130_fd_sc_hd__a21bo_2
XFILLER_0_16_701 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
X_06484_ _05546_ _05612_ _05613_ VGND VGND VPWR VPWR _05614_ sky130_fd_sc_hd__nor3_2
XFILLER_0_90_626 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_62_317 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XTAP_TAPCELL_ROW_31_651 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
X_08223_ _01770_ _01772_ _01773_ VGND VGND VPWR VPWR _01774_ sky130_fd_sc_hd__nand3_1
XFILLER_0_55_391 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
X_08154_ _01695_ _01696_ _01538_ _01539_ VGND VGND VPWR VPWR _01698_ sky130_fd_sc_hd__o211ai_1
XFILLER_0_7_488 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_43_553 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_0_15_255 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
X_07105_ _00551_ _00552_ VGND VGND VPWR VPWR _00553_ sky130_fd_sc_hd__or2_1
X_08085_ net27 net49 net50 _00297_ VGND VGND VPWR VPWR _01623_ sky130_fd_sc_hd__a22o_1
XTAP_TAPCELL_ROW_95_1447 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
X_07036_ _00240_ _00358_ _00476_ VGND VGND VPWR VPWR _00477_ sky130_fd_sc_hd__or3_4
XFILLER_0_100_113 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_30_269 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_11_494 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_11_461 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XFILLER_0_100_179 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
X_08987_ _02595_ _02605_ _02606_ VGND VGND VPWR VPWR _02607_ sky130_fd_sc_hd__and3b_1
X_07938_ _01440_ _01461_ _01462_ VGND VGND VPWR VPWR _01463_ sky130_fd_sc_hd__and3_1
X_07869_ _01245_ _01248_ VGND VGND VPWR VPWR _01387_ sky130_fd_sc_hd__or2_1
XTAP_TAPCELL_ROW_39_751 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
X_10880_ _03433_ _02236_ _04588_ _04670_ VGND VGND VPWR VPWR _04671_ sky130_fd_sc_hd__a31o_1
X_09608_ _03583_ _03172_ _03174_ _03175_ _01782_ VGND VGND VPWR VPWR _03285_ sky130_fd_sc_hd__a32o_1
XFILLER_0_78_472 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
X_09539_ _03165_ _03166_ _03208_ _03209_ VGND VGND VPWR VPWR _03210_ sky130_fd_sc_hd__and4_1
XTAP_TAPCELL_ROW_104_1565 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_66_645 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XFILLER_0_38_347 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_0_93_442 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_81_615 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_66_667 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_108_246 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_53_328 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_11432_ _05265_ _05267_ VGND VGND VPWR VPWR _05268_ sky130_fd_sc_hd__nand2_1
XFILLER_0_34_531 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_34_553 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XTAP_TAPCELL_ROW_59_1000 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
X_11363_ _05163_ _05162_ VGND VGND VPWR VPWR _05194_ sky130_fd_sc_hd__or2b_1
XFILLER_0_1_609 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_0_34_597 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_10314_ _03938_ _03946_ _03945_ VGND VGND VPWR VPWR _04056_ sky130_fd_sc_hd__a21bo_1
XFILLER_0_104_485 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_11294_ _01357_ _01501_ _03178_ _03807_ VGND VGND VPWR VPWR _05120_ sky130_fd_sc_hd__and4_1
XTAP_TAPCELL_ROW_115_1694 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
X_10245_ _00556_ _03237_ _03238_ _00546_ VGND VGND VPWR VPWR _03981_ sky130_fd_sc_hd__a22oi_1
XFILLER_0_119_39 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
X_10176_ _03799_ _03783_ _03904_ _03905_ VGND VGND VPWR VPWR _03906_ sky130_fd_sc_hd__o211ai_4
XFILLER_0_28_15 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_69_472 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_9_709 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XTAP_TAPCELL_ROW_17_478 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_29_314 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_44_306 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XFILLER_0_44_317 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_114_3 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_4_425 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_4_403 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_114_238 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_71_169 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XFILLER_0_52_361 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_0_52_383 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_110_433 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_0_631 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XFILLER_0_100_85 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
X_09890_ _03589_ _03590_ _03591_ VGND VGND VPWR VPWR _03593_ sky130_fd_sc_hd__a21o_1
X_08910_ _02515_ _02521_ _02522_ VGND VGND VPWR VPWR _02523_ sky130_fd_sc_hd__and3_1
XFILLER_0_40_589 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
X_08841_ _02408_ _02446_ VGND VGND VPWR VPWR _02448_ sky130_fd_sc_hd__xnor2_2
XTAP_TAPCELL_ROW_90_1388 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
X_08772_ _02371_ _02373_ VGND VGND VPWR VPWR _02374_ sky130_fd_sc_hd__xnor2_4
X_05984_ _03299_ _03354_ _03386_ VGND VGND VPWR VPWR _03397_ sky130_fd_sc_hd__nand3_1
XFILLER_0_79_225 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
X_07723_ _01222_ _01226_ _01227_ VGND VGND VPWR VPWR _01228_ sky130_fd_sc_hd__nand3b_2
XFILLER_0_19_3 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
X_07654_ _01133_ _01151_ _01152_ VGND VGND VPWR VPWR _01153_ sky130_fd_sc_hd__nand3_2
XTAP_TAPCELL_ROW_36_710 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
X_06605_ net9 VGND VGND VPWR VPWR _00033_ sky130_fd_sc_hd__clkbuf_4
X_07585_ _04998_ _04976_ _00138_ _05636_ VGND VGND VPWR VPWR _01077_ sky130_fd_sc_hd__nand4_2
XFILLER_0_48_623 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_48_645 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_118_533 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
X_09324_ _01582_ _00488_ _02973_ _02974_ VGND VGND VPWR VPWR _02975_ sky130_fd_sc_hd__a22o_1
X_06536_ _05562_ _05564_ _05663_ _05664_ VGND VGND VPWR VPWR _05665_ sky130_fd_sc_hd__a211o_2
X_09255_ _02617_ _02724_ _02900_ VGND VGND VPWR VPWR _02901_ sky130_fd_sc_hd__a21oi_2
X_06467_ _05594_ _05595_ _05592_ VGND VGND VPWR VPWR _05597_ sky130_fd_sc_hd__a21o_1
XFILLER_0_47_177 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
X_08206_ _01600_ _01601_ _01643_ _01644_ VGND VGND VPWR VPWR _01755_ sky130_fd_sc_hd__nor4_1
X_09186_ _02822_ _02823_ _02824_ VGND VGND VPWR VPWR _02825_ sky130_fd_sc_hd__nand3_1
X_06398_ _05528_ VGND VGND VPWR VPWR _05529_ sky130_fd_sc_hd__clkbuf_2
XFILLER_0_31_512 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
X_08137_ _01171_ _01673_ _01676_ _01678_ VGND VGND VPWR VPWR _01679_ sky130_fd_sc_hd__a22oi_1
XFILLER_0_16_597 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_31_567 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
X_08068_ _01603_ VGND VGND VPWR VPWR _01604_ sky130_fd_sc_hd__buf_4
X_07019_ _00231_ _00327_ _00326_ VGND VGND VPWR VPWR _00459_ sky130_fd_sc_hd__a21bo_1
XFILLER_0_101_477 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
X_10030_ _01249_ _01671_ _03744_ _03745_ VGND VGND VPWR VPWR _03746_ sky130_fd_sc_hd__o2bb2a_1
X_10932_ _04577_ _04696_ _04697_ VGND VGND VPWR VPWR _04728_ sky130_fd_sc_hd__and3_1
XFILLER_0_98_589 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_98_578 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
X_10863_ _02281_ _04275_ _04649_ _04651_ VGND VGND VPWR VPWR _04653_ sky130_fd_sc_hd__nand4_2
XFILLER_0_39_634 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
X_10794_ _04556_ _04480_ _04576_ VGND VGND VPWR VPWR _04578_ sky130_fd_sc_hd__and3_1
XFILLER_0_109_511 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_66_442 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XTAP_TAPCELL_ROW_65_1070 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_54_604 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XTAP_TAPCELL_ROW_14_437 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_38_155 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_121_29 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_19_380 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_30_27 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XTAP_TAPCELL_ROW_117_1723 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_53_169 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_0_34_361 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XPHY_EDGE_ROW_49_Left_171 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
X_11415_ _05215_ _05216_ VGND VGND VPWR VPWR _05250_ sky130_fd_sc_hd__nor2_1
XFILLER_0_34_372 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_11346_ _05174_ _05175_ VGND VGND VPWR VPWR _05176_ sky130_fd_sc_hd__nand2_1
XFILLER_0_22_589 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
X_11277_ _04997_ _05059_ VGND VGND VPWR VPWR _05102_ sky130_fd_sc_hd__nand2_1
X_10228_ _00488_ _02984_ _03960_ _03961_ VGND VGND VPWR VPWR _03962_ sky130_fd_sc_hd__a22o_1
X_10159_ _03884_ _03885_ _03877_ VGND VGND VPWR VPWR _03887_ sky130_fd_sc_hd__a21o_1
XPHY_EDGE_ROW_58_Left_180 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_0_89_523 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_89_501 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_0_76_239 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_0_71_34 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_29_100 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
X_07370_ _00694_ _00697_ _00696_ VGND VGND VPWR VPWR _00842_ sky130_fd_sc_hd__a21bo_1
XFILLER_0_72_412 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_06321_ _05450_ _05452_ VGND VGND VPWR VPWR _05453_ sky130_fd_sc_hd__xnor2_4
XFILLER_0_45_615 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_45_626 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
X_09040_ _05656_ _02321_ VGND VGND VPWR VPWR _02665_ sky130_fd_sc_hd__nand2_1
X_06252_ _01181_ _05320_ _05317_ VGND VGND VPWR VPWR _05384_ sky130_fd_sc_hd__nand3_2
XFILLER_0_45_659 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_115_558 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XFILLER_0_60_618 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_53_670 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XFILLER_0_103_709 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_06183_ _04563_ _04607_ VGND VGND VPWR VPWR _05316_ sky130_fd_sc_hd__or2_1
XFILLER_0_53_692 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XTAP_TAPCELL_ROW_92_1417 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_92_1406 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_4_277 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
Xmax_cap132 _01023_ VGND VGND VPWR VPWR net132 sky130_fd_sc_hd__buf_1
Xmax_cap143 _00324_ VGND VGND VPWR VPWR net143 sky130_fd_sc_hd__buf_1
X_09942_ _03533_ _03534_ _03648_ _03650_ VGND VGND VPWR VPWR _03651_ sky130_fd_sc_hd__a211o_2
Xmax_cap165 _03507_ VGND VGND VPWR VPWR net165 sky130_fd_sc_hd__clkbuf_2
X_09873_ _03574_ _00356_ _03570_ _03571_ VGND VGND VPWR VPWR _03575_ sky130_fd_sc_hd__nand4_1
XFILLER_0_0_483 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_08824_ _05497_ _00750_ _02279_ _02278_ _00495_ VGND VGND VPWR VPWR _02429_ sky130_fd_sc_hd__a32o_1
X_08755_ _02353_ _02354_ VGND VGND VPWR VPWR _02355_ sky130_fd_sc_hd__and2b_1
X_07706_ _00609_ _01207_ _01208_ VGND VGND VPWR VPWR _01209_ sky130_fd_sc_hd__a21bo_1
X_05967_ _00832_ _02054_ _03201_ _01508_ VGND VGND VPWR VPWR _03212_ sky130_fd_sc_hd__and4_1
X_08686_ _05008_ _00494_ _00612_ _04998_ VGND VGND VPWR VPWR _02279_ sky130_fd_sc_hd__a22o_1
X_05898_ net63 VGND VGND VPWR VPWR _02458_ sky130_fd_sc_hd__buf_4
XFILLER_0_95_559 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
X_07637_ _00971_ _00979_ _00978_ VGND VGND VPWR VPWR _01134_ sky130_fd_sc_hd__a21o_1
XTAP_TAPCELL_ROW_101_1524 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
X_07568_ _00947_ _00948_ _01012_ _01013_ VGND VGND VPWR VPWR _01058_ sky130_fd_sc_hd__nor4_1
XFILLER_0_48_442 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
X_09307_ _02954_ _02955_ _02778_ _02780_ VGND VGND VPWR VPWR _02957_ sky130_fd_sc_hd__o211ai_1
XFILLER_0_75_272 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_0_63_423 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_0_0_81 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
X_06519_ _05646_ _05647_ VGND VGND VPWR VPWR _05648_ sky130_fd_sc_hd__or2_1
XFILLER_0_118_363 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_118_352 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_0_63_434 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
X_07499_ net46 VGND VGND VPWR VPWR _00983_ sky130_fd_sc_hd__clkbuf_4
XFILLER_0_90_253 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_09238_ _02870_ _02880_ _02881_ VGND VGND VPWR VPWR _02882_ sky130_fd_sc_hd__and3_1
XFILLER_0_44_670 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_0_106_569 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
X_09169_ _02800_ _02801_ _02804_ _02805_ VGND VGND VPWR VPWR _02806_ sky130_fd_sc_hd__o211a_1
XFILLER_0_121_539 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
X_11200_ _05016_ _05017_ VGND VGND VPWR VPWR _05018_ sky130_fd_sc_hd__or2_1
X_11131_ _04879_ _04885_ VGND VGND VPWR VPWR _04944_ sky130_fd_sc_hd__or2b_1
XFILLER_0_8_3 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
X_11062_ _04795_ _04869_ VGND VGND VPWR VPWR _04870_ sky130_fd_sc_hd__nor2_1
XTAP_TAPCELL_ROW_112_1664 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
X_10013_ _03724_ _03726_ _03719_ VGND VGND VPWR VPWR _03728_ sky130_fd_sc_hd__a21o_1
XFILLER_0_116_29 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XTAP_TAPCELL_ROW_47_849 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
X_10915_ _04625_ _04627_ VGND VGND VPWR VPWR _04710_ sky130_fd_sc_hd__or2b_1
XFILLER_0_86_548 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XFILLER_0_39_420 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
X_10846_ _04551_ _04553_ _04634_ VGND VGND VPWR VPWR _04635_ sky130_fd_sc_hd__a21oi_1
XTAP_TAPCELL_ROW_27_595 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_66_261 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_6_509 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_39_475 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_10777_ _04157_ _04557_ _04558_ VGND VGND VPWR VPWR _04559_ sky130_fd_sc_hd__a21bo_1
XFILLER_0_26_125 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_81_275 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_0_41_128 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_22_331 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
X_11329_ _01357_ _03807_ _04042_ VGND VGND VPWR VPWR _05157_ sky130_fd_sc_hd__and3_1
XFILLER_0_5_15 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_66_56 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
X_06870_ _00330_ _05695_ _05696_ _01007_ VGND VGND VPWR VPWR _00296_ sky130_fd_sc_hd__a22o_1
X_05821_ net58 net55 _01607_ VGND VGND VPWR VPWR _01618_ sky130_fd_sc_hd__and3_1
X_08540_ _01917_ _01925_ _01923_ VGND VGND VPWR VPWR _02119_ sky130_fd_sc_hd__a21bo_1
X_05752_ _00624_ _00832_ _00843_ _00854_ VGND VGND VPWR VPWR _00865_ sky130_fd_sc_hd__a22o_1
X_08471_ _02040_ _02042_ VGND VGND VPWR VPWR _02044_ sky130_fd_sc_hd__xnor2_1
XFILLER_0_49_217 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_0_119_105 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
X_07422_ _01181_ _00896_ _00746_ _00752_ VGND VGND VPWR VPWR _00899_ sky130_fd_sc_hd__a211oi_1
XFILLER_0_119_149 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_64_209 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XFILLER_0_18_626 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_45_412 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_57_294 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XFILLER_0_17_136 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
X_07353_ net31 _00189_ _00820_ _00822_ VGND VGND VPWR VPWR _00824_ sky130_fd_sc_hd__a22o_1
XFILLER_0_72_253 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
X_07284_ _00611_ VGND VGND VPWR VPWR _00748_ sky130_fd_sc_hd__buf_4
X_06304_ _05432_ _05433_ _05434_ VGND VGND VPWR VPWR _05436_ sky130_fd_sc_hd__a21oi_2
XFILLER_0_115_355 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_72_286 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
X_09023_ _02645_ _02646_ _02639_ _02642_ VGND VGND VPWR VPWR _02647_ sky130_fd_sc_hd__nand4_2
XFILLER_0_60_448 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_0_32_117 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_0_32_139 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
X_06235_ _05223_ _05245_ VGND VGND VPWR VPWR _05368_ sky130_fd_sc_hd__or2_1
XFILLER_0_41_640 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
X_06166_ _05298_ _05299_ VGND VGND VPWR VPWR net67 sky130_fd_sc_hd__xor2_1
XFILLER_0_111_561 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_06097_ _04607_ _04618_ VGND VGND VPWR VPWR _04629_ sky130_fd_sc_hd__nor2_1
XFILLER_0_40_194 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
X_09925_ _03629_ _03630_ _03625_ VGND VGND VPWR VPWR _03632_ sky130_fd_sc_hd__a21o_1
X_09856_ _03554_ _03555_ VGND VGND VPWR VPWR _03556_ sky130_fd_sc_hd__or2_1
XFILLER_0_99_106 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
X_08807_ _00472_ _01849_ _02245_ VGND VGND VPWR VPWR _02410_ sky130_fd_sc_hd__nand3_1
X_09787_ _03477_ _03480_ VGND VGND VPWR VPWR _03481_ sky130_fd_sc_hd__xnor2_4
X_06999_ _00433_ _00434_ _00435_ VGND VGND VPWR VPWR _00437_ sky130_fd_sc_hd__a21o_1
X_08738_ _02327_ _02334_ _02335_ VGND VGND VPWR VPWR _02336_ sky130_fd_sc_hd__nand3_2
X_08669_ _04889_ _02064_ _02257_ _02258_ VGND VGND VPWR VPWR _02260_ sky130_fd_sc_hd__nand4_2
XTAP_TAPCELL_ROW_44_808 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
X_10700_ _04472_ _04473_ _04467_ _04468_ VGND VGND VPWR VPWR _04475_ sky130_fd_sc_hd__a211o_1
XFILLER_0_48_261 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
X_10631_ _04398_ _04399_ _02105_ _01671_ VGND VGND VPWR VPWR _04402_ sky130_fd_sc_hd__and4bb_1
XFILLER_0_63_220 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XTAP_TAPCELL_ROW_62_1040 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_24_565 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
X_10562_ _04323_ _04324_ _04214_ _04217_ VGND VGND VPWR VPWR _04327_ sky130_fd_sc_hd__o211ai_2
XFILLER_0_91_551 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_10493_ _02113_ _02230_ _04203_ VGND VGND VPWR VPWR _04251_ sky130_fd_sc_hd__and3_1
X_11114_ _04845_ _04847_ _04848_ _04807_ VGND VGND VPWR VPWR _04926_ sky130_fd_sc_hd__o22ai_2
X_11045_ _04780_ _04849_ VGND VGND VPWR VPWR _04851_ sky130_fd_sc_hd__or2_1
XTAP_TAPCELL_ROW_73_1180 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_36_15 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_99_673 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_99_651 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_98_194 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XFILLER_0_27_412 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_0_39_250 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
X_10829_ _04595_ _04614_ _04615_ VGND VGND VPWR VPWR _04616_ sky130_fd_sc_hd__nor3_2
XFILLER_0_54_220 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_0_70_713 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_0_54_253 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_0_6_328 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_15_629 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_0_112_325 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XTAP_TAPCELL_ROW_76_1209 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
X_06020_ _03780_ VGND VGND VPWR VPWR _03791_ sky130_fd_sc_hd__buf_4
XFILLER_0_2_545 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_23_673 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_2_589 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_10_378 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_10_356 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_07971_ _01356_ _01357_ _01352_ VGND VGND VPWR VPWR _01498_ sky130_fd_sc_hd__nand3_2
X_09710_ _03012_ VGND VGND VPWR VPWR _03396_ sky130_fd_sc_hd__clkbuf_4
X_06922_ _00347_ _00352_ VGND VGND VPWR VPWR _00353_ sky130_fd_sc_hd__nand2_2
X_09641_ _00411_ _01762_ _00914_ VGND VGND VPWR VPWR _03322_ sky130_fd_sc_hd__and3_1
X_06853_ _00262_ _00263_ _00277_ VGND VGND VPWR VPWR _00279_ sky130_fd_sc_hd__nand3_2
XFILLER_0_96_109 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_0_93_98 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XTAP_TAPCELL_ROW_87_1349 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
X_09572_ _03243_ _03245_ VGND VGND VPWR VPWR _03246_ sky130_fd_sc_hd__xnor2_4
X_05804_ _01378_ _01422_ VGND VGND VPWR VPWR _01433_ sky130_fd_sc_hd__and2_1
X_06784_ _00105_ _00107_ _00209_ _00210_ VGND VGND VPWR VPWR _00211_ sky130_fd_sc_hd__a211oi_4
X_08523_ _02099_ _02100_ VGND VGND VPWR VPWR _02101_ sky130_fd_sc_hd__or2b_1
X_05735_ net55 VGND VGND VPWR VPWR _00679_ sky130_fd_sc_hd__buf_2
XFILLER_0_77_378 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_0_9_111 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
X_08454_ _01491_ _01665_ _01843_ _02025_ VGND VGND VPWR VPWR _02026_ sky130_fd_sc_hd__o31a_2
XFILLER_0_107_108 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_0_92_337 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_08385_ _05308_ _01610_ _01949_ _05307_ VGND VGND VPWR VPWR _01950_ sky130_fd_sc_hd__a22o_1
XFILLER_0_9_144 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
X_07405_ _00878_ _00880_ VGND VGND VPWR VPWR net80 sky130_fd_sc_hd__xnor2_1
XFILLER_0_18_467 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XTAP_TAPCELL_ROW_21_524 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
X_07336_ _04074_ _05423_ _00086_ _03015_ VGND VGND VPWR VPWR _00805_ sky130_fd_sc_hd__a22o_1
XFILLER_0_42_91 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_45_242 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XFILLER_0_116_642 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XFILLER_0_33_415 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_0_116_697 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XTAP_TAPCELL_ROW_98_1489 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
X_09006_ _00546_ _00556_ _01379_ _00236_ VGND VGND VPWR VPWR _02628_ sky130_fd_sc_hd__nand4_1
XFILLER_0_60_234 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
X_07267_ _00460_ _00596_ _00729_ VGND VGND VPWR VPWR _00730_ sky130_fd_sc_hd__o21a_1
XFILLER_0_5_361 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_0_14_651 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_07198_ _00545_ _00554_ VGND VGND VPWR VPWR _00654_ sky130_fd_sc_hd__and2b_1
X_06218_ _05347_ _05348_ _05349_ VGND VGND VPWR VPWR _05351_ sky130_fd_sc_hd__a21o_1
X_06149_ _05159_ _05170_ _03965_ _04683_ VGND VGND VPWR VPWR _05192_ sky130_fd_sc_hd__a211o_1
X_09908_ _03611_ _03612_ VGND VGND VPWR VPWR _03613_ sky130_fd_sc_hd__xnor2_2
X_09839_ _02136_ _02160_ _02692_ _05551_ VGND VGND VPWR VPWR _03537_ sky130_fd_sc_hd__a22o_1
XTAP_TAPCELL_ROW_29_624 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_68_323 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_68_301 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XTAP_TAPCELL_ROW_57_977 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_1_271 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_107_1596 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_28_209 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XTAP_TAPCELL_ROW_120_1763 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
X_10614_ _02459_ _02178_ _03030_ _00151_ VGND VGND VPWR VPWR _04383_ sky130_fd_sc_hd__a22o_1
XFILLER_0_36_242 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_106_141 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_24_437 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
X_10545_ _04305_ _04307_ VGND VGND VPWR VPWR _04308_ sky130_fd_sc_hd__xor2_1
XFILLER_0_107_697 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_106_174 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_24_448 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_0_121_111 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
X_10476_ _04230_ _04231_ _04188_ VGND VGND VPWR VPWR _04233_ sky130_fd_sc_hd__o21ai_1
XFILLER_0_20_643 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_121_177 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XTAP_TAPCELL_ROW_9_371 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_47_69 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
X_11028_ _01354_ _04830_ _04831_ VGND VGND VPWR VPWR _04832_ sky130_fd_sc_hd__a21bo_1
XFILLER_0_2_27 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_87_621 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_74_315 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XPHY_EDGE_ROW_120_Right_120 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XANTENNA_16 _03387_ VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XANTENNA_27 net10 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XANTENNA_38 net116 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
X_08170_ _01576_ _01577_ _01598_ _01599_ VGND VGND VPWR VPWR _01715_ sky130_fd_sc_hd__o211ai_4
XANTENNA_49 _02865_ VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_0_70_521 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_07121_ _00429_ _00432_ _00431_ VGND VGND VPWR VPWR _00571_ sky130_fd_sc_hd__a21bo_1
XFILLER_0_88_21 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_0_12_83 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
X_07052_ _00494_ VGND VGND VPWR VPWR _00495_ sky130_fd_sc_hd__buf_4
Xoutput101 net101 VGND VGND VPWR VPWR product[42] sky130_fd_sc_hd__clkbuf_4
XFILLER_0_30_429 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XFILLER_0_42_278 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_42_289 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
Xoutput112 net112 VGND VGND VPWR VPWR product[52] sky130_fd_sc_hd__clkbuf_4
Xoutput123 net123 VGND VGND VPWR VPWR product[62] sky130_fd_sc_hd__clkbuf_4
XFILLER_0_113_667 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_0_100_306 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XFILLER_0_88_65 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_06003_ _00559_ VGND VGND VPWR VPWR _03605_ sky130_fd_sc_hd__clkbuf_4
XFILLER_0_10_197 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
X_07954_ _01330_ _01478_ _01479_ VGND VGND VPWR VPWR _01480_ sky130_fd_sc_hd__or3_1
XFILLER_0_49_3 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
X_07885_ _01264_ _01265_ _01300_ _01301_ VGND VGND VPWR VPWR _01405_ sky130_fd_sc_hd__nor4_1
X_06905_ _00333_ _00334_ VGND VGND VPWR VPWR _00335_ sky130_fd_sc_hd__xnor2_1
X_09624_ _03194_ _03196_ _03301_ _03302_ VGND VGND VPWR VPWR _03303_ sky130_fd_sc_hd__a211o_1
X_06836_ _00179_ _00184_ VGND VGND VPWR VPWR _00262_ sky130_fd_sc_hd__or2b_1
X_09555_ _03068_ _03076_ _03227_ VGND VGND VPWR VPWR _03228_ sky130_fd_sc_hd__o21a_1
XFILLER_0_78_665 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XTAP_TAPCELL_ROW_54_936 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
X_06767_ _01497_ _05693_ VGND VGND VPWR VPWR _00194_ sky130_fd_sc_hd__and2_1
X_09486_ _02646_ _02321_ _03149_ _03150_ VGND VGND VPWR VPWR _03152_ sky130_fd_sc_hd__nand4_2
X_05718_ net58 VGND VGND VPWR VPWR _00493_ sky130_fd_sc_hd__clkbuf_4
X_06698_ _00123_ _00125_ VGND VGND VPWR VPWR _00126_ sky130_fd_sc_hd__xnor2_4
X_08506_ _02079_ _02080_ _01933_ _01936_ VGND VGND VPWR VPWR _02082_ sky130_fd_sc_hd__o211a_1
XFILLER_0_38_529 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_0_65_337 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
X_08437_ _01821_ _01939_ _02005_ _02006_ VGND VGND VPWR VPWR _02007_ sky130_fd_sc_hd__o211a_2
XFILLER_0_80_307 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XTAP_TAPCELL_ROW_34_682 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_34_693 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_80_329 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_0_34_713 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
X_08368_ _01929_ _01930_ _01916_ VGND VGND VPWR VPWR _01932_ sky130_fd_sc_hd__a21oi_2
XFILLER_0_104_601 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
X_08299_ net22 VGND VGND VPWR VPWR _01856_ sky130_fd_sc_hd__clkbuf_4
X_07319_ _00670_ _00672_ _00784_ _00785_ VGND VGND VPWR VPWR _00786_ sky130_fd_sc_hd__o211ai_4
XPHY_EDGE_ROW_12_Left_134 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_0_6_681 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
X_10330_ _04071_ _04072_ VGND VGND VPWR VPWR _04073_ sky130_fd_sc_hd__or2b_1
X_10261_ _03881_ _03883_ VGND VGND VPWR VPWR _03999_ sky130_fd_sc_hd__nand2_1
X_10192_ _03919_ _03923_ VGND VGND VPWR VPWR net101 sky130_fd_sc_hd__xnor2_4
XTAP_TAPCELL_ROW_6_341 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XPHY_EDGE_ROW_21_Left_143 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XTAP_TAPCELL_ROW_109_1625 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_17_39 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_88_418 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XFILLER_0_68_153 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_33_27 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_83_167 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_114_409 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_83_189 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XFILLER_0_52_510 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XPHY_EDGE_ROW_30_Left_152 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
Xinput36 mplier[12] VGND VGND VPWR VPWR net36 sky130_fd_sc_hd__clkbuf_4
Xinput25 mcand[31] VGND VGND VPWR VPWR net25 sky130_fd_sc_hd__clkbuf_1
XFILLER_0_64_392 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XFILLER_0_52_554 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
Xinput14 mcand[21] VGND VGND VPWR VPWR net14 sky130_fd_sc_hd__clkbuf_4
XFILLER_0_24_234 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
Xinput47 mplier[22] VGND VGND VPWR VPWR net47 sky130_fd_sc_hd__clkbuf_4
Xinput58 mplier[3] VGND VGND VPWR VPWR net58 sky130_fd_sc_hd__clkbuf_4
X_10528_ _04255_ _04256_ _04287_ VGND VGND VPWR VPWR _04289_ sky130_fd_sc_hd__or3_1
XFILLER_0_107_494 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_52_587 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
X_10459_ _04060_ _04062_ _04212_ _04213_ VGND VGND VPWR VPWR _04214_ sky130_fd_sc_hd__a211o_2
XFILLER_0_20_451 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_58_68 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XTAP_TAPCELL_ROW_84_1308 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_79_429 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
X_07670_ _01167_ _01168_ _00905_ VGND VGND VPWR VPWR _01170_ sky130_fd_sc_hd__a21oi_1
XFILLER_0_90_11 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
X_06621_ _00384_ _00406_ _05541_ _05637_ VGND VGND VPWR VPWR _00049_ sky130_fd_sc_hd__and4_1
XFILLER_0_90_44 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
X_09340_ _02983_ _02990_ _02991_ VGND VGND VPWR VPWR _02992_ sky130_fd_sc_hd__nand3_1
X_06552_ _05675_ _05679_ _05680_ VGND VGND VPWR VPWR _05681_ sky130_fd_sc_hd__and3_1
X_09271_ _02769_ _02789_ _02916_ VGND VGND VPWR VPWR _02918_ sky130_fd_sc_hd__o21ba_1
XFILLER_0_47_337 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_0_117_214 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_06483_ _05610_ _05611_ _05516_ _05518_ VGND VGND VPWR VPWR _05613_ sky130_fd_sc_hd__o211a_1
X_08222_ _00269_ _01588_ _01591_ _01590_ _01603_ VGND VGND VPWR VPWR _01773_ sky130_fd_sc_hd__a32o_1
XFILLER_0_74_189 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_0_62_329 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_16_713 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_0_23_93 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XTAP_TAPCELL_ROW_31_652 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_99_53 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
X_08153_ _01538_ _01539_ _01695_ _01696_ VGND VGND VPWR VPWR _01697_ sky130_fd_sc_hd__a211o_1
XFILLER_0_15_212 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_0_15_223 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_113_431 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
X_07104_ net31 _05423_ _00549_ _00550_ VGND VGND VPWR VPWR _00552_ sky130_fd_sc_hd__o2bb2a_1
X_08084_ _00297_ net27 net49 net50 VGND VGND VPWR VPWR _01622_ sky130_fd_sc_hd__and4_1
XFILLER_0_101_615 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XTAP_TAPCELL_ROW_95_1448 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
X_07035_ _00376_ _00378_ VGND VGND VPWR VPWR _00476_ sky130_fd_sc_hd__nor2_1
XFILLER_0_3_673 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_15_289 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_100_158 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_11_473 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
X_08986_ _02603_ _02604_ _02596_ VGND VGND VPWR VPWR _02606_ sky130_fd_sc_hd__a21o_1
XTAP_TAPCELL_ROW_3_300 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
X_07937_ _01458_ _01459_ _01460_ VGND VGND VPWR VPWR _01462_ sky130_fd_sc_hd__a21o_1
XFILLER_0_3_81 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
X_07868_ _01223_ _01226_ VGND VGND VPWR VPWR _01386_ sky130_fd_sc_hd__nand2_1
XTAP_TAPCELL_ROW_39_752 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
X_09607_ _03583_ _03175_ VGND VGND VPWR VPWR _03284_ sky130_fd_sc_hd__nand2_1
X_06819_ _01486_ _05539_ _05636_ _00493_ VGND VGND VPWR VPWR _00245_ sky130_fd_sc_hd__a22oi_1
X_07799_ _01204_ _01309_ _01310_ VGND VGND VPWR VPWR _01311_ sky130_fd_sc_hd__or3_1
X_09538_ _03206_ _03207_ _03167_ _03169_ VGND VGND VPWR VPWR _03209_ sky130_fd_sc_hd__o211ai_2
XFILLER_0_66_613 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_0_38_304 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XTAP_TAPCELL_ROW_104_1566 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_66_635 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_09469_ _02113_ _00751_ VGND VGND VPWR VPWR _03133_ sky130_fd_sc_hd__nand2_1
XFILLER_0_66_679 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_65_189 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_19_573 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
X_11431_ _05264_ _05257_ VGND VGND VPWR VPWR _05267_ sky130_fd_sc_hd__or2b_1
X_11362_ _05140_ _05178_ VGND VGND VPWR VPWR _05193_ sky130_fd_sc_hd__nand2_1
XTAP_TAPCELL_ROW_59_1001 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_34_587 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
X_10313_ _04051_ _04053_ _04046_ VGND VGND VPWR VPWR _04055_ sky130_fd_sc_hd__a21o_1
X_11293_ _01501_ _04800_ _03807_ _01357_ VGND VGND VPWR VPWR _05119_ sky130_fd_sc_hd__a22oi_2
XFILLER_0_21_248 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XTAP_TAPCELL_ROW_115_1695 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
X_10244_ _03875_ _03893_ _03894_ VGND VGND VPWR VPWR _03980_ sky130_fd_sc_hd__nor3_1
X_10175_ _03902_ _03903_ _03741_ net169 VGND VGND VPWR VPWR _03905_ sky130_fd_sc_hd__a211o_1
XFILLER_0_28_27 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_44_15 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_84_432 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_0_84_421 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_0_69_484 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XTAP_TAPCELL_ROW_17_479 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_29_337 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_56_156 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_4_415 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_0_52_351 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_8_15 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_52_395 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_0_12_215 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_25_587 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_40_557 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_110_445 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_100_97 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_0_643 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
X_08840_ _02426_ _02445_ VGND VGND VPWR VPWR _02446_ sky130_fd_sc_hd__xnor2_2
XTAP_TAPCELL_ROW_90_1389 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_85_55 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_109_51 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
X_05983_ _03365_ _03376_ _03343_ _00526_ VGND VGND VPWR VPWR _03386_ sky130_fd_sc_hd__a22o_1
X_08771_ _02172_ _02198_ _02196_ VGND VGND VPWR VPWR _02373_ sky130_fd_sc_hd__a21bo_2
X_07722_ _05497_ _00143_ _01223_ _01224_ VGND VGND VPWR VPWR _01227_ sky130_fd_sc_hd__a22o_1
X_07653_ _01148_ _01150_ _01134_ VGND VGND VPWR VPWR _01152_ sky130_fd_sc_hd__a21o_1
XTAP_TAPCELL_ROW_36_711 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
X_06604_ _05669_ _05671_ VGND VGND VPWR VPWR _00032_ sky130_fd_sc_hd__or2_1
XFILLER_0_87_281 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
X_09323_ _01588_ _02104_ _00151_ _02459_ VGND VGND VPWR VPWR _02974_ sky130_fd_sc_hd__nand4_2
X_07584_ _05589_ _05557_ _00951_ _00950_ VGND VGND VPWR VPWR _01076_ sky130_fd_sc_hd__a31o_1
XFILLER_0_48_635 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_118_501 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
X_06535_ _05660_ _05661_ _05662_ VGND VGND VPWR VPWR _05664_ sky130_fd_sc_hd__and3_1
X_09254_ _02720_ _02723_ VGND VGND VPWR VPWR _02900_ sky130_fd_sc_hd__nor2_1
X_06466_ _05592_ _05594_ _05595_ VGND VGND VPWR VPWR _05596_ sky130_fd_sc_hd__nand3_1
XFILLER_0_47_167 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_47_189 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_118_589 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
X_09185_ _02637_ _02649_ _02648_ VGND VGND VPWR VPWR _02824_ sky130_fd_sc_hd__a21bo_1
XFILLER_0_7_242 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
X_08205_ _01751_ _01752_ _01566_ net163 VGND VGND VPWR VPWR _01754_ sky130_fd_sc_hd__a211o_1
X_08136_ _01677_ VGND VGND VPWR VPWR _01678_ sky130_fd_sc_hd__inv_2
X_06397_ _05526_ _05527_ VGND VGND VPWR VPWR _05528_ sky130_fd_sc_hd__or2_1
XFILLER_0_113_272 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_08067_ _00688_ VGND VGND VPWR VPWR _01603_ sky130_fd_sc_hd__buf_4
XFILLER_0_3_470 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_0_31_546 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
X_07018_ _00455_ _00456_ _00255_ _00338_ VGND VGND VPWR VPWR _00458_ sky130_fd_sc_hd__o211ai_2
X_08969_ _03616_ _02045_ VGND VGND VPWR VPWR _02587_ sky130_fd_sc_hd__nand2_1
XFILLER_0_98_513 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
X_10931_ _04704_ VGND VGND VPWR VPWR _04727_ sky130_fd_sc_hd__inv_2
XFILLER_0_86_719 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
X_10862_ _00753_ _03297_ _04649_ _04651_ VGND VGND VPWR VPWR _04652_ sky130_fd_sc_hd__a22o_1
XFILLER_0_66_421 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_0_14_29 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
X_10793_ _04556_ _04480_ _04576_ VGND VGND VPWR VPWR _04577_ sky130_fd_sc_hd__a21oi_1
XFILLER_0_109_523 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XTAP_TAPCELL_ROW_65_1071 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_81_424 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XFILLER_0_54_616 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XTAP_TAPCELL_ROW_14_438 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_26_307 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_38_167 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_11414_ _05247_ _05248_ VGND VGND VPWR VPWR _05249_ sky130_fd_sc_hd__xnor2_1
XTAP_TAPCELL_ROW_117_1724 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_34_395 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XFILLER_0_104_261 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
X_11345_ _05013_ _05085_ _05117_ _05135_ VGND VGND VPWR VPWR _05175_ sky130_fd_sc_hd__a31o_1
XFILLER_0_10_719 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_22_546 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_39_15 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
X_11276_ _05099_ _05100_ VGND VGND VPWR VPWR _05101_ sky130_fd_sc_hd__nor2_2
XFILLER_0_39_48 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_10227_ _00151_ _00236_ _01800_ _02516_ VGND VGND VPWR VPWR _03961_ sky130_fd_sc_hd__nand4_1
X_10158_ _03877_ _03884_ _03885_ VGND VGND VPWR VPWR _03886_ sky130_fd_sc_hd__nand3_4
X_10089_ _03806_ _03809_ VGND VGND VPWR VPWR _03810_ sky130_fd_sc_hd__xnor2_1
XFILLER_0_89_513 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_0_55_69 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XFILLER_0_89_535 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_57_421 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_71_57 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_84_251 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_17_329 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
X_06320_ _05266_ _05369_ _05451_ VGND VGND VPWR VPWR _05452_ sky130_fd_sc_hd__o21a_1
X_06251_ _05312_ _05314_ _05316_ VGND VGND VPWR VPWR _05383_ sky130_fd_sc_hd__or3b_2
XTAP_TAPCELL_ROW_41_780 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
X_06182_ _05312_ _05314_ VGND VGND VPWR VPWR _05315_ sky130_fd_sc_hd__or2_1
XFILLER_0_52_170 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_13_513 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_13_535 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_20_61 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
Xmax_cap144 _04082_ VGND VGND VPWR VPWR net144 sky130_fd_sc_hd__buf_1
XTAP_TAPCELL_ROW_92_1418 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_92_1407 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_52_181 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
Xmax_cap133 _02031_ VGND VGND VPWR VPWR net133 sky130_fd_sc_hd__clkbuf_1
X_09941_ _03603_ _03604_ _03646_ _03647_ VGND VGND VPWR VPWR _03650_ sky130_fd_sc_hd__o22a_1
Xmax_cap166 _01826_ VGND VGND VPWR VPWR net166 sky130_fd_sc_hd__clkbuf_1
Xmax_cap155 _01575_ VGND VGND VPWR VPWR net155 sky130_fd_sc_hd__buf_1
XFILLER_0_40_365 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_110_253 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
X_09872_ _02141_ VGND VGND VPWR VPWR _03574_ sky130_fd_sc_hd__buf_4
X_08823_ _02258_ _02260_ VGND VGND VPWR VPWR _02428_ sky130_fd_sc_hd__nand2_1
X_08754_ _02349_ _02352_ _02346_ VGND VGND VPWR VPWR _02354_ sky130_fd_sc_hd__a21o_1
XFILLER_0_31_3 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
X_05966_ net27 VGND VGND VPWR VPWR _03201_ sky130_fd_sc_hd__clkbuf_4
X_07705_ _00810_ net14 _00611_ _00559_ VGND VGND VPWR VPWR _01208_ sky130_fd_sc_hd__a22o_1
X_08685_ _04998_ _05008_ _00612_ VGND VGND VPWR VPWR _02278_ sky130_fd_sc_hd__and3_1
XFILLER_0_68_719 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XTAP_TAPCELL_ROW_49_880 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
X_05897_ net1 VGND VGND VPWR VPWR _02447_ sky130_fd_sc_hd__clkbuf_8
XFILLER_0_95_538 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_07636_ _00961_ _00964_ VGND VGND VPWR VPWR _01133_ sky130_fd_sc_hd__nand2_1
XFILLER_0_48_421 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
X_07567_ _01034_ _01056_ VGND VGND VPWR VPWR _01057_ sky130_fd_sc_hd__xor2_1
XTAP_TAPCELL_ROW_101_1525 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
X_09306_ _02778_ _02780_ _02954_ _02955_ VGND VGND VPWR VPWR _02956_ sky130_fd_sc_hd__a211o_1
X_06518_ _05634_ _05571_ _05645_ VGND VGND VPWR VPWR _05647_ sky130_fd_sc_hd__and3_1
XFILLER_0_48_465 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_106_504 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
X_09237_ _02878_ _02879_ _02871_ VGND VGND VPWR VPWR _02881_ sky130_fd_sc_hd__a21o_1
X_07498_ _00963_ _03201_ _00430_ _00565_ VGND VGND VPWR VPWR _00982_ sky130_fd_sc_hd__and4_1
XFILLER_0_106_526 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
X_06449_ _04726_ _03080_ _05577_ _05578_ VGND VGND VPWR VPWR _05579_ sky130_fd_sc_hd__a22o_1
X_09168_ _01759_ _00355_ _02802_ _02803_ VGND VGND VPWR VPWR _02805_ sky130_fd_sc_hd__a22o_1
XFILLER_0_44_682 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
X_09099_ _02558_ _02555_ VGND VGND VPWR VPWR _02730_ sky130_fd_sc_hd__or2b_1
X_08119_ _01478_ net131 _01658_ _01659_ VGND VGND VPWR VPWR _01660_ sky130_fd_sc_hd__o211ai_4
X_11130_ _00754_ _04873_ VGND VGND VPWR VPWR _04942_ sky130_fd_sc_hd__nand2_1
XFILLER_0_101_231 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
X_11061_ _04714_ _04715_ _04794_ _04865_ _04721_ VGND VGND VPWR VPWR _04869_ sky130_fd_sc_hd__o32ai_2
XTAP_TAPCELL_ROW_112_1665 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
X_10012_ _03719_ _03724_ _03726_ VGND VGND VPWR VPWR _03727_ sky130_fd_sc_hd__nand3_1
XTAP_TAPCELL_ROW_67_1100 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_98_365 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
X_10914_ _04707_ _04708_ VGND VGND VPWR VPWR _04709_ sky130_fd_sc_hd__nor2_1
XFILLER_0_86_527 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
X_10845_ _04632_ _04633_ VGND VGND VPWR VPWR _04634_ sky130_fd_sc_hd__or2_1
XTAP_TAPCELL_ROW_27_596 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_39_432 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_0_39_443 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_0_94_582 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_0_94_571 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_66_273 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XPHY_EDGE_ROW_4_Left_126 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
X_10776_ _00748_ _01980_ _02178_ _00747_ VGND VGND VPWR VPWR _04558_ sky130_fd_sc_hd__a22o_1
XFILLER_0_54_446 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_26_137 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_0_39_498 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_0_42_619 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_35_671 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XTAP_TAPCELL_ROW_78_1240 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_22_343 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
X_11328_ _05124_ _05123_ VGND VGND VPWR VPWR _05156_ sky130_fd_sc_hd__or2b_1
XFILLER_0_120_562 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_0_5_27 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
X_11259_ _05007_ _05010_ _05081_ VGND VGND VPWR VPWR _05082_ sky130_fd_sc_hd__o21a_1
X_05820_ net27 VGND VGND VPWR VPWR _01607_ sky130_fd_sc_hd__clkbuf_4
XTAP_TAPCELL_ROW_89_1380 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
X_05751_ net59 VGND VGND VPWR VPWR _00854_ sky130_fd_sc_hd__buf_2
XFILLER_0_106_41 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_77_516 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
X_08470_ _01247_ _02041_ _01854_ _01851_ _01354_ VGND VGND VPWR VPWR _02042_ sky130_fd_sc_hd__a32o_1
X_07421_ _00746_ _00752_ _01171_ _00896_ VGND VGND VPWR VPWR _00898_ sky130_fd_sc_hd__o211a_2
XFILLER_0_57_251 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XFILLER_0_9_337 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_0_18_605 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
X_07352_ _03080_ _00189_ _00820_ _00822_ VGND VGND VPWR VPWR _00823_ sky130_fd_sc_hd__nand4_1
XFILLER_0_72_221 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XFILLER_0_18_638 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_0_18_649 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
X_06303_ _05432_ _05433_ _05434_ VGND VGND VPWR VPWR _05435_ sky130_fd_sc_hd__and3_2
X_07283_ _00494_ VGND VGND VPWR VPWR _00747_ sky130_fd_sc_hd__clkbuf_4
XFILLER_0_45_468 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_115_367 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_115_334 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
X_09022_ _00143_ VGND VGND VPWR VPWR _02646_ sky130_fd_sc_hd__buf_4
XFILLER_0_60_416 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_0_26_671 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
X_06234_ _04650_ _05366_ VGND VGND VPWR VPWR _05367_ sky130_fd_sc_hd__xor2_2
X_06165_ _04390_ _04412_ _04379_ VGND VGND VPWR VPWR _05299_ sky130_fd_sc_hd__o21ba_1
XFILLER_0_13_354 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
X_06096_ _00406_ _04596_ _04563_ _04574_ VGND VGND VPWR VPWR _04618_ sky130_fd_sc_hd__o2bb2a_1
XFILLER_0_40_184 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
X_09924_ _03625_ _03629_ _03630_ VGND VGND VPWR VPWR _03631_ sky130_fd_sc_hd__nand3_4
X_09855_ _03552_ _03553_ _03536_ VGND VGND VPWR VPWR _03555_ sky130_fd_sc_hd__a21oi_1
X_08806_ _02243_ _02244_ VGND VGND VPWR VPWR _02409_ sky130_fd_sc_hd__or2b_1
X_09786_ _05574_ _03478_ _03246_ _03479_ VGND VGND VPWR VPWR _03480_ sky130_fd_sc_hd__a31o_2
X_06998_ _00433_ _00434_ _00435_ VGND VGND VPWR VPWR _00436_ sky130_fd_sc_hd__nand3_1
X_08737_ _02332_ _02333_ _02144_ _02145_ VGND VGND VPWR VPWR _02335_ sky130_fd_sc_hd__o211ai_2
X_05949_ _03004_ VGND VGND VPWR VPWR _03015_ sky130_fd_sc_hd__clkbuf_4
XFILLER_0_95_302 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
X_08668_ _04889_ _01187_ _02257_ _02258_ VGND VGND VPWR VPWR _02259_ sky130_fd_sc_hd__a22o_1
XTAP_TAPCELL_ROW_44_809 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XPHY_EDGE_ROW_77_Left_199 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_0_68_549 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
X_07619_ net50 VGND VGND VPWR VPWR _01114_ sky130_fd_sc_hd__clkbuf_4
X_10630_ _02105_ _01856_ _04398_ _04399_ VGND VGND VPWR VPWR _04400_ sky130_fd_sc_hd__o2bb2a_1
X_08599_ _03321_ _01987_ net57 _00799_ VGND VGND VPWR VPWR _02184_ sky130_fd_sc_hd__a22o_1
XFILLER_0_119_673 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XTAP_TAPCELL_ROW_62_1041 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_24_566 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
X_10561_ _04214_ _04217_ _04323_ _04324_ VGND VGND VPWR VPWR _04326_ sky130_fd_sc_hd__a211o_2
XFILLER_0_106_323 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
X_10492_ _04200_ _04202_ VGND VGND VPWR VPWR _04250_ sky130_fd_sc_hd__and2_1
XFILLER_0_118_194 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XFILLER_0_51_449 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XFILLER_0_121_337 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XFILLER_0_102_573 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
X_11113_ _04923_ _04924_ VGND VGND VPWR VPWR _04925_ sky130_fd_sc_hd__or2_1
X_11044_ _04780_ _04849_ VGND VGND VPWR VPWR _04850_ sky130_fd_sc_hd__nand2_1
XTAP_TAPCELL_ROW_73_1170 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_36_27 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XPHY_EDGE_ROW_101_Right_101 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_0_99_663 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_99_685 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_59_549 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_0_52_26 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XFILLER_0_116_109 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
X_10828_ _04612_ _04613_ _04512_ _04597_ VGND VGND VPWR VPWR _04615_ sky130_fd_sc_hd__a211oi_2
XFILLER_0_27_424 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
X_10759_ _04538_ _04539_ VGND VGND VPWR VPWR _04540_ sky130_fd_sc_hd__nor2_2
XFILLER_0_82_541 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_27_457 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_0_109_194 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XFILLER_0_42_427 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_2_557 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_23_685 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_22_195 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_120_381 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_10_346 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
X_07970_ _01349_ _01351_ VGND VGND VPWR VPWR _01496_ sky130_fd_sc_hd__or2b_1
X_06921_ _00461_ _00348_ _00350_ _01236_ VGND VGND VPWR VPWR _00352_ sky130_fd_sc_hd__a22o_1
XFILLER_0_93_55 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
X_09640_ _03185_ _03199_ _03200_ VGND VGND VPWR VPWR _03320_ sky130_fd_sc_hd__nand3_1
X_06852_ _00262_ _00263_ _00277_ VGND VGND VPWR VPWR _00278_ sky130_fd_sc_hd__a21o_2
XFILLER_0_117_51 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
X_09571_ _05574_ _02041_ _03087_ _03086_ _01355_ VGND VGND VPWR VPWR _03245_ sky130_fd_sc_hd__a32o_2
X_05803_ _01400_ _01411_ VGND VGND VPWR VPWR _01422_ sky130_fd_sc_hd__and2b_1
X_06783_ _00207_ _00208_ _00186_ VGND VGND VPWR VPWR _00210_ sky130_fd_sc_hd__a21oi_2
X_05734_ net58 VGND VGND VPWR VPWR _00668_ sky130_fd_sc_hd__clkbuf_4
X_08522_ _02095_ _02096_ _02097_ VGND VGND VPWR VPWR _02100_ sky130_fd_sc_hd__a21o_1
X_08453_ _01660_ _01663_ _01842_ VGND VGND VPWR VPWR _02025_ sky130_fd_sc_hd__a21o_1
XFILLER_0_92_316 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
X_07404_ _00728_ _00879_ _00731_ _00733_ VGND VGND VPWR VPWR _00880_ sky130_fd_sc_hd__o22a_1
XFILLER_0_46_711 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_9_167 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
X_08384_ _00565_ VGND VGND VPWR VPWR _01949_ sky130_fd_sc_hd__buf_4
XFILLER_0_116_610 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_61_703 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_18_457 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XTAP_TAPCELL_ROW_21_525 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
X_07335_ _05304_ _04074_ _05423_ _00086_ VGND VGND VPWR VPWR _00804_ sky130_fd_sc_hd__nand4_4
XFILLER_0_42_81 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
X_07266_ _00594_ _00595_ VGND VGND VPWR VPWR _00729_ sky130_fd_sc_hd__nand2_1
XFILLER_0_103_304 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
X_09005_ _00294_ _00343_ _00345_ _00421_ VGND VGND VPWR VPWR _02627_ sky130_fd_sc_hd__a22o_1
XFILLER_0_60_246 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
X_06217_ _05347_ _05348_ _05349_ VGND VGND VPWR VPWR _05350_ sky130_fd_sc_hd__nand3_2
XFILLER_0_115_186 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_103_337 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_13_151 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
X_07197_ _00553_ _00547_ VGND VGND VPWR VPWR _00653_ sky130_fd_sc_hd__and2b_1
X_06148_ _03965_ _04683_ _05159_ _05170_ VGND VGND VPWR VPWR _05181_ sky130_fd_sc_hd__o211ai_2
X_06079_ _04270_ _04281_ _04303_ VGND VGND VPWR VPWR _04433_ sky130_fd_sc_hd__a21oi_1
X_09907_ _03469_ _03471_ VGND VGND VPWR VPWR _03612_ sky130_fd_sc_hd__or2_1
X_09838_ _03583_ _03175_ VGND VGND VPWR VPWR _03536_ sky130_fd_sc_hd__and2_1
X_09769_ _03417_ _03418_ _03459_ _03460_ VGND VGND VPWR VPWR _03461_ sky130_fd_sc_hd__and4_1
XPHY_EDGE_ROW_85_Left_207 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XTAP_TAPCELL_ROW_29_625 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_57_978 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_1_272 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_107_1597 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_96_699 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_95_187 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XFILLER_0_22_29 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XTAP_TAPCELL_ROW_120_1764 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
X_10613_ _00356_ _03440_ _04278_ _04279_ VGND VGND VPWR VPWR _04382_ sky130_fd_sc_hd__and4_1
XFILLER_0_64_563 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
X_10544_ _02302_ _03478_ _04198_ _04306_ VGND VGND VPWR VPWR _04307_ sky130_fd_sc_hd__a31o_1
XPHY_EDGE_ROW_94_Left_216 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_0_91_393 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
X_10475_ _04188_ _04230_ _04231_ VGND VGND VPWR VPWR _04232_ sky130_fd_sc_hd__or3_4
XFILLER_0_106_197 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XTAP_TAPCELL_ROW_9_372 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_20_699 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
X_11027_ _03012_ _01353_ _03238_ _03006_ VGND VGND VPWR VPWR _04831_ sky130_fd_sc_hd__a22o_1
XFILLER_0_87_633 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_59_368 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XANTENNA_17 _03759_ VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XANTENNA_28 net18 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XANTENNA_39 net116 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
X_07120_ _00566_ _00567_ _00564_ VGND VGND VPWR VPWR _00569_ sky130_fd_sc_hd__a21o_1
XFILLER_0_27_287 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XFILLER_0_70_533 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_15_438 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_15_449 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_88_33 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
X_07051_ net14 VGND VGND VPWR VPWR _00494_ sky130_fd_sc_hd__clkbuf_4
Xoutput124 net124 VGND VGND VPWR VPWR product[63] sky130_fd_sc_hd__buf_2
X_06002_ _01247_ _03583_ _03135_ _03113_ VGND VGND VPWR VPWR _03594_ sky130_fd_sc_hd__a31o_1
Xoutput102 net102 VGND VGND VPWR VPWR product[43] sky130_fd_sc_hd__clkbuf_4
Xoutput113 net113 VGND VGND VPWR VPWR product[53] sky130_fd_sc_hd__buf_2
XFILLER_0_112_178 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_50_290 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XFILLER_0_11_655 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
X_07953_ _01475_ _01477_ _01309_ _01331_ VGND VGND VPWR VPWR _01479_ sky130_fd_sc_hd__a211oi_1
X_07884_ _01401_ _01402_ _01364_ _01365_ VGND VGND VPWR VPWR _01404_ sky130_fd_sc_hd__o211a_1
X_06904_ _00121_ _00224_ _00223_ VGND VGND VPWR VPWR _00334_ sky130_fd_sc_hd__a21oi_1
X_09623_ _05311_ _03297_ _03298_ _03300_ VGND VGND VPWR VPWR _03302_ sky130_fd_sc_hd__and4_1
X_06835_ _00165_ _00172_ VGND VGND VPWR VPWR _00261_ sky130_fd_sc_hd__and2_1
XFILLER_0_37_92 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
X_09554_ _03065_ _03067_ VGND VGND VPWR VPWR _03227_ sky130_fd_sc_hd__or2_1
XFILLER_0_77_121 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XTAP_TAPCELL_ROW_54_937 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
X_06766_ _00188_ _00192_ VGND VGND VPWR VPWR _00193_ sky130_fd_sc_hd__xnor2_2
XFILLER_0_93_614 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
X_09485_ _00034_ _02321_ _03149_ _03150_ VGND VGND VPWR VPWR _03151_ sky130_fd_sc_hd__a22o_1
XFILLER_0_78_677 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
X_05717_ _00439_ _00472_ VGND VGND VPWR VPWR _00482_ sky130_fd_sc_hd__nand2_1
X_08505_ _01933_ _01936_ _02079_ _02080_ VGND VGND VPWR VPWR _02081_ sky130_fd_sc_hd__a211oi_2
X_06697_ _05526_ _05629_ _00023_ _00124_ VGND VGND VPWR VPWR _00125_ sky130_fd_sc_hd__a31o_1
X_08436_ _02003_ _02004_ _01964_ VGND VGND VPWR VPWR _02006_ sky130_fd_sc_hd__o21ai_2
X_08367_ _01916_ _01929_ _01930_ VGND VGND VPWR VPWR _01931_ sky130_fd_sc_hd__and3_2
XTAP_TAPCELL_ROW_34_683 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_92_179 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XFILLER_0_61_511 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
X_07318_ _00782_ _00783_ _00769_ VGND VGND VPWR VPWR _00785_ sky130_fd_sc_hd__a21o_1
X_08298_ _01850_ _01851_ _01854_ VGND VGND VPWR VPWR _01855_ sky130_fd_sc_hd__a21bo_1
XFILLER_0_33_246 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_6_693 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_0_5_181 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
X_07249_ _00707_ _00708_ _00685_ VGND VGND VPWR VPWR _00710_ sky130_fd_sc_hd__a21oi_2
X_10260_ _03820_ _03830_ _03829_ VGND VGND VPWR VPWR _03997_ sky130_fd_sc_hd__a21o_1
XFILLER_0_14_493 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
X_10191_ _03920_ _03921_ VGND VGND VPWR VPWR _03923_ sky130_fd_sc_hd__nand2_2
XTAP_TAPCELL_ROW_70_1140 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_6_342 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_6_331 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_109_1626 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_69_611 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_0_68_165 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_0_33_39 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_83_124 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_0_83_113 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_0_83_146 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XTAP_TAPCELL_ROW_81_1280 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_71_319 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_37_585 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_52_522 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
Xinput15 mcand[22] VGND VGND VPWR VPWR net15 sky130_fd_sc_hd__clkbuf_2
Xinput26 mcand[3] VGND VGND VPWR VPWR net26 sky130_fd_sc_hd__buf_1
Xinput37 mplier[13] VGND VGND VPWR VPWR net37 sky130_fd_sc_hd__buf_4
Xinput48 mplier[23] VGND VGND VPWR VPWR net48 sky130_fd_sc_hd__buf_2
X_10527_ _04255_ _04256_ _04287_ VGND VGND VPWR VPWR _04288_ sky130_fd_sc_hd__o21ai_2
Xinput59 mplier[4] VGND VGND VPWR VPWR net59 sky130_fd_sc_hd__buf_2
XFILLER_0_52_566 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
X_10458_ _01604_ _02064_ _04210_ _04211_ VGND VGND VPWR VPWR _04213_ sky130_fd_sc_hd__and4_1
XFILLER_0_110_638 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
X_10389_ _01249_ _02230_ _03993_ VGND VGND VPWR VPWR _04138_ sky130_fd_sc_hd__and3_1
XFILLER_0_79_408 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
X_06620_ _00046_ _00047_ VGND VGND VPWR VPWR _00048_ sky130_fd_sc_hd__nor2_2
XTAP_TAPCELL_ROW_84_1309 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_59_121 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
X_06551_ _04922_ _05410_ _05677_ _05678_ VGND VGND VPWR VPWR _05680_ sky130_fd_sc_hd__nand4_1
XFILLER_0_114_41 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
X_09270_ _02787_ _02788_ VGND VGND VPWR VPWR _02916_ sky130_fd_sc_hd__nor2_1
XFILLER_0_59_198 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
X_06482_ _05516_ _05518_ _05610_ _05611_ VGND VGND VPWR VPWR _05612_ sky130_fd_sc_hd__a211oi_4
XFILLER_0_114_85 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_75_669 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_0_74_157 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
X_08221_ _01768_ _01769_ _01767_ VGND VGND VPWR VPWR _01772_ sky130_fd_sc_hd__a21o_1
XFILLER_0_117_259 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XFILLER_0_7_435 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_28_574 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XTAP_TAPCELL_ROW_31_653 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_43_500 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
X_08152_ _00908_ net19 _01692_ _01693_ VGND VGND VPWR VPWR _01696_ sky130_fd_sc_hd__and4_1
XFILLER_0_55_393 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_0_70_363 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_15_246 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
X_07103_ _00549_ _00550_ net31 _05423_ VGND VGND VPWR VPWR _00551_ sky130_fd_sc_hd__and4bb_1
X_08083_ _01662_ _01620_ VGND VGND VPWR VPWR _01621_ sky130_fd_sc_hd__nand2_1
XFILLER_0_113_454 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_113_443 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XTAP_TAPCELL_ROW_95_1449 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_70_385 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
X_07034_ _00223_ _00333_ _00463_ VGND VGND VPWR VPWR _00475_ sky130_fd_sc_hd__nand3_1
XFILLER_0_3_641 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_15_279 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_30_205 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_0_3_685 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_2_195 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
X_08985_ _02596_ _02603_ _02604_ VGND VGND VPWR VPWR _02605_ sky130_fd_sc_hd__nand3_1
XTAP_TAPCELL_ROW_3_301 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
X_07936_ _01458_ _01459_ _01460_ VGND VGND VPWR VPWR _01461_ sky130_fd_sc_hd__nand3_4
XTAP_TAPCELL_ROW_39_753 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
X_07867_ _01383_ _01384_ VGND VGND VPWR VPWR _01385_ sky130_fd_sc_hd__or2_2
X_09606_ _03583_ _02864_ _02866_ _02251_ VGND VGND VPWR VPWR _03283_ sky130_fd_sc_hd__a22o_1
X_06818_ _00559_ _00581_ _00035_ _05635_ VGND VGND VPWR VPWR _00244_ sky130_fd_sc_hd__and4_1
X_07798_ _01307_ _01308_ _01158_ _01161_ VGND VGND VPWR VPWR _01310_ sky130_fd_sc_hd__o211a_1
XFILLER_0_3_93 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_78_441 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
X_09537_ _03167_ _03169_ _03206_ _03207_ VGND VGND VPWR VPWR _03208_ sky130_fd_sc_hd__a211o_2
X_06749_ _00158_ _00174_ _00175_ VGND VGND VPWR VPWR _00176_ sky130_fd_sc_hd__and3_1
XTAP_TAPCELL_ROW_104_1567 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_104_1556 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_65_113 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_09468_ _01898_ _03130_ _03131_ VGND VGND VPWR VPWR _03132_ sky130_fd_sc_hd__a21bo_1
XFILLER_0_65_135 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_0_93_477 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_0_81_617 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_80_105 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
X_09399_ _02894_ _02897_ VGND VGND VPWR VPWR _03057_ sky130_fd_sc_hd__nor2_1
X_08419_ net56 VGND VGND VPWR VPWR _01987_ sky130_fd_sc_hd__buf_2
X_11430_ _05257_ _05264_ VGND VGND VPWR VPWR _05265_ sky130_fd_sc_hd__or2b_1
XFILLER_0_80_127 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_74_691 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_34_533 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_11361_ _05188_ _05191_ VGND VGND VPWR VPWR net118 sky130_fd_sc_hd__xor2_4
XTAP_TAPCELL_ROW_59_1002 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_104_443 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
X_10312_ _04046_ _04051_ _04053_ VGND VGND VPWR VPWR _04054_ sky130_fd_sc_hd__nand3_1
XFILLER_0_61_374 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_21_216 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_11292_ _05113_ _05117_ VGND VGND VPWR VPWR _05118_ sky130_fd_sc_hd__xor2_1
XTAP_TAPCELL_ROW_115_1696 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
X_10243_ _03855_ _03975_ _03977_ VGND VGND VPWR VPWR _03979_ sky130_fd_sc_hd__and3_1
X_10174_ _03741_ net137 _03902_ _03903_ VGND VGND VPWR VPWR _03904_ sky130_fd_sc_hd__o211ai_4
XFILLER_0_89_717 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_0_88_205 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XFILLER_0_44_27 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_69_463 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XTAP_TAPCELL_ROW_17_469 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_29_349 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_84_499 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_84_477 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_71_105 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_0_60_59 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XFILLER_0_114_207 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_37_393 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_0_107_281 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_0_8_27 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_13_717 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_0_25_566 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_69_57 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_69_79 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_40_569 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_0_0_688 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
X_05982_ net63 VGND VGND VPWR VPWR _03376_ sky130_fd_sc_hd__clkbuf_4
X_08770_ _02356_ _02370_ VGND VGND VPWR VPWR _02371_ sky130_fd_sc_hd__xnor2_4
XFILLER_0_79_205 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_18_83 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
X_07721_ _05497_ _00041_ _01223_ _01224_ VGND VGND VPWR VPWR _01226_ sky130_fd_sc_hd__nand4_2
X_07652_ _01134_ _01148_ _01150_ VGND VGND VPWR VPWR _01151_ sky130_fd_sc_hd__nand3_2
XTAP_TAPCELL_ROW_36_712 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_95_709 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_06603_ _05648_ _00014_ _00015_ VGND VGND VPWR VPWR _00031_ sky130_fd_sc_hd__nor3_1
X_07583_ _00931_ _00933_ VGND VGND VPWR VPWR _01075_ sky130_fd_sc_hd__nand2_1
X_09322_ _00558_ _00343_ _00236_ _01588_ VGND VGND VPWR VPWR _02973_ sky130_fd_sc_hd__a22o_1
X_06534_ _05660_ _05661_ _05662_ VGND VGND VPWR VPWR _05663_ sky130_fd_sc_hd__a21oi_1
XFILLER_0_47_113 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_118_524 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_87_293 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_0_47_135 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
X_09253_ _02792_ _02898_ VGND VGND VPWR VPWR _02899_ sky130_fd_sc_hd__xor2_4
XFILLER_0_63_617 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
X_06465_ _03310_ _03365_ _05502_ _05593_ VGND VGND VPWR VPWR _05595_ sky130_fd_sc_hd__nand4_2
XFILLER_0_35_319 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
X_09184_ _02820_ _02821_ _02811_ VGND VGND VPWR VPWR _02823_ sky130_fd_sc_hd__a21o_1
X_08204_ _01566_ _01568_ _01751_ _01752_ VGND VGND VPWR VPWR _01753_ sky130_fd_sc_hd__o211ai_4
XFILLER_0_16_511 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
X_06396_ _05524_ _05525_ VGND VGND VPWR VPWR _05527_ sky130_fd_sc_hd__nor2_1
X_08135_ _00690_ _00362_ _01674_ _01499_ VGND VGND VPWR VPWR _01677_ sky130_fd_sc_hd__and4_1
XFILLER_0_113_251 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_08066_ _01440_ _01461_ _01462_ VGND VGND VPWR VPWR _01602_ sky130_fd_sc_hd__nand3_2
XFILLER_0_101_457 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
X_07017_ _00255_ _00338_ _00455_ _00456_ VGND VGND VPWR VPWR _00457_ sky130_fd_sc_hd__a211o_1
XFILLER_0_3_482 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_08968_ _02584_ _02585_ VGND VGND VPWR VPWR _02586_ sky130_fd_sc_hd__xnor2_1
X_08899_ _02334_ _02336_ _02509_ _02510_ VGND VGND VPWR VPWR _02511_ sky130_fd_sc_hd__a211o_1
X_07919_ _01662_ _01441_ VGND VGND VPWR VPWR _01442_ sky130_fd_sc_hd__nand2_1
X_10930_ _03433_ _04724_ _04673_ VGND VGND VPWR VPWR _04725_ sky130_fd_sc_hd__and3_1
XFILLER_0_98_525 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
X_10861_ _03323_ _00914_ _02178_ _03171_ VGND VGND VPWR VPWR _04651_ sky130_fd_sc_hd__nand4_4
XFILLER_0_39_625 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
X_10792_ _04573_ _04575_ VGND VGND VPWR VPWR _04576_ sky130_fd_sc_hd__or2_1
XTAP_TAPCELL_ROW_65_1072 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_109_535 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XTAP_TAPCELL_ROW_14_439 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_66_499 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_0_19_393 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_0_30_29 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
X_11413_ _05207_ _05208_ _05206_ VGND VGND VPWR VPWR _05248_ sky130_fd_sc_hd__o21a_1
XFILLER_0_81_469 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XFILLER_0_62_650 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_117_590 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XTAP_TAPCELL_ROW_117_1725 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_62_683 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_22_503 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
X_11344_ _05114_ _05173_ VGND VGND VPWR VPWR _05174_ sky130_fd_sc_hd__xnor2_1
XFILLER_0_22_558 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_0_22_569 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
X_11275_ _05097_ _05098_ VGND VGND VPWR VPWR _05100_ sky130_fd_sc_hd__and2_1
XFILLER_0_39_27 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_10226_ _00345_ _01798_ _02516_ _00343_ VGND VGND VPWR VPWR _03960_ sky130_fd_sc_hd__a22o_1
X_10157_ _03882_ _03883_ _03879_ VGND VGND VPWR VPWR _03885_ sky130_fd_sc_hd__a21o_1
X_10088_ _04596_ _02866_ _03808_ VGND VGND VPWR VPWR _03809_ sky130_fd_sc_hd__and3_1
XFILLER_0_77_709 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_0_69_271 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_0_69_260 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_0_71_69 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_57_455 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_29_113 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_0_84_263 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
X_06250_ _05360_ VGND VGND VPWR VPWR _05382_ sky130_fd_sc_hd__inv_2
XFILLER_0_44_116 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_0_45_639 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_95_9 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_0_53_650 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_0_25_330 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XTAP_TAPCELL_ROW_41_770 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_111_53 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
X_06181_ _01247_ _04596_ _05313_ _05309_ VGND VGND VPWR VPWR _05314_ sky130_fd_sc_hd__a22oi_1
XFILLER_0_13_503 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XTAP_TAPCELL_ROW_92_1408 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
Xmax_cap134 net135 VGND VGND VPWR VPWR net134 sky130_fd_sc_hd__clkbuf_1
XFILLER_0_110_210 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
X_09940_ _03603_ _03604_ _03646_ _03647_ VGND VGND VPWR VPWR _03648_ sky130_fd_sc_hd__nor4_1
Xmax_cap167 _01190_ VGND VGND VPWR VPWR net167 sky130_fd_sc_hd__buf_1
Xmax_cap156 _01405_ VGND VGND VPWR VPWR net156 sky130_fd_sc_hd__buf_1
Xmax_cap145 _01889_ VGND VGND VPWR VPWR net145 sky130_fd_sc_hd__buf_1
XFILLER_0_40_377 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XPHY_EDGE_ROW_115_Right_115 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_0_110_265 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
X_09871_ _02321_ _02626_ _03570_ _03571_ VGND VGND VPWR VPWR _03573_ sky130_fd_sc_hd__a22o_1
XFILLER_0_0_474 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
X_08822_ _02283_ _02293_ _02292_ VGND VGND VPWR VPWR _02427_ sky130_fd_sc_hd__a21oi_1
X_08753_ _02346_ _02349_ _02352_ VGND VGND VPWR VPWR _02353_ sky130_fd_sc_hd__and3_1
X_05965_ _03168_ _03179_ VGND VGND VPWR VPWR _03190_ sky130_fd_sc_hd__xor2_1
X_07704_ _00832_ _00854_ _00611_ VGND VGND VPWR VPWR _01207_ sky130_fd_sc_hd__and3_1
XTAP_TAPCELL_ROW_49_870 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_24_3 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
X_08684_ _02117_ _02118_ _02119_ _02123_ VGND VGND VPWR VPWR _02277_ sky130_fd_sc_hd__a31o_2
X_05896_ _00428_ _01508_ VGND VGND VPWR VPWR _02436_ sky130_fd_sc_hd__and2_1
XFILLER_0_67_219 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
X_07635_ _01129_ _01130_ _01003_ _01005_ VGND VGND VPWR VPWR _01132_ sky130_fd_sc_hd__a211oi_2
X_07566_ _01036_ _01055_ VGND VGND VPWR VPWR _01056_ sky130_fd_sc_hd__xnor2_1
XTAP_TAPCELL_ROW_101_1526 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_75_241 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
X_09305_ _02952_ _02953_ _02937_ VGND VGND VPWR VPWR _02955_ sky130_fd_sc_hd__a21oi_2
X_06517_ _05634_ _05571_ _05645_ VGND VGND VPWR VPWR _05646_ sky130_fd_sc_hd__a21oi_1
XFILLER_0_118_365 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
X_09236_ _02871_ _02878_ _02879_ VGND VGND VPWR VPWR _02880_ sky130_fd_sc_hd__nand3_1
X_07497_ _00971_ _00980_ VGND VGND VPWR VPWR _00981_ sky130_fd_sc_hd__xnor2_1
XFILLER_0_90_266 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XPHY_EDGE_ROW_17_Right_17 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
X_06448_ _01771_ _02219_ _02458_ _05416_ VGND VGND VPWR VPWR _05578_ sky130_fd_sc_hd__nand4_2
XFILLER_0_44_661 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
X_09167_ _02302_ _02626_ _02802_ _02803_ VGND VGND VPWR VPWR _02804_ sky130_fd_sc_hd__nand4_1
XFILLER_0_50_108 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
X_06379_ _05507_ _05508_ _05499_ VGND VGND VPWR VPWR _05510_ sky130_fd_sc_hd__a21o_1
XFILLER_0_31_311 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_0_114_560 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
X_09098_ _02573_ _02728_ VGND VGND VPWR VPWR _02729_ sky130_fd_sc_hd__xnor2_4
XFILLER_0_9_81 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
X_08118_ _01656_ _01657_ _01494_ VGND VGND VPWR VPWR _01659_ sky130_fd_sc_hd__o21ai_2
XFILLER_0_31_322 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_31_355 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
X_08049_ _05318_ net5 _05593_ VGND VGND VPWR VPWR _01583_ sky130_fd_sc_hd__and3_1
X_11060_ _04866_ VGND VGND VPWR VPWR _04867_ sky130_fd_sc_hd__inv_2
XFILLER_0_101_243 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_31_388 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XTAP_TAPCELL_ROW_112_1666 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
X_10011_ _03722_ _03723_ _03538_ _03541_ VGND VGND VPWR VPWR _03726_ sky130_fd_sc_hd__o211ai_2
XPHY_EDGE_ROW_26_Right_26 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_0_98_300 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_98_344 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XTAP_TAPCELL_ROW_67_1101 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
X_10913_ _04704_ _04706_ _04641_ _04621_ VGND VGND VPWR VPWR _04708_ sky130_fd_sc_hd__a211oi_1
XFILLER_0_98_377 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_86_539 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_39_400 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_0_39_411 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
X_10844_ _04630_ _04631_ _04554_ _04555_ VGND VGND VPWR VPWR _04633_ sky130_fd_sc_hd__o211a_1
XFILLER_0_82_701 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XTAP_TAPCELL_ROW_27_597 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
X_10775_ _00747_ _00748_ _01980_ VGND VGND VPWR VPWR _04557_ sky130_fd_sc_hd__and3_1
XFILLER_0_81_222 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XFILLER_0_54_414 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XPHY_EDGE_ROW_35_Right_35 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XTAP_TAPCELL_ROW_78_1241 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_120_530 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
X_11327_ _05129_ _05130_ VGND VGND VPWR VPWR _05155_ sky130_fd_sc_hd__or2_1
X_11258_ _04505_ _04042_ _05005_ _05080_ VGND VGND VPWR VPWR _05081_ sky130_fd_sc_hd__a31oi_1
XFILLER_0_5_39 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XPHY_EDGE_ROW_44_Right_44 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XPHY_EDGE_ROW_105_Left_227 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
X_11189_ _00896_ _04042_ _05005_ VGND VGND VPWR VPWR _05006_ sky130_fd_sc_hd__a21oi_1
X_10209_ _05540_ _00038_ _02160_ _02692_ VGND VGND VPWR VPWR _03941_ sky130_fd_sc_hd__nand4_2
X_05750_ _00537_ VGND VGND VPWR VPWR _00843_ sky130_fd_sc_hd__clkbuf_8
XFILLER_0_89_355 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XTAP_TAPCELL_ROW_89_1370 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_106_53 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_77_528 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XTAP_TAPCELL_ROW_46_840 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
X_07420_ _00895_ VGND VGND VPWR VPWR _00896_ sky130_fd_sc_hd__clkbuf_4
XFILLER_0_9_316 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_9_305 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_15_51 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XPHY_EDGE_ROW_114_Left_236 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XPHY_EDGE_ROW_53_Right_53 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
X_07351_ _02208_ net40 net41 _02699_ VGND VGND VPWR VPWR _00822_ sky130_fd_sc_hd__a22o_1
X_06302_ _05339_ _05351_ _05350_ VGND VGND VPWR VPWR _05434_ sky130_fd_sc_hd__a21bo_1
XFILLER_0_45_425 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_45_436 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_0_115_302 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
X_07282_ _00461_ _00373_ _00495_ _00614_ VGND VGND VPWR VPWR _00746_ sky130_fd_sc_hd__and4_1
XFILLER_0_45_447 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
X_09021_ _01762_ VGND VGND VPWR VPWR _02645_ sky130_fd_sc_hd__buf_4
X_06233_ _05364_ _05365_ VGND VGND VPWR VPWR _05366_ sky130_fd_sc_hd__xnor2_2
XFILLER_0_5_588 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_13_311 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
X_06164_ _05296_ _05297_ VGND VGND VPWR VPWR _05298_ sky130_fd_sc_hd__or2_1
XFILLER_0_13_366 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XPHY_EDGE_ROW_62_Right_62 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
X_06095_ _04563_ _04574_ _00395_ _04596_ VGND VGND VPWR VPWR _04607_ sky130_fd_sc_hd__and4bb_1
XFILLER_0_13_399 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
X_09923_ _02113_ _03489_ _03626_ _03628_ VGND VGND VPWR VPWR _03630_ sky130_fd_sc_hd__nand4_2
XFILLER_0_0_271 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
X_09854_ _03536_ _03552_ _03553_ VGND VGND VPWR VPWR _03554_ sky130_fd_sc_hd__and3_1
X_08805_ _02277_ _02316_ _02314_ VGND VGND VPWR VPWR _02408_ sky130_fd_sc_hd__a21o_2
X_09785_ _03243_ _03245_ VGND VGND VPWR VPWR _03479_ sky130_fd_sc_hd__and2b_1
X_06997_ _00300_ _00303_ _00302_ VGND VGND VPWR VPWR _00435_ sky130_fd_sc_hd__a21bo_1
X_08736_ _02144_ _02145_ _02332_ _02333_ VGND VGND VPWR VPWR _02334_ sky130_fd_sc_hd__a211o_1
X_05948_ net32 VGND VGND VPWR VPWR _03004_ sky130_fd_sc_hd__clkbuf_4
XFILLER_0_95_314 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
X_08667_ _03736_ _04922_ _02060_ _01040_ VGND VGND VPWR VPWR _02258_ sky130_fd_sc_hd__nand4_2
XFILLER_0_68_528 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
X_05879_ _02219_ VGND VGND VPWR VPWR _02251_ sky130_fd_sc_hd__buf_4
XPHY_EDGE_ROW_71_Right_71 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
X_07618_ _00428_ _00837_ VGND VGND VPWR VPWR _01113_ sky130_fd_sc_hd__and2_1
XFILLER_0_64_701 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
X_08598_ _01497_ _01805_ VGND VGND VPWR VPWR _02183_ sky130_fd_sc_hd__and2_1
XTAP_TAPCELL_ROW_62_1042 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_62_1031 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
X_07549_ _00924_ _00925_ VGND VGND VPWR VPWR _01037_ sky130_fd_sc_hd__nand2_1
XTAP_TAPCELL_ROW_24_556 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_24_567 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_36_425 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XFILLER_0_119_685 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
X_10560_ _04321_ _04322_ _04311_ VGND VGND VPWR VPWR _04324_ sky130_fd_sc_hd__a21oi_1
X_10491_ _04245_ _04248_ VGND VGND VPWR VPWR net104 sky130_fd_sc_hd__xor2_1
XFILLER_0_91_586 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
X_09219_ _02858_ _02859_ _02835_ VGND VGND VPWR VPWR _02861_ sky130_fd_sc_hd__a21o_1
XFILLER_0_63_288 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XFILLER_0_121_316 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XFILLER_0_121_327 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XPHY_EDGE_ROW_80_Right_80 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
X_11112_ _04877_ _04921_ VGND VGND VPWR VPWR _04924_ sky130_fd_sc_hd__nor2_1
XFILLER_0_102_596 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_102_585 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
X_11043_ _04807_ _04848_ VGND VGND VPWR VPWR _04849_ sky130_fd_sc_hd__xor2_1
XTAP_TAPCELL_ROW_73_1171 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_98_141 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_0_99_697 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_52_49 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
X_10827_ _04512_ _04597_ _04612_ _04613_ VGND VGND VPWR VPWR _04614_ sky130_fd_sc_hd__o211a_1
XFILLER_0_27_436 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XFILLER_0_39_263 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
X_10758_ _04445_ _04456_ _04537_ VGND VGND VPWR VPWR _04539_ sky130_fd_sc_hd__and3_1
XFILLER_0_82_531 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_27_447 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_42_417 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
X_10689_ _04275_ _04461_ _04462_ VGND VGND VPWR VPWR _04463_ sky130_fd_sc_hd__a21bo_1
XFILLER_0_2_525 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_0_22_141 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_2_569 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_23_697 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_120_371 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
X_06920_ _00349_ VGND VGND VPWR VPWR _00350_ sky130_fd_sc_hd__clkbuf_4
X_06851_ _00268_ _00276_ VGND VGND VPWR VPWR _00277_ sky130_fd_sc_hd__xnor2_1
X_09570_ _03241_ _03242_ VGND VGND VPWR VPWR _03243_ sky130_fd_sc_hd__or2_2
X_05802_ _00635_ _00657_ _01192_ _01181_ VGND VGND VPWR VPWR _01411_ sky130_fd_sc_hd__and4_2
X_06782_ _00186_ _00207_ _00208_ VGND VGND VPWR VPWR _00209_ sky130_fd_sc_hd__and3_1
X_08521_ _02095_ _02096_ _02097_ VGND VGND VPWR VPWR _02099_ sky130_fd_sc_hd__and3_1
XFILLER_0_26_83 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
X_05733_ _00646_ VGND VGND VPWR VPWR _00657_ sky130_fd_sc_hd__buf_4
XFILLER_0_77_347 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
X_08452_ _01840_ _02023_ VGND VGND VPWR VPWR _02024_ sky130_fd_sc_hd__xor2_4
XFILLER_0_9_113 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
X_07403_ _00460_ _00596_ VGND VGND VPWR VPWR _00879_ sky130_fd_sc_hd__or2_1
XFILLER_0_46_701 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_0_58_583 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
X_08383_ _05310_ _00688_ VGND VGND VPWR VPWR _01948_ sky130_fd_sc_hd__and2_1
XFILLER_0_116_622 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_85_391 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XTAP_TAPCELL_ROW_21_526 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
X_07334_ _03026_ _04085_ _00802_ _00187_ VGND VGND VPWR VPWR _00803_ sky130_fd_sc_hd__and4_2
XFILLER_0_61_715 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_60_203 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
X_07265_ _00477_ _00727_ VGND VGND VPWR VPWR _00728_ sky130_fd_sc_hd__xnor2_4
X_09004_ _00623_ VGND VGND VPWR VPWR _02626_ sky130_fd_sc_hd__clkbuf_4
X_06216_ _04987_ _05041_ _05019_ VGND VGND VPWR VPWR _05349_ sky130_fd_sc_hd__a21bo_1
X_07196_ _00529_ _00538_ VGND VGND VPWR VPWR _00652_ sky130_fd_sc_hd__or2_1
XFILLER_0_13_163 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
X_06147_ _05138_ _05149_ _04868_ VGND VGND VPWR VPWR _05170_ sky130_fd_sc_hd__a21o_1
XFILLER_0_111_371 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_06078_ _04401_ _04412_ VGND VGND VPWR VPWR net66 sky130_fd_sc_hd__xor2_4
X_09906_ _03609_ _03610_ VGND VGND VPWR VPWR _03611_ sky130_fd_sc_hd__or2_1
XFILLER_0_67_90 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
X_09837_ _03417_ _03418_ _03459_ _03460_ VGND VGND VPWR VPWR _03535_ sky130_fd_sc_hd__nand4_2
X_09768_ _03457_ _03458_ _03420_ _03356_ VGND VGND VPWR VPWR _03460_ sky130_fd_sc_hd__a211o_1
XTAP_TAPCELL_ROW_29_626 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_96_612 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XTAP_TAPCELL_ROW_57_979 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
X_08719_ _02312_ _02313_ _02152_ _02155_ VGND VGND VPWR VPWR _02315_ sky130_fd_sc_hd__o211a_1
XFILLER_0_96_645 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_95_111 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
X_09699_ _03381_ _03384_ VGND VGND VPWR VPWR net96 sky130_fd_sc_hd__xor2_4
XTAP_TAPCELL_ROW_1_273 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_107_1598 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_95_144 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_49_561 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XTAP_TAPCELL_ROW_120_1765 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
X_10612_ _00152_ _00237_ _04275_ _04157_ VGND VGND VPWR VPWR _04381_ sky130_fd_sc_hd__and4_1
X_10543_ _04196_ _04197_ VGND VGND VPWR VPWR _04306_ sky130_fd_sc_hd__and2b_1
XFILLER_0_91_372 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_0_52_715 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_24_406 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_51_247 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_0_51_225 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
X_10474_ _04228_ _04229_ _04120_ _04189_ VGND VGND VPWR VPWR _04231_ sky130_fd_sc_hd__a211oi_1
XTAP_TAPCELL_ROW_75_1200 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_51_258 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_121_135 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_0_20_634 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XTAP_TAPCELL_ROW_9_373 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
X_11026_ _02351_ _01977_ _03238_ VGND VGND VPWR VPWR _04830_ sky130_fd_sc_hd__and3_1
XFILLER_0_2_29 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_99_472 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XTAP_TAPCELL_ROW_86_1340 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_63_48 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_0_63_26 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_0_87_645 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_86_155 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_74_306 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XFILLER_0_28_701 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XANTENNA_18 _03759_ VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_0_7_617 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XANTENNA_29 net32 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_0_103_76 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_103_54 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XFILLER_0_55_586 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_0_12_41 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_15_417 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XFILLER_0_27_255 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_0_27_277 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_0_70_545 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_07050_ _00490_ _00491_ VGND VGND VPWR VPWR _00492_ sky130_fd_sc_hd__xnor2_2
XFILLER_0_12_85 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_0_27_299 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_0_88_45 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
X_06001_ _03572_ VGND VGND VPWR VPWR _03583_ sky130_fd_sc_hd__buf_4
Xoutput103 net103 VGND VGND VPWR VPWR product[44] sky130_fd_sc_hd__clkbuf_4
Xoutput114 net114 VGND VGND VPWR VPWR product[54] sky130_fd_sc_hd__clkbuf_4
XTAP_TAPCELL_ROW_97_1480 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_11_612 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
Xoutput125 net125 VGND VGND VPWR VPWR product[6] sky130_fd_sc_hd__clkbuf_4
XFILLER_0_11_667 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_0_11_645 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_120_190 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_0_10_177 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_07952_ _01309_ _01331_ _01475_ _01477_ VGND VGND VPWR VPWR _01478_ sky130_fd_sc_hd__o211a_2
X_07883_ _01364_ _01365_ _01401_ _01402_ VGND VGND VPWR VPWR _01403_ sky130_fd_sc_hd__a211oi_4
X_06903_ _00331_ _00332_ VGND VGND VPWR VPWR _00333_ sky130_fd_sc_hd__nor2_1
X_09622_ _04596_ _03297_ _03298_ _03300_ VGND VGND VPWR VPWR _03301_ sky130_fd_sc_hd__a22oi_2
X_06834_ _00171_ _00170_ VGND VGND VPWR VPWR _00260_ sky130_fd_sc_hd__and2b_1
X_09553_ _03078_ _03225_ VGND VGND VPWR VPWR _03226_ sky130_fd_sc_hd__xnor2_2
X_08504_ _02077_ _02078_ _02055_ VGND VGND VPWR VPWR _02080_ sky130_fd_sc_hd__o21a_1
XTAP_TAPCELL_ROW_54_938 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
X_06765_ _00190_ _00191_ VGND VGND VPWR VPWR _00192_ sky130_fd_sc_hd__nor2_1
X_09484_ _02640_ _02641_ _01605_ _02667_ VGND VGND VPWR VPWR _03150_ sky130_fd_sc_hd__nand4_2
XFILLER_0_78_689 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_77_133 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_05716_ _00461_ VGND VGND VPWR VPWR _00472_ sky130_fd_sc_hd__clkbuf_4
X_06696_ _05630_ _05632_ _00020_ _00021_ VGND VGND VPWR VPWR _00124_ sky130_fd_sc_hd__a211oi_2
X_08435_ _01964_ _02003_ _02004_ VGND VGND VPWR VPWR _02005_ sky130_fd_sc_hd__or3_4
XTAP_TAPCELL_ROW_34_684 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
X_08366_ _01926_ _01927_ _01928_ VGND VGND VPWR VPWR _01930_ sky130_fd_sc_hd__a21o_1
XFILLER_0_46_531 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_73_361 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
X_07317_ _00769_ _00782_ _00783_ VGND VGND VPWR VPWR _00784_ sky130_fd_sc_hd__nand3_2
XFILLER_0_18_277 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_46_586 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XFILLER_0_116_452 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
X_08297_ _00908_ _01674_ _01853_ _02666_ VGND VGND VPWR VPWR _01854_ sky130_fd_sc_hd__a22o_1
XFILLER_0_61_523 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_33_225 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
X_07248_ _00685_ _00707_ _00708_ VGND VGND VPWR VPWR _00709_ sky130_fd_sc_hd__and3_1
XFILLER_0_61_589 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_5_193 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
X_07179_ _02000_ _00035_ _05635_ _03223_ VGND VGND VPWR VPWR _00633_ sky130_fd_sc_hd__a22oi_2
X_10190_ _03663_ _03672_ _03798_ VGND VGND VPWR VPWR _03921_ sky130_fd_sc_hd__or3b_1
XTAP_TAPCELL_ROW_70_1141 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_6_343 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_6_332 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_109_1627 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_96_475 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_84_637 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_0_56_306 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XTAP_TAPCELL_ROW_81_1270 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_83_169 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
Xinput27 mcand[4] VGND VGND VPWR VPWR net27 sky130_fd_sc_hd__clkbuf_8
XFILLER_0_116_9 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
Xinput16 mcand[23] VGND VGND VPWR VPWR net16 sky130_fd_sc_hd__clkbuf_4
X_10526_ _04268_ _04286_ VGND VGND VPWR VPWR _04287_ sky130_fd_sc_hd__xnor2_1
XFILLER_0_107_474 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
Xinput49 mplier[24] VGND VGND VPWR VPWR net49 sky130_fd_sc_hd__clkbuf_2
Xinput38 mplier[14] VGND VGND VPWR VPWR net38 sky130_fd_sc_hd__clkbuf_4
XFILLER_0_24_269 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_40_707 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
X_10457_ _01604_ _02941_ _04210_ _04211_ VGND VGND VPWR VPWR _04212_ sky130_fd_sc_hd__a22oi_2
XFILLER_0_58_37 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
X_10388_ _04135_ _04136_ VGND VGND VPWR VPWR _04137_ sky130_fd_sc_hd__nor2_1
XFILLER_0_74_25 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
X_11009_ _01903_ _04157_ _04730_ _04810_ VGND VGND VPWR VPWR _04811_ sky130_fd_sc_hd__a31o_1
XFILLER_0_87_420 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
X_06550_ _05676_ _02764_ _05677_ _05678_ VGND VGND VPWR VPWR _05679_ sky130_fd_sc_hd__a22o_1
XFILLER_0_59_166 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
X_06481_ _05571_ _05572_ _05608_ _05609_ VGND VGND VPWR VPWR _05611_ sky130_fd_sc_hd__a22oi_4
XFILLER_0_114_53 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
X_08220_ _01767_ _01768_ _01769_ VGND VGND VPWR VPWR _01770_ sky130_fd_sc_hd__nand3_1
XFILLER_0_114_97 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_62_309 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_0_7_447 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_55_372 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
X_08151_ _00504_ net19 _01692_ _01693_ VGND VGND VPWR VPWR _01695_ sky130_fd_sc_hd__a22oi_2
XFILLER_0_15_225 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XTAP_TAPCELL_ROW_31_654 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_43_523 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
X_07102_ _03649_ net38 _05695_ _02721_ VGND VGND VPWR VPWR _00550_ sky130_fd_sc_hd__a22oi_1
X_08082_ _01278_ VGND VGND VPWR VPWR _01620_ sky130_fd_sc_hd__buf_4
XFILLER_0_70_397 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
X_07033_ _00468_ _00471_ _00465_ VGND VGND VPWR VPWR _00474_ sky130_fd_sc_hd__a21o_1
XFILLER_0_3_653 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_3_697 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_2_141 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_100_138 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
X_08984_ _02601_ _02602_ _02597_ VGND VGND VPWR VPWR _02604_ sky130_fd_sc_hd__a21o_1
XFILLER_0_54_3 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XTAP_TAPCELL_ROW_3_302 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
X_07935_ _01282_ _01292_ _01290_ VGND VGND VPWR VPWR _01460_ sky130_fd_sc_hd__a21bo_1
X_09605_ _03165_ _03166_ _03208_ _03209_ VGND VGND VPWR VPWR _03282_ sky130_fd_sc_hd__nand4_1
X_07866_ _01372_ _01382_ VGND VGND VPWR VPWR _01384_ sky130_fd_sc_hd__nor2_1
X_06817_ _00140_ _00242_ VGND VGND VPWR VPWR _00243_ sky130_fd_sc_hd__nand2_2
X_07797_ _01158_ _01161_ _01307_ _01308_ VGND VGND VPWR VPWR _01309_ sky130_fd_sc_hd__a211oi_2
XTAP_TAPCELL_ROW_39_754 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
X_09536_ _03204_ _03205_ _03184_ VGND VGND VPWR VPWR _03207_ sky130_fd_sc_hd__a21oi_1
X_06748_ _00159_ _00160_ _00173_ VGND VGND VPWR VPWR _00175_ sky130_fd_sc_hd__nand3_1
XTAP_TAPCELL_ROW_104_1557 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
X_09467_ _00411_ _00609_ _00748_ _00546_ VGND VGND VPWR VPWR _03131_ sky130_fd_sc_hd__a22o_1
XFILLER_0_109_717 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_0_108_216 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XTAP_TAPCELL_ROW_104_1568 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
X_06679_ _00083_ _00105_ _00106_ VGND VGND VPWR VPWR _00107_ sky130_fd_sc_hd__nand3_4
X_08418_ _03365_ _01805_ net56 _00799_ VGND VGND VPWR VPWR _01986_ sky130_fd_sc_hd__a22o_1
XFILLER_0_93_489 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
X_09398_ _02964_ _03055_ VGND VGND VPWR VPWR _03056_ sky130_fd_sc_hd__xor2_2
XFILLER_0_80_117 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
X_08349_ _01722_ _01723_ _01724_ VGND VGND VPWR VPWR _01911_ sky130_fd_sc_hd__a21bo_1
XFILLER_0_116_271 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
X_11360_ _05108_ _05189_ _05190_ VGND VGND VPWR VPWR _05191_ sky130_fd_sc_hd__o21a_2
XTAP_TAPCELL_ROW_59_1003 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
X_10311_ _04049_ _04050_ _03929_ _03931_ VGND VGND VPWR VPWR _04053_ sky130_fd_sc_hd__o211ai_2
XFILLER_0_61_386 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_0_104_477 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
X_11291_ _05114_ _05115_ VGND VGND VPWR VPWR _05117_ sky130_fd_sc_hd__nor2_1
XFILLER_0_21_239 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
X_10242_ _03975_ _03977_ _03855_ VGND VGND VPWR VPWR _03978_ sky130_fd_sc_hd__a21oi_1
XTAP_TAPCELL_ROW_115_1697 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
X_10173_ _03858_ _03859_ _03899_ _03901_ VGND VGND VPWR VPWR _03903_ sky130_fd_sc_hd__a22o_1
XFILLER_0_28_29 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_96_250 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XFILLER_0_57_615 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_56_114 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_29_306 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_29_328 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_96_283 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_37_350 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_0_115_709 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_0_80_640 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
X_10509_ _04266_ _04267_ VGND VGND VPWR VPWR _04268_ sky130_fd_sc_hd__or2_1
XFILLER_0_69_36 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_0_25_578 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XFILLER_0_100_44 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_0_623 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_0_645 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_20_250 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XFILLER_0_0_667 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
X_07720_ _05030_ _00138_ _05636_ _04998_ VGND VGND VPWR VPWR _01224_ sky130_fd_sc_hd__a22o_1
X_05981_ _00537_ VGND VGND VPWR VPWR _03365_ sky130_fd_sc_hd__buf_4
X_07651_ _01146_ _01147_ _01140_ VGND VGND VPWR VPWR _01150_ sky130_fd_sc_hd__a21o_1
X_06602_ _05628_ _00030_ VGND VGND VPWR VPWR net72 sky130_fd_sc_hd__xnor2_1
XTAP_TAPCELL_ROW_36_713 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
X_07582_ _01065_ _01073_ VGND VGND VPWR VPWR _01074_ sky130_fd_sc_hd__xnor2_2
X_09321_ _01759_ _00355_ _02802_ _02803_ VGND VGND VPWR VPWR _02972_ sky130_fd_sc_hd__and4_1
X_06533_ _04705_ _05310_ VGND VGND VPWR VPWR _05662_ sky130_fd_sc_hd__and2_1
XFILLER_0_75_423 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_8_701 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_48_659 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
X_09252_ _02894_ _02897_ VGND VGND VPWR VPWR _02898_ sky130_fd_sc_hd__xor2_4
XFILLER_0_63_629 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_0_16_501 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
X_06464_ _00843_ net38 _05593_ _02447_ VGND VGND VPWR VPWR _05594_ sky130_fd_sc_hd__a22o_1
XFILLER_0_35_309 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_0_47_169 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
X_09183_ _02811_ _02820_ _02821_ VGND VGND VPWR VPWR _02822_ sky130_fd_sc_hd__nand3_1
XFILLER_0_7_266 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
X_08203_ _01748_ _01750_ _01598_ _01715_ VGND VGND VPWR VPWR _01752_ sky130_fd_sc_hd__o211ai_4
X_06395_ _05524_ _05525_ VGND VGND VPWR VPWR _05526_ sky130_fd_sc_hd__and2_1
XFILLER_0_43_320 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_08134_ _00690_ _01674_ _01675_ _00362_ VGND VGND VPWR VPWR _01676_ sky130_fd_sc_hd__a22o_1
XFILLER_0_50_82 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XFILLER_0_16_567 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_0_71_673 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_16_589 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_101_414 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
X_08065_ _01598_ _01599_ _01576_ _01577_ VGND VGND VPWR VPWR _01601_ sky130_fd_sc_hd__a211oi_2
X_07016_ _00453_ _00454_ _00322_ _00324_ VGND VGND VPWR VPWR _00456_ sky130_fd_sc_hd__a211oi_2
X_08967_ _03616_ _02041_ _02412_ _02411_ _01354_ VGND VGND VPWR VPWR _02585_ sky130_fd_sc_hd__a32o_1
X_08898_ _02507_ _02508_ _02490_ VGND VGND VPWR VPWR _02510_ sky130_fd_sc_hd__a21oi_1
X_07918_ _01109_ VGND VGND VPWR VPWR _01441_ sky130_fd_sc_hd__clkbuf_8
X_07849_ _01219_ _01233_ _01234_ VGND VGND VPWR VPWR _01365_ sky130_fd_sc_hd__or3_2
X_10860_ _00914_ _02178_ _03030_ _00747_ VGND VGND VPWR VPWR _04649_ sky130_fd_sc_hd__a22o_1
X_09519_ _03012_ _03186_ _03187_ VGND VGND VPWR VPWR _03188_ sky130_fd_sc_hd__a21bo_1
XFILLER_0_39_615 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_109_503 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
X_10791_ _04369_ _04572_ VGND VGND VPWR VPWR _04575_ sky130_fd_sc_hd__nor2_1
XFILLER_0_66_434 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XTAP_TAPCELL_ROW_65_1073 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_109_547 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_0_54_629 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_26_309 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_109_558 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XFILLER_0_93_286 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_0_47_681 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
X_11412_ _05244_ _05246_ VGND VGND VPWR VPWR _05247_ sky130_fd_sc_hd__and2_1
XFILLER_0_62_662 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_34_342 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XTAP_TAPCELL_ROW_117_1726 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_62_695 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_0_22_515 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_120_701 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_11343_ _05171_ _05172_ VGND VGND VPWR VPWR _05173_ sky130_fd_sc_hd__xor2_2
X_11274_ _05097_ _05098_ VGND VGND VPWR VPWR _05099_ sky130_fd_sc_hd__nor2_1
XPHY_EDGE_ROW_18_Left_140 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
X_10225_ _00488_ _02667_ _03824_ _03825_ VGND VGND VPWR VPWR _03959_ sky130_fd_sc_hd__and4_1
X_10156_ _03879_ _03882_ _03883_ VGND VGND VPWR VPWR _03884_ sky130_fd_sc_hd__nand3_4
X_10087_ _04085_ _03807_ VGND VGND VPWR VPWR _03808_ sky130_fd_sc_hd__nand2_1
XFILLER_0_71_26 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
X_10989_ _04787_ _04788_ _04723_ _04725_ VGND VGND VPWR VPWR _04790_ sky130_fd_sc_hd__a211o_1
XFILLER_0_84_231 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_0_69_294 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_0_29_125 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_0_29_169 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_115_539 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_112_3 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_111_21 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_72_459 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XTAP_TAPCELL_ROW_41_771 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_53_673 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
X_06180_ _05306_ VGND VGND VPWR VPWR _05313_ sky130_fd_sc_hd__inv_2
XFILLER_0_20_41 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_25_364 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XTAP_TAPCELL_ROW_92_1409 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_80_492 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_4_269 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_13_559 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
Xmax_cap157 net158 VGND VGND VPWR VPWR net157 sky130_fd_sc_hd__clkbuf_1
Xmax_cap146 _01058_ VGND VGND VPWR VPWR net146 sky130_fd_sc_hd__clkbuf_1
XFILLER_0_110_244 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
X_09870_ _01379_ _00236_ _01949_ _01441_ VGND VGND VPWR VPWR _03571_ sky130_fd_sc_hd__nand4_2
XFILLER_0_110_277 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
X_08821_ _02423_ _02424_ VGND VGND VPWR VPWR _02426_ sky130_fd_sc_hd__xor2_2
XFILLER_0_0_497 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
X_08752_ _03091_ _02351_ _02347_ _02348_ VGND VGND VPWR VPWR _02352_ sky130_fd_sc_hd__nand4_1
X_05964_ _02742_ _02775_ _02710_ VGND VGND VPWR VPWR _03179_ sky130_fd_sc_hd__o21ba_1
X_08683_ _02233_ _02275_ VGND VGND VPWR VPWR _02276_ sky130_fd_sc_hd__xnor2_4
X_07703_ _00504_ net16 VGND VGND VPWR VPWR _01206_ sky130_fd_sc_hd__nand2_2
X_05895_ _02164_ _02175_ _02306_ VGND VGND VPWR VPWR _02425_ sky130_fd_sc_hd__nor3_1
XTAP_TAPCELL_ROW_49_871 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
X_07634_ _01003_ _01005_ _01129_ _01130_ VGND VGND VPWR VPWR _01131_ sky130_fd_sc_hd__o211a_2
XFILLER_0_17_3 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
X_07565_ _01053_ _01054_ VGND VGND VPWR VPWR _01055_ sky130_fd_sc_hd__xnor2_2
XTAP_TAPCELL_ROW_101_1527 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
X_09304_ _02937_ _02952_ _02953_ VGND VGND VPWR VPWR _02954_ sky130_fd_sc_hd__and3_2
XFILLER_0_75_253 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_0_63_404 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
X_06516_ _05643_ _05644_ VGND VGND VPWR VPWR _05645_ sky130_fd_sc_hd__nand2_1
X_07496_ _00978_ _00979_ VGND VGND VPWR VPWR _00980_ sky130_fd_sc_hd__and2b_1
XFILLER_0_36_607 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_90_201 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_75_297 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_0_61_81 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_09235_ _02876_ _02877_ _02872_ VGND VGND VPWR VPWR _02879_ sky130_fd_sc_hd__a21o_1
X_06447_ _02732_ _02458_ _05416_ _02197_ VGND VGND VPWR VPWR _05577_ sky130_fd_sc_hd__a22o_1
XFILLER_0_118_388 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_90_278 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
X_09166_ _00556_ _01588_ _01379_ _00236_ VGND VGND VPWR VPWR _02803_ sky130_fd_sc_hd__nand4_1
X_06378_ _05499_ _05507_ _05508_ VGND VGND VPWR VPWR _05509_ sky130_fd_sc_hd__nand3_1
XFILLER_0_102_701 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
X_09097_ _02725_ _02727_ VGND VGND VPWR VPWR _02728_ sky130_fd_sc_hd__xnor2_4
XFILLER_0_9_93 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
X_08117_ _01494_ _01656_ _01657_ VGND VGND VPWR VPWR _01658_ sky130_fd_sc_hd__or3_2
XFILLER_0_16_397 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_0_31_334 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
X_08048_ _00556_ VGND VGND VPWR VPWR _01582_ sky130_fd_sc_hd__clkbuf_4
XFILLER_0_101_255 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XFILLER_0_12_581 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XTAP_TAPCELL_ROW_112_1667 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_112_1656 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
X_10010_ _03538_ _03541_ _03722_ _03723_ VGND VGND VPWR VPWR _03724_ sky130_fd_sc_hd__a211o_1
X_09999_ _00488_ _02837_ _03710_ _03711_ VGND VGND VPWR VPWR _03712_ sky130_fd_sc_hd__a22o_1
XFILLER_0_98_323 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
X_10912_ _04641_ _04621_ _04704_ _04706_ VGND VGND VPWR VPWR _04707_ sky130_fd_sc_hd__o211a_1
XFILLER_0_98_356 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XTAP_TAPCELL_ROW_67_1102 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_25_19 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_98_389 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_0_58_209 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
X_10843_ _04554_ _04555_ _04630_ _04631_ VGND VGND VPWR VPWR _04632_ sky130_fd_sc_hd__a211oi_1
X_10774_ _04458_ _04459_ VGND VGND VPWR VPWR _04556_ sky130_fd_sc_hd__or2b_1
XFILLER_0_82_713 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XTAP_TAPCELL_ROW_27_598 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_81_289 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XTAP_TAPCELL_ROW_78_1242 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_78_1231 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_50_632 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_0_50_621 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_0_34_183 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
X_11326_ _05142_ _05143_ VGND VGND VPWR VPWR _05154_ sky130_fd_sc_hd__nand2_1
X_11257_ _04505_ _04040_ _04042_ _01042_ VGND VGND VPWR VPWR _05080_ sky130_fd_sc_hd__a22oi_1
X_11188_ _01042_ _03807_ VGND VGND VPWR VPWR _05005_ sky130_fd_sc_hd__and2_1
X_10208_ _05636_ _02160_ _02177_ _00138_ VGND VGND VPWR VPWR _03940_ sky130_fd_sc_hd__a22o_1
X_10139_ _03863_ _03864_ VGND VGND VPWR VPWR _03865_ sky130_fd_sc_hd__or2_2
XTAP_TAPCELL_ROW_89_1371 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_89_367 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XTAP_TAPCELL_ROW_46_841 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_106_65 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_73_713 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
X_07350_ _02721_ _03649_ _05696_ _00423_ VGND VGND VPWR VPWR _00820_ sky130_fd_sc_hd__nand4_2
XFILLER_0_85_584 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
X_06301_ _05430_ _05431_ _05421_ VGND VGND VPWR VPWR _05433_ sky130_fd_sc_hd__a21o_1
XFILLER_0_115_314 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
X_09020_ _02134_ _00034_ _02639_ _02642_ VGND VGND VPWR VPWR _02643_ sky130_fd_sc_hd__a22o_1
X_07281_ _00629_ _00641_ _00642_ VGND VGND VPWR VPWR _00745_ sky130_fd_sc_hd__nor3_2
XFILLER_0_5_501 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_0_26_640 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_0_72_278 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_26_684 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
X_06232_ _05181_ _05202_ VGND VGND VPWR VPWR _05365_ sky130_fd_sc_hd__nand2_1
XFILLER_0_41_632 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_06163_ _05294_ _05295_ _04433_ VGND VGND VPWR VPWR _05297_ sky130_fd_sc_hd__a21oi_1
XFILLER_0_41_665 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
X_06094_ _04585_ VGND VGND VPWR VPWR _04596_ sky130_fd_sc_hd__buf_4
X_09922_ _02113_ _02947_ _03626_ _03628_ VGND VGND VPWR VPWR _03629_ sky130_fd_sc_hd__a22o_1
XFILLER_0_0_250 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XFILLER_0_40_197 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
X_09853_ _03549_ _03551_ _03542_ VGND VGND VPWR VPWR _03553_ sky130_fd_sc_hd__a21o_1
X_09784_ _03247_ VGND VGND VPWR VPWR _03478_ sky130_fd_sc_hd__buf_4
X_08804_ _02253_ _02272_ _02406_ VGND VGND VPWR VPWR _02407_ sky130_fd_sc_hd__o21ba_2
X_08735_ _02329_ _02330_ _02331_ VGND VGND VPWR VPWR _02333_ sky130_fd_sc_hd__and3_1
X_06996_ _00431_ _00432_ _00429_ VGND VGND VPWR VPWR _00434_ sky130_fd_sc_hd__a21o_1
X_05947_ _02240_ _02797_ _02982_ VGND VGND VPWR VPWR _02993_ sky130_fd_sc_hd__o21a_1
X_08666_ _04922_ _00893_ _01040_ _05659_ VGND VGND VPWR VPWR _02257_ sky130_fd_sc_hd__a22o_1
X_05878_ _02229_ VGND VGND VPWR VPWR _02240_ sky130_fd_sc_hd__inv_2
X_07617_ _01107_ _01111_ VGND VGND VPWR VPWR _01112_ sky130_fd_sc_hd__xnor2_2
X_08597_ _02176_ _02181_ VGND VGND VPWR VPWR _02182_ sky130_fd_sc_hd__xor2_1
X_07548_ _00945_ _01035_ VGND VGND VPWR VPWR _01036_ sky130_fd_sc_hd__nand2_1
XFILLER_0_48_253 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_91_521 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_76_595 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_0_64_713 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XTAP_TAPCELL_ROW_62_1043 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_62_1032 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_24_557 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_24_568 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_119_697 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
X_07479_ _00804_ _00806_ _00959_ _00960_ VGND VGND VPWR VPWR _00961_ sky130_fd_sc_hd__a211o_1
XFILLER_0_48_297 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
X_10490_ _04246_ _04247_ VGND VGND VPWR VPWR _04248_ sky130_fd_sc_hd__nand2_1
XFILLER_0_91_598 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
X_09218_ _02835_ _02858_ _02859_ VGND VGND VPWR VPWR _02860_ sky130_fd_sc_hd__nand3_4
XFILLER_0_63_267 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_17_673 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_106_369 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
X_09149_ _02603_ _02605_ _02782_ _02783_ VGND VGND VPWR VPWR _02784_ sky130_fd_sc_hd__a211oi_1
XFILLER_0_44_470 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_0_32_676 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
X_11111_ _04877_ _04921_ VGND VGND VPWR VPWR _04923_ sky130_fd_sc_hd__and2_1
XFILLER_0_6_3 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
X_11042_ _04845_ _04847_ VGND VGND VPWR VPWR _04848_ sky130_fd_sc_hd__xnor2_1
XTAP_TAPCELL_ROW_73_1172 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_99_621 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_36_29 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_98_186 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XTAP_TAPCELL_ROW_43_800 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
X_10826_ _04610_ _04611_ _04507_ _04510_ VGND VGND VPWR VPWR _04613_ sky130_fd_sc_hd__o211ai_2
XFILLER_0_39_242 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_94_381 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_67_573 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
X_10757_ _04445_ _04456_ _04537_ VGND VGND VPWR VPWR _04538_ sky130_fd_sc_hd__a21oi_2
XFILLER_0_6_309 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
X_10688_ _00914_ _02345_ _02161_ _03323_ VGND VGND VPWR VPWR _04462_ sky130_fd_sc_hd__a22o_1
XFILLER_0_82_587 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_14_109 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XFILLER_0_50_451 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_22_153 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_105_391 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
X_11309_ _05118_ _05134_ VGND VGND VPWR VPWR _05136_ sky130_fd_sc_hd__and2_1
XFILLER_0_22_197 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
X_06850_ _00274_ _00275_ VGND VGND VPWR VPWR _00276_ sky130_fd_sc_hd__xor2_1
XFILLER_0_93_57 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
X_05801_ _01280_ _01389_ VGND VGND VPWR VPWR _01400_ sky130_fd_sc_hd__or2_1
XFILLER_0_89_131 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
X_06781_ _00204_ _00205_ _00206_ VGND VGND VPWR VPWR _00208_ sky130_fd_sc_hd__a21o_1
XFILLER_0_77_315 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
X_08520_ _01906_ _01907_ _01908_ VGND VGND VPWR VPWR _02097_ sky130_fd_sc_hd__a21bo_1
X_05732_ net12 VGND VGND VPWR VPWR _00646_ sky130_fd_sc_hd__buf_4
XFILLER_0_77_326 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
X_08451_ _02020_ _02021_ VGND VGND VPWR VPWR _02023_ sky130_fd_sc_hd__nor2_2
XFILLER_0_92_307 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
X_07402_ _00875_ _00877_ VGND VGND VPWR VPWR _00878_ sky130_fd_sc_hd__and2_1
X_08382_ _01942_ _01946_ VGND VGND VPWR VPWR _01947_ sky130_fd_sc_hd__xor2_1
X_07333_ _05343_ VGND VGND VPWR VPWR _00802_ sky130_fd_sc_hd__clkbuf_4
XTAP_TAPCELL_ROW_21_527 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_115_111 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_73_576 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
X_07264_ _00725_ _00726_ VGND VGND VPWR VPWR _00727_ sky130_fd_sc_hd__xnor2_4
XFILLER_0_45_278 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XFILLER_0_115_133 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_84_3 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_09003_ _02623_ _02624_ VGND VGND VPWR VPWR _02625_ sky130_fd_sc_hd__xor2_1
X_06215_ _05344_ _05346_ _05340_ VGND VGND VPWR VPWR _05348_ sky130_fd_sc_hd__a21o_1
XFILLER_0_5_375 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_14_643 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
X_07195_ _00535_ _00536_ VGND VGND VPWR VPWR _00651_ sky130_fd_sc_hd__or2b_1
X_06146_ _04868_ _05138_ _05149_ VGND VGND VPWR VPWR _05159_ sky130_fd_sc_hd__nand3_2
X_06077_ _02950_ _04357_ VGND VGND VPWR VPWR _04412_ sky130_fd_sc_hd__nand2_2
X_09905_ _03607_ _03608_ _00408_ _01680_ VGND VGND VPWR VPWR _03610_ sky130_fd_sc_hd__and4bb_1
XFILLER_0_6_83 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
X_09836_ _03464_ _03465_ _03512_ _03513_ VGND VGND VPWR VPWR _03534_ sky130_fd_sc_hd__or4_2
X_09767_ _03420_ _03356_ _03457_ _03458_ VGND VGND VPWR VPWR _03459_ sky130_fd_sc_hd__o211ai_4
XTAP_TAPCELL_ROW_29_627 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
X_06979_ _00413_ _00414_ net31 _05345_ VGND VGND VPWR VPWR _00415_ sky130_fd_sc_hd__and4bb_1
X_09698_ _03068_ _03076_ _03226_ _03383_ VGND VGND VPWR VPWR _03384_ sky130_fd_sc_hd__o31a_2
XTAP_TAPCELL_ROW_57_969 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
X_08718_ _02152_ _02155_ _02312_ _02313_ VGND VGND VPWR VPWR _02314_ sky130_fd_sc_hd__a211oi_2
XFILLER_0_96_657 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_96_624 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
X_08649_ _03780_ _01552_ _01852_ VGND VGND VPWR VPWR _02238_ sky130_fd_sc_hd__and3_1
XTAP_TAPCELL_ROW_1_274 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_107_1599 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_120_1766 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
X_10611_ _04377_ _04378_ VGND VGND VPWR VPWR _04380_ sky130_fd_sc_hd__xor2_1
X_10542_ _04302_ _04304_ VGND VGND VPWR VPWR _04305_ sky130_fd_sc_hd__xnor2_1
XFILLER_0_64_587 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_24_418 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XFILLER_0_51_237 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_0_51_215 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_0_121_103 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_10473_ _04120_ _04189_ _04228_ _04229_ VGND VGND VPWR VPWR _04230_ sky130_fd_sc_hd__o211a_2
XFILLER_0_106_188 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XTAP_TAPCELL_ROW_75_1201 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_121_169 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XTAP_TAPCELL_ROW_9_374 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
X_11025_ _02838_ _03478_ _04746_ VGND VGND VPWR VPWR _04829_ sky130_fd_sc_hd__nand3_1
XFILLER_0_87_613 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_0_63_16 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XTAP_TAPCELL_ROW_86_1341 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_59_337 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_87_657 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_86_167 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_67_370 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_0_28_713 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
X_10809_ _02325_ _02227_ VGND VGND VPWR VPWR _04594_ sky130_fd_sc_hd__nand2_1
XANTENNA_19 _04085_ VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_0_55_554 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_0_7_629 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_12_53 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_6_139 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
X_06000_ _02764_ VGND VGND VPWR VPWR _03572_ sky130_fd_sc_hd__buf_4
Xoutput104 net104 VGND VGND VPWR VPWR product[45] sky130_fd_sc_hd__clkbuf_4
XTAP_TAPCELL_ROW_97_1470 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
Xoutput115 net115 VGND VGND VPWR VPWR product[55] sky130_fd_sc_hd__buf_2
XFILLER_0_100_309 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
Xoutput126 net126 VGND VGND VPWR VPWR product[7] sky130_fd_sc_hd__clkbuf_4
XFILLER_0_10_167 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
X_07951_ _01361_ _01362_ _01473_ _01474_ VGND VGND VPWR VPWR _01477_ sky130_fd_sc_hd__o22ai_1
X_06902_ _00328_ _00329_ _00219_ _00221_ VGND VGND VPWR VPWR _00332_ sky130_fd_sc_hd__o211a_1
X_07882_ _01398_ _01399_ _01262_ _01366_ VGND VGND VPWR VPWR _01402_ sky130_fd_sc_hd__o211a_1
XFILLER_0_37_50 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
X_09621_ _04531_ _04552_ _02692_ _03030_ VGND VGND VPWR VPWR _03300_ sky130_fd_sc_hd__nand4_4
X_06833_ _00176_ _00177_ _00211_ _00212_ VGND VGND VPWR VPWR _00259_ sky130_fd_sc_hd__nor4_1
XFILLER_0_37_72 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
X_09552_ _03079_ _03224_ VGND VGND VPWR VPWR _03225_ sky130_fd_sc_hd__xnor2_2
X_06764_ _00974_ _00985_ _05502_ _05593_ VGND VGND VPWR VPWR _00191_ sky130_fd_sc_hd__and4_1
X_08503_ _02055_ _02077_ _02078_ VGND VGND VPWR VPWR _02079_ sky130_fd_sc_hd__nor3_2
X_05715_ _00450_ VGND VGND VPWR VPWR _00461_ sky130_fd_sc_hd__clkbuf_4
X_09483_ _02110_ _01949_ _02812_ _02108_ VGND VGND VPWR VPWR _03149_ sky130_fd_sc_hd__a22o_1
XTAP_TAPCELL_ROW_54_939 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
X_06695_ _00121_ _00122_ VGND VGND VPWR VPWR _00123_ sky130_fd_sc_hd__and2b_2
XFILLER_0_19_713 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
X_08434_ _02001_ _02002_ _01817_ _01965_ VGND VGND VPWR VPWR _02004_ sky130_fd_sc_hd__o211a_1
XTAP_TAPCELL_ROW_34_685 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
X_08365_ _01926_ _01927_ _01928_ VGND VGND VPWR VPWR _01929_ sky130_fd_sc_hd__nand3_1
X_07316_ _00637_ _00770_ _00781_ VGND VGND VPWR VPWR _00783_ sky130_fd_sc_hd__nand3_2
X_08296_ _01852_ VGND VGND VPWR VPWR _01853_ sky130_fd_sc_hd__clkbuf_4
XFILLER_0_61_535 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_0_18_289 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_0_116_475 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_104_626 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_61_557 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_0_5_161 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
X_07247_ _00704_ _00705_ _00706_ VGND VGND VPWR VPWR _00708_ sky130_fd_sc_hd__a21o_1
XFILLER_0_33_259 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_0_103_147 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
X_07178_ _01508_ net62 net7 net8 VGND VGND VPWR VPWR _00632_ sky130_fd_sc_hd__and4_1
X_06129_ net64 VGND VGND VPWR VPWR _04976_ sky130_fd_sc_hd__buf_4
XFILLER_0_41_281 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_0_112_681 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_78_90 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XTAP_TAPCELL_ROW_70_1131 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_6_333 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_70_1142 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_109_1628 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
X_09819_ _03364_ _03389_ net140 _03515_ VGND VGND VPWR VPWR _03516_ sky130_fd_sc_hd__a211oi_4
XFILLER_0_96_421 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_69_624 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_37_510 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XTAP_TAPCELL_ROW_81_1271 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_64_340 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
Xinput17 mcand[24] VGND VGND VPWR VPWR net17 sky130_fd_sc_hd__buf_4
Xinput28 mcand[5] VGND VGND VPWR VPWR net28 sky130_fd_sc_hd__clkbuf_2
XFILLER_0_119_291 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_0_64_384 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_107_486 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
X_10525_ _04274_ _04285_ VGND VGND VPWR VPWR _04286_ sky130_fd_sc_hd__xnor2_1
XFILLER_0_52_579 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
Xinput39 mplier[15] VGND VGND VPWR VPWR net39 sky130_fd_sc_hd__buf_1
X_10456_ _02320_ _01605_ _00894_ _02061_ VGND VGND VPWR VPWR _04211_ sky130_fd_sc_hd__nand4_1
X_10387_ _04133_ _04134_ _04024_ _04026_ VGND VGND VPWR VPWR _04136_ sky130_fd_sc_hd__a211oi_1
X_11008_ _00495_ _03324_ _03171_ _02868_ VGND VGND VPWR VPWR _04810_ sky130_fd_sc_hd__and4_1
XFILLER_0_99_281 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_99_292 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_0_90_25 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_0_59_189 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
X_06480_ _05571_ _05572_ _05608_ _05609_ VGND VGND VPWR VPWR _05610_ sky130_fd_sc_hd__and4_2
XFILLER_0_114_65 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_74_148 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_68_690 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_08150_ _03780_ _01486_ _00893_ _01185_ VGND VGND VPWR VPWR _01693_ sky130_fd_sc_hd__nand4_1
XFILLER_0_55_351 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XTAP_TAPCELL_ROW_31_644 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_70_321 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XTAP_TAPCELL_ROW_31_655 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
X_07101_ _02699_ _02208_ net38 _05695_ VGND VGND VPWR VPWR _00549_ sky130_fd_sc_hd__and4_1
X_08081_ _01608_ _01617_ VGND VGND VPWR VPWR _01619_ sky130_fd_sc_hd__xnor2_2
X_07032_ _00465_ _00473_ VGND VGND VPWR VPWR net77 sky130_fd_sc_hd__xnor2_4
XFILLER_0_101_607 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_3_665 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_0_2_153 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_2_197 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
X_08983_ _02597_ _02601_ _02602_ VGND VGND VPWR VPWR _02603_ sky130_fd_sc_hd__nand3_2
X_07934_ _01456_ _01457_ _01447_ VGND VGND VPWR VPWR _01459_ sky130_fd_sc_hd__a21o_1
XTAP_TAPCELL_ROW_3_303 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
X_07865_ _01372_ _01382_ VGND VGND VPWR VPWR _01383_ sky130_fd_sc_hd__and2_1
XFILLER_0_98_719 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
X_09604_ _03278_ _03279_ _03235_ _03236_ VGND VGND VPWR VPWR _03281_ sky130_fd_sc_hd__o211a_1
XFILLER_0_3_51 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XTAP_TAPCELL_ROW_39_744 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_78_421 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
X_06816_ _00142_ VGND VGND VPWR VPWR _00242_ sky130_fd_sc_hd__inv_2
X_07796_ _01240_ _01241_ _01305_ _01306_ VGND VGND VPWR VPWR _01308_ sky130_fd_sc_hd__a2bb2oi_1
XTAP_TAPCELL_ROW_39_755 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
X_09535_ _03184_ _03204_ _03205_ VGND VGND VPWR VPWR _03206_ sky130_fd_sc_hd__and3_1
X_06747_ _00159_ _00160_ _00173_ VGND VGND VPWR VPWR _00174_ sky130_fd_sc_hd__a21o_1
XTAP_TAPCELL_ROW_104_1558 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
X_09466_ _00546_ _00556_ _01060_ VGND VGND VPWR VPWR _03130_ sky130_fd_sc_hd__and3_1
XFILLER_0_65_104 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_06678_ _00102_ _00103_ _00104_ VGND VGND VPWR VPWR _00106_ sky130_fd_sc_hd__a21o_1
XFILLER_0_93_446 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
X_08417_ _01497_ net53 VGND VGND VPWR VPWR _01985_ sky130_fd_sc_hd__and2_1
X_09397_ _03052_ _03054_ VGND VGND VPWR VPWR _03055_ sky130_fd_sc_hd__xor2_4
XFILLER_0_34_502 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
X_08348_ _01907_ _01908_ _01906_ VGND VGND VPWR VPWR _01910_ sky130_fd_sc_hd__a21o_1
XFILLER_0_46_373 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XTAP_TAPCELL_ROW_59_1004 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_6_470 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
X_08279_ _01832_ _01833_ _01652_ net134 VGND VGND VPWR VPWR _01835_ sky130_fd_sc_hd__a211oi_2
XFILLER_0_116_294 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
X_11290_ _04505_ _04873_ _05082_ VGND VGND VPWR VPWR _05115_ sky130_fd_sc_hd__a21oi_1
X_10310_ _03929_ _03931_ _04049_ _04050_ VGND VGND VPWR VPWR _04051_ sky130_fd_sc_hd__a211o_1
XFILLER_0_21_207 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_0_22_719 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
X_10241_ _03973_ _03974_ _03937_ VGND VGND VPWR VPWR _03977_ sky130_fd_sc_hd__o21ai_2
XTAP_TAPCELL_ROW_115_1698 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
X_10172_ _03858_ _03859_ _03899_ _03901_ VGND VGND VPWR VPWR _03902_ sky130_fd_sc_hd__nand4_2
XFILLER_0_44_29 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XTAP_TAPCELL_ROW_83_1300 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_69_443 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_0_84_457 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_0_65_671 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_107_261 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_64_192 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_0_8_29 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
X_10508_ _04264_ _04265_ VGND VGND VPWR VPWR _04267_ sky130_fd_sc_hd__and2_1
XFILLER_0_52_365 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_100_56 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XTAP_TAPCELL_ROW_94_1440 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
X_10439_ _00686_ _00558_ _02036_ _01852_ VGND VGND VPWR VPWR _04192_ sky130_fd_sc_hd__and4_1
XFILLER_0_0_657 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
X_05980_ _03310_ _03321_ _03332_ _03343_ VGND VGND VPWR VPWR _03354_ sky130_fd_sc_hd__nand4_2
XFILLER_0_18_41 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_18_85 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
X_07650_ _01140_ _01146_ _01147_ VGND VGND VPWR VPWR _01148_ sky130_fd_sc_hd__nand3_2
X_06601_ _00027_ _00029_ VGND VGND VPWR VPWR _00030_ sky130_fd_sc_hd__and2_1
XTAP_TAPCELL_ROW_36_714 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
X_07581_ _01070_ _01071_ VGND VGND VPWR VPWR _01073_ sky130_fd_sc_hd__and2b_1
X_09320_ _01582_ _02134_ _00344_ _00346_ VGND VGND VPWR VPWR _02971_ sky130_fd_sc_hd__and4_1
X_06532_ _05486_ _03736_ _04531_ _04552_ VGND VGND VPWR VPWR _05661_ sky130_fd_sc_hd__nand4_1
X_09251_ _02662_ _02719_ _02895_ VGND VGND VPWR VPWR _02897_ sky130_fd_sc_hd__a21oi_4
XFILLER_0_8_713 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XTAP_TAPCELL_ROW_16_460 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
X_08202_ _01598_ _01715_ _01748_ _01750_ VGND VGND VPWR VPWR _01751_ sky130_fd_sc_hd__a211o_2
X_06463_ net39 VGND VGND VPWR VPWR _05593_ sky130_fd_sc_hd__clkbuf_4
XFILLER_0_47_148 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_0_90_427 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
X_09182_ _02817_ _02818_ _02814_ VGND VGND VPWR VPWR _02821_ sky130_fd_sc_hd__a21o_1
XFILLER_0_28_362 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
X_06394_ _05381_ _05445_ _05444_ VGND VGND VPWR VPWR _05525_ sky130_fd_sc_hd__o21bai_1
X_08133_ net21 VGND VGND VPWR VPWR _01675_ sky130_fd_sc_hd__clkbuf_4
XFILLER_0_7_278 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XFILLER_0_71_685 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
X_08064_ _01576_ _01577_ _01598_ _01599_ VGND VGND VPWR VPWR _01600_ sky130_fd_sc_hd__o211a_1
XFILLER_0_31_505 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
X_07015_ _00322_ _00324_ _00453_ _00454_ VGND VGND VPWR VPWR _00455_ sky130_fd_sc_hd__o211a_1
XFILLER_0_3_495 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_11_262 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_08966_ _02582_ _02583_ VGND VGND VPWR VPWR _02584_ sky130_fd_sc_hd__xnor2_1
XFILLER_0_75_91 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
X_08897_ _02490_ _02507_ _02508_ VGND VGND VPWR VPWR _02509_ sky130_fd_sc_hd__and3_1
X_07917_ _01431_ _01439_ VGND VGND VPWR VPWR _01440_ sky130_fd_sc_hd__xor2_2
X_07848_ _01233_ VGND VGND VPWR VPWR _01364_ sky130_fd_sc_hd__inv_2
X_09518_ _05387_ _01798_ _01976_ _05319_ VGND VGND VPWR VPWR _03187_ sky130_fd_sc_hd__a22o_1
X_07779_ _01113_ _01117_ _01115_ VGND VGND VPWR VPWR _01289_ sky130_fd_sc_hd__a21bo_1
X_10790_ _04369_ _04572_ VGND VGND VPWR VPWR _04573_ sky130_fd_sc_hd__and2_1
XFILLER_0_91_90 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_78_284 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XTAP_TAPCELL_ROW_65_1074 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_93_254 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
X_09449_ _03108_ _03109_ _03105_ VGND VGND VPWR VPWR _03111_ sky130_fd_sc_hd__a21o_1
XFILLER_0_66_457 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_38_148 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_93_276 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_117_570 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
X_11411_ _05176_ _05209_ _05243_ VGND VGND VPWR VPWR _05246_ sky130_fd_sc_hd__or3_1
XFILLER_0_81_449 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_62_641 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XTAP_TAPCELL_ROW_117_1727 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
X_11342_ _04883_ _02228_ VGND VGND VPWR VPWR _05172_ sky130_fd_sc_hd__nand2_1
XFILLER_0_22_527 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_0_34_354 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_34_387 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_11273_ _05053_ _05055_ _05050_ VGND VGND VPWR VPWR _05098_ sky130_fd_sc_hd__a21oi_1
X_10224_ _00344_ _00346_ _02163_ _03006_ VGND VGND VPWR VPWR _03958_ sky130_fd_sc_hd__and4_1
X_10155_ _02976_ _03489_ _03880_ _03881_ VGND VGND VPWR VPWR _03883_ sky130_fd_sc_hd__nand4_2
X_10086_ _02864_ VGND VGND VPWR VPWR _03807_ sky130_fd_sc_hd__clkbuf_4
XFILLER_0_89_505 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_10988_ _04723_ _04725_ _04787_ _04788_ VGND VGND VPWR VPWR _04789_ sky130_fd_sc_hd__o211ai_4
XFILLER_0_57_435 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_57_413 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_29_137 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_84_243 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_29_148 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_0_84_276 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_72_438 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XTAP_TAPCELL_ROW_13_430 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_38_660 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_38_693 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_0_4_204 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XTAP_TAPCELL_ROW_41_772 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_111_33 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_108_581 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_0_105_3 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_80_471 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_0_13_505 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_25_376 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XFILLER_0_52_195 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_13_527 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_20_53 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_110_201 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
Xmax_cap147 _03642_ VGND VGND VPWR VPWR net147 sky130_fd_sc_hd__clkbuf_1
Xmax_cap136 _01495_ VGND VGND VPWR VPWR net136 sky130_fd_sc_hd__clkbuf_1
XFILLER_0_96_57 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_0_0_454 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_21_582 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_110_289 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
X_08820_ _00472_ _02052_ VGND VGND VPWR VPWR _02424_ sky130_fd_sc_hd__nand2_1
X_08751_ _01798_ VGND VGND VPWR VPWR _02351_ sky130_fd_sc_hd__buf_4
X_05963_ _03070_ _03157_ VGND VGND VPWR VPWR _03168_ sky130_fd_sc_hd__xnor2_1
X_08682_ _02234_ _02274_ VGND VGND VPWR VPWR _02275_ sky130_fd_sc_hd__xnor2_4
X_05894_ _02339_ _02350_ _01793_ VGND VGND VPWR VPWR _02414_ sky130_fd_sc_hd__and3b_1
X_07702_ _01084_ _01085_ _01086_ VGND VGND VPWR VPWR _01205_ sky130_fd_sc_hd__nand3_1
XTAP_TAPCELL_ROW_49_872 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
X_07633_ _01126_ _01128_ _01106_ VGND VGND VPWR VPWR _01130_ sky130_fd_sc_hd__a21o_1
X_07564_ _00898_ _00901_ VGND VGND VPWR VPWR _01054_ sky130_fd_sc_hd__nor2_1
XTAP_TAPCELL_ROW_101_1528 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
X_09303_ _02949_ _02951_ _02938_ VGND VGND VPWR VPWR _02953_ sky130_fd_sc_hd__a21o_1
XFILLER_0_8_510 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
X_06515_ _05543_ _05642_ VGND VGND VPWR VPWR _05644_ sky130_fd_sc_hd__or2_1
X_07495_ _00976_ _00977_ _00972_ VGND VGND VPWR VPWR _00979_ sky130_fd_sc_hd__a21o_1
XFILLER_0_36_619 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_63_427 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
X_09234_ _02872_ _02876_ _02877_ VGND VGND VPWR VPWR _02878_ sky130_fd_sc_hd__nand3_1
XPHY_EDGE_ROW_3_Right_3 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
X_06446_ _01039_ _04976_ _05495_ _05494_ _05008_ VGND VGND VPWR VPWR _05576_ sky130_fd_sc_hd__a32o_1
X_09165_ _00686_ _00150_ _00345_ _00294_ VGND VGND VPWR VPWR _02802_ sky130_fd_sc_hd__a22o_1
XFILLER_0_63_449 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_8_587 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_16_343 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
X_08116_ _01654_ _01655_ _01473_ net136 VGND VGND VPWR VPWR _01657_ sky130_fd_sc_hd__a211oi_2
X_06377_ _05504_ _05505_ _05506_ VGND VGND VPWR VPWR _05508_ sky130_fd_sc_hd__a21o_1
X_09096_ _02449_ _02554_ _02726_ VGND VGND VPWR VPWR _02727_ sky130_fd_sc_hd__a21oi_4
XFILLER_0_102_713 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
X_08047_ _01580_ _00798_ VGND VGND VPWR VPWR _01581_ sky130_fd_sc_hd__nand2_1
XFILLER_0_101_223 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XTAP_TAPCELL_ROW_112_1668 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_112_1657 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_101_289 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
X_09998_ _00151_ _02459_ _02812_ _02843_ VGND VGND VPWR VPWR _03711_ sky130_fd_sc_hd__nand4_1
X_08949_ _02402_ _02564_ VGND VGND VPWR VPWR _02566_ sky130_fd_sc_hd__and2_1
X_10911_ _04702_ _04703_ _04623_ VGND VGND VPWR VPWR _04706_ sky130_fd_sc_hd__o21ai_1
XTAP_TAPCELL_ROW_67_1103 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
X_10842_ _04627_ _04628_ _04527_ _04529_ VGND VGND VPWR VPWR _04631_ sky130_fd_sc_hd__a211oi_1
XFILLER_0_94_530 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
X_10773_ _02645_ _03675_ _04495_ VGND VGND VPWR VPWR _04555_ sky130_fd_sc_hd__nand3_1
XFILLER_0_94_563 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_66_243 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XTAP_TAPCELL_ROW_27_599 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_66_287 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_0_54_438 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XFILLER_0_66_298 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_35_630 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_81_279 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XTAP_TAPCELL_ROW_78_1243 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_78_1232 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
X_11325_ _05112_ _05145_ VGND VGND VPWR VPWR _05153_ sky130_fd_sc_hd__or2b_1
XFILLER_0_105_595 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_11256_ _05077_ _05078_ VGND VGND VPWR VPWR _05079_ sky130_fd_sc_hd__xor2_1
X_11187_ _04893_ _04959_ VGND VGND VPWR VPWR _05004_ sky130_fd_sc_hd__or2_1
X_10207_ _03802_ _03805_ _03803_ VGND VGND VPWR VPWR _03939_ sky130_fd_sc_hd__a21boi_1
X_10138_ _03861_ _03862_ _01414_ net22 VGND VGND VPWR VPWR _03864_ sky130_fd_sc_hd__and4bb_1
X_10069_ _03644_ _03677_ _03787_ _03788_ VGND VGND VPWR VPWR _03789_ sky130_fd_sc_hd__a211oi_4
XTAP_TAPCELL_ROW_89_1372 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_82_26 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XTAP_TAPCELL_ROW_46_831 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_46_842 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_85_596 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_72_213 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_07280_ _00741_ _00742_ VGND VGND VPWR VPWR _00743_ sky130_fd_sc_hd__and2_1
X_06300_ _05421_ _05430_ _05431_ VGND VGND VPWR VPWR _05432_ sky130_fd_sc_hd__nand3_1
X_06231_ _05362_ _05363_ VGND VGND VPWR VPWR _05364_ sky130_fd_sc_hd__nand2_1
XFILLER_0_45_449 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_0_115_337 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_0_115_326 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_5_546 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_25_151 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_26_696 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
X_06162_ _04433_ _05294_ _05295_ VGND VGND VPWR VPWR _05296_ sky130_fd_sc_hd__and3_1
X_06093_ net3 VGND VGND VPWR VPWR _04585_ sky130_fd_sc_hd__clkbuf_8
X_09921_ _01759_ _00411_ _03490_ _03491_ VGND VGND VPWR VPWR _03628_ sky130_fd_sc_hd__nand4_2
XFILLER_0_41_688 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_111_587 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_21_390 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
X_09852_ _03542_ _03549_ _03551_ VGND VGND VPWR VPWR _03552_ sky130_fd_sc_hd__nand3_2
X_09783_ _03475_ _03476_ VGND VGND VPWR VPWR _03477_ sky130_fd_sc_hd__xor2_4
X_08803_ _02270_ _02271_ VGND VGND VPWR VPWR _02406_ sky130_fd_sc_hd__nor2_1
XPHY_EDGE_ROW_0_Left_122 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XPHY_EDGE_ROW_37_Left_159 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_0_56_93 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XFILLER_0_56_82 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XFILLER_0_56_60 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
X_08734_ _02329_ _02330_ _02331_ VGND VGND VPWR VPWR _02332_ sky130_fd_sc_hd__a21oi_1
X_06995_ _00429_ _00431_ _00432_ VGND VGND VPWR VPWR _00433_ sky130_fd_sc_hd__nand3_1
X_05946_ _02786_ _02688_ VGND VGND VPWR VPWR _02982_ sky130_fd_sc_hd__or2b_1
X_08665_ _05419_ _00750_ _02089_ _02088_ _00610_ VGND VGND VPWR VPWR _02256_ sky130_fd_sc_hd__a32o_1
X_05877_ _00351_ net33 _02197_ _02219_ VGND VGND VPWR VPWR _02229_ sky130_fd_sc_hd__and4_1
X_08596_ _02178_ _02179_ _02180_ VGND VGND VPWR VPWR _02181_ sky130_fd_sc_hd__a21bo_1
X_07616_ _01108_ _01110_ VGND VGND VPWR VPWR _01111_ sky130_fd_sc_hd__nor2_1
XFILLER_0_88_390 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XFILLER_0_76_530 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
X_07547_ _00910_ _00911_ _00945_ _00946_ VGND VGND VPWR VPWR _01035_ sky130_fd_sc_hd__o211ai_2
XFILLER_0_48_243 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XFILLER_0_91_500 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XTAP_TAPCELL_ROW_62_1033 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_24_558 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_118_164 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_106_304 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
X_07478_ _00956_ _00957_ _00958_ VGND VGND VPWR VPWR _00960_ sky130_fd_sc_hd__a21oi_1
XPHY_EDGE_ROW_46_Left_168 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
X_09217_ _02856_ _02857_ _02836_ VGND VGND VPWR VPWR _02859_ sky130_fd_sc_hd__a21o_1
XFILLER_0_63_279 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
X_06429_ _05556_ _05558_ VGND VGND VPWR VPWR _05559_ sky130_fd_sc_hd__or2_2
XFILLER_0_32_600 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_121_307 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
X_09148_ _02780_ _02781_ _02770_ VGND VGND VPWR VPWR _02783_ sky130_fd_sc_hd__a21boi_1
XFILLER_0_17_685 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
X_09079_ _02703_ _02707_ VGND VGND VPWR VPWR _02708_ sky130_fd_sc_hd__xnor2_1
XFILLER_0_114_392 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
X_11110_ _04918_ _04920_ VGND VGND VPWR VPWR _04921_ sky130_fd_sc_hd__xnor2_1
X_11041_ _04772_ _04774_ VGND VGND VPWR VPWR _04847_ sky130_fd_sc_hd__nor2_1
XTAP_TAPCELL_ROW_73_1173 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XPHY_EDGE_ROW_55_Left_177 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_0_86_327 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_0_52_29 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XTAP_TAPCELL_ROW_43_801 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
X_10825_ _04507_ _04510_ _04610_ _04611_ VGND VGND VPWR VPWR _04612_ sky130_fd_sc_hd__a211o_1
XFILLER_0_67_541 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XPHY_EDGE_ROW_64_Left_186 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_0_27_416 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
X_10756_ _04534_ _04536_ VGND VGND VPWR VPWR _04537_ sky130_fd_sc_hd__xnor2_1
XFILLER_0_82_533 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_54_224 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_27_449 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_10687_ _03323_ _00914_ _02695_ VGND VGND VPWR VPWR _04461_ sky130_fd_sc_hd__and3_1
XFILLER_0_82_577 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_105_370 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_0_50_441 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_77_15 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_0_10_316 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_0_22_165 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
X_11308_ _05118_ _05134_ VGND VGND VPWR VPWR _05135_ sky130_fd_sc_hd__nor2_1
XPHY_EDGE_ROW_73_Left_195 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
X_11239_ _04996_ _05001_ _05060_ VGND VGND VPWR VPWR _05061_ sky130_fd_sc_hd__o21a_1
X_05800_ _00439_ _01181_ _01258_ _01269_ VGND VGND VPWR VPWR _01389_ sky130_fd_sc_hd__o2bb2a_1
XFILLER_0_93_69 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
X_06780_ _00204_ _00205_ _00206_ VGND VGND VPWR VPWR _00207_ sky130_fd_sc_hd__nand3_4
XFILLER_0_26_41 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_89_143 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_26_63 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
X_05731_ _00624_ VGND VGND VPWR VPWR _00635_ sky130_fd_sc_hd__clkbuf_4
X_08450_ _02018_ _02019_ _01834_ _01844_ VGND VGND VPWR VPWR _02021_ sky130_fd_sc_hd__a211oi_1
XFILLER_0_26_85 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
X_08381_ _01943_ _01944_ _01945_ VGND VGND VPWR VPWR _01946_ sky130_fd_sc_hd__a21bo_1
X_07401_ _00873_ _00874_ VGND VGND VPWR VPWR _00877_ sky130_fd_sc_hd__or2_1
XFILLER_0_73_511 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
X_07332_ _00797_ _00800_ VGND VGND VPWR VPWR _00801_ sky130_fd_sc_hd__xor2_2
XFILLER_0_85_393 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_73_555 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XFILLER_0_18_449 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XTAP_TAPCELL_ROW_21_528 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_42_73 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_07263_ _00479_ _00591_ _00590_ VGND VGND VPWR VPWR _00726_ sky130_fd_sc_hd__a21oi_2
XFILLER_0_115_145 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
X_09002_ _00409_ _01903_ VGND VGND VPWR VPWR _02624_ sky130_fd_sc_hd__nand2_1
X_07194_ _00542_ _00543_ _00582_ _00583_ VGND VGND VPWR VPWR _00650_ sky130_fd_sc_hd__nor4_1
X_06214_ _05340_ _05344_ _05346_ VGND VGND VPWR VPWR _05347_ sky130_fd_sc_hd__nand3_1
XFILLER_0_13_110 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XFILLER_0_13_121 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_06145_ _05106_ _05116_ _05127_ VGND VGND VPWR VPWR _05149_ sky130_fd_sc_hd__a21o_1
XFILLER_0_77_3 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_14_699 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_41_485 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
X_06076_ _04379_ _04390_ VGND VGND VPWR VPWR _04401_ sky130_fd_sc_hd__or2_2
X_09904_ _00409_ _01671_ _03607_ _03608_ VGND VGND VPWR VPWR _03609_ sky130_fd_sc_hd__o2bb2a_1
X_09835_ _03317_ _03390_ _03461_ _03462_ VGND VGND VPWR VPWR _03533_ sky130_fd_sc_hd__a211o_1
X_09766_ _03455_ _03456_ _03421_ _03309_ VGND VGND VPWR VPWR _03458_ sky130_fd_sc_hd__a211o_1
XTAP_TAPCELL_ROW_29_628 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
X_06978_ _03649_ net37 net38 _02721_ VGND VGND VPWR VPWR _00414_ sky130_fd_sc_hd__a22oi_1
X_09697_ _03078_ _03225_ _03382_ VGND VGND VPWR VPWR _03383_ sky130_fd_sc_hd__a21o_1
X_08717_ _02310_ _02311_ _02296_ VGND VGND VPWR VPWR _02313_ sky130_fd_sc_hd__a21oi_1
X_05929_ _02688_ _02786_ VGND VGND VPWR VPWR _02797_ sky130_fd_sc_hd__xor2_1
XFILLER_0_96_636 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_95_113 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
X_08648_ _01192_ _02236_ _02044_ VGND VGND VPWR VPWR _02237_ sky130_fd_sc_hd__nand3_1
XFILLER_0_68_316 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XTAP_TAPCELL_ROW_1_275 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_96_669 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_49_552 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XFILLER_0_95_179 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_83_319 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
X_08579_ _01050_ _01977_ _01982_ _01981_ _02161_ VGND VGND VPWR VPWR _02162_ sky130_fd_sc_hd__a32o_1
XTAP_TAPCELL_ROW_120_1767 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_120_1756 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_107_613 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
X_10610_ _00754_ _03294_ VGND VGND VPWR VPWR _04378_ sky130_fd_sc_hd__nand2_1
XFILLER_0_9_671 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
X_10541_ _02976_ _01849_ VGND VGND VPWR VPWR _04304_ sky130_fd_sc_hd__nand2_1
XFILLER_0_106_112 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_0_64_555 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_8_170 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
X_10472_ _04225_ _04226_ _04190_ _04080_ VGND VGND VPWR VPWR _04229_ sky130_fd_sc_hd__a211o_1
XTAP_TAPCELL_ROW_75_1202 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_17_493 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_32_452 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_102_362 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XTAP_TAPCELL_ROW_9_375 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
X_11024_ _04744_ _04745_ VGND VGND VPWR VPWR _04828_ sky130_fd_sc_hd__or2b_1
XTAP_TAPCELL_ROW_86_1331 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_86_1342 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_87_669 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_0_59_349 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_0_86_179 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
X_10808_ _04590_ _04592_ VGND VGND VPWR VPWR _04593_ sky130_fd_sc_hd__xor2_1
XFILLER_0_94_190 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_67_393 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_0_27_213 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
X_10739_ _04497_ _04516_ _04517_ VGND VGND VPWR VPWR _04518_ sky130_fd_sc_hd__or3_2
XFILLER_0_103_45 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_82_363 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_12_65 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_12_98 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
Xoutput105 net105 VGND VGND VPWR VPWR product[46] sky130_fd_sc_hd__clkbuf_4
XTAP_TAPCELL_ROW_97_1471 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XPHY_EDGE_ROW_81_Left_203 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
Xoutput116 net116 VGND VGND VPWR VPWR product[56] sky130_fd_sc_hd__clkbuf_4
Xoutput127 net127 VGND VGND VPWR VPWR product[8] sky130_fd_sc_hd__clkbuf_4
XFILLER_0_63_9 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_10_135 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_0_2_379 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
X_07950_ _01361_ _01362_ _01473_ _01474_ VGND VGND VPWR VPWR _01475_ sky130_fd_sc_hd__or4_1
X_06901_ _00219_ _00221_ _00328_ _00329_ VGND VGND VPWR VPWR _00331_ sky130_fd_sc_hd__a211oi_2
X_07881_ _01262_ _01366_ _01398_ _01399_ VGND VGND VPWR VPWR _01401_ sky130_fd_sc_hd__a211oi_4
X_09620_ _05308_ _02692_ _02529_ _04531_ VGND VGND VPWR VPWR _03298_ sky130_fd_sc_hd__a22o_1
X_06832_ _00255_ _00256_ _00232_ _00233_ VGND VGND VPWR VPWR _00258_ sky130_fd_sc_hd__a211oi_2
XPHY_EDGE_ROW_90_Left_212 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
X_09551_ _03220_ _03222_ VGND VGND VPWR VPWR _03224_ sky130_fd_sc_hd__xor2_4
X_06763_ _00985_ _00086_ _00189_ _00974_ VGND VGND VPWR VPWR _00190_ sky130_fd_sc_hd__a22oi_2
XFILLER_0_77_113 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
X_08502_ _02074_ _02075_ _01882_ _01884_ VGND VGND VPWR VPWR _02078_ sky130_fd_sc_hd__a211oi_2
X_05714_ net55 VGND VGND VPWR VPWR _00450_ sky130_fd_sc_hd__clkbuf_4
XFILLER_0_93_606 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_09482_ _00798_ _02813_ _03008_ _03007_ _02850_ VGND VGND VPWR VPWR _03148_ sky130_fd_sc_hd__a32o_1
X_06694_ _00119_ _00120_ _00018_ _00020_ VGND VGND VPWR VPWR _00122_ sky130_fd_sc_hd__a211o_1
XFILLER_0_93_617 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
X_08433_ _01817_ _01965_ _02001_ _02002_ VGND VGND VPWR VPWR _02003_ sky130_fd_sc_hd__a211oi_2
XFILLER_0_92_138 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XTAP_TAPCELL_ROW_34_686 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
X_08364_ _01734_ _01742_ _01741_ VGND VGND VPWR VPWR _01928_ sky130_fd_sc_hd__a21bo_1
XFILLER_0_116_421 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_85_190 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_73_330 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_0_18_257 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
X_07315_ _00637_ _00770_ _00781_ VGND VGND VPWR VPWR _00782_ sky130_fd_sc_hd__a21o_1
XFILLER_0_104_605 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
X_08295_ net21 VGND VGND VPWR VPWR _01852_ sky130_fd_sc_hd__clkbuf_4
XFILLER_0_104_638 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
X_07246_ _00704_ _00705_ _00706_ VGND VGND VPWR VPWR _00707_ sky130_fd_sc_hd__nand3_2
XFILLER_0_33_238 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_07177_ _00501_ _00503_ VGND VGND VPWR VPWR _00631_ sky130_fd_sc_hd__or2_2
XFILLER_0_41_260 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
X_06128_ _04911_ _04954_ VGND VGND VPWR VPWR _04965_ sky130_fd_sc_hd__xnor2_2
XFILLER_0_112_693 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_0_78_80 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
X_06059_ _03529_ _03550_ _03539_ VGND VGND VPWR VPWR _04216_ sky130_fd_sc_hd__o21ai_1
XFILLER_0_111_192 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XTAP_TAPCELL_ROW_70_1132 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_6_334 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_70_1143 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
X_09818_ _03464_ _03465_ _03512_ _03513_ VGND VGND VPWR VPWR _03515_ sky130_fd_sc_hd__o22a_1
XTAP_TAPCELL_ROW_109_1629 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
X_09749_ _03345_ _03347_ VGND VGND VPWR VPWR _03439_ sky130_fd_sc_hd__nand2_1
XFILLER_0_96_433 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_69_647 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_0_96_477 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_0_83_105 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_0_68_179 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_0_83_138 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_49_393 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_107_421 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XTAP_TAPCELL_ROW_81_1272 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_25_717 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_0_64_363 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
Xinput18 mcand[25] VGND VGND VPWR VPWR net18 sky130_fd_sc_hd__buf_2
X_10524_ _04283_ _04284_ VGND VGND VPWR VPWR _04285_ sky130_fd_sc_hd__or2b_1
Xinput29 mcand[6] VGND VGND VPWR VPWR net29 sky130_fd_sc_hd__clkbuf_4
XFILLER_0_24_249 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
X_10455_ _01949_ _02060_ _01040_ _01610_ VGND VGND VPWR VPWR _04210_ sky130_fd_sc_hd__a22o_1
XFILLER_0_32_271 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
X_10386_ _04024_ _04026_ _04133_ _04134_ VGND VGND VPWR VPWR _04135_ sky130_fd_sc_hd__o211a_1
XFILLER_0_20_477 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
X_11007_ _00896_ _01042_ _04374_ _04275_ _04762_ VGND VGND VPWR VPWR _04809_ sky130_fd_sc_hd__a41o_1
XFILLER_0_87_400 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_59_113 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XFILLER_0_59_146 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_87_477 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_47_319 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_118_719 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_114_77 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_0_28_533 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XTAP_TAPCELL_ROW_99_1500 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_90_609 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XFILLER_0_7_449 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_55_385 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XTAP_TAPCELL_ROW_31_645 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
X_07100_ _02677_ _00546_ _00425_ _00424_ VGND VGND VPWR VPWR _00547_ sky130_fd_sc_hd__a31o_1
XFILLER_0_99_57 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_0_82_193 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_0_70_355 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_70_333 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_0_15_238 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_08080_ _01615_ _01616_ VGND VGND VPWR VPWR _01617_ sky130_fd_sc_hd__or2b_1
X_07031_ _00468_ _00471_ VGND VGND VPWR VPWR _00473_ sky130_fd_sc_hd__nand2_2
XFILLER_0_2_121 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_113_479 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_0_2_165 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
X_08982_ _05574_ _02064_ _02598_ _02599_ VGND VGND VPWR VPWR _02602_ sky130_fd_sc_hd__nand4_2
X_07933_ _01447_ _01456_ _01457_ VGND VGND VPWR VPWR _01458_ sky130_fd_sc_hd__nand3_2
XFILLER_0_48_83 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XTAP_TAPCELL_ROW_3_304 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
X_07864_ _01377_ _01381_ VGND VGND VPWR VPWR _01382_ sky130_fd_sc_hd__xnor2_1
X_09603_ _03235_ _03236_ _03278_ _03279_ VGND VGND VPWR VPWR _03280_ sky130_fd_sc_hd__a211oi_2
X_06815_ _00238_ _00240_ VGND VGND VPWR VPWR _00241_ sky130_fd_sc_hd__and2_1
X_07795_ _01240_ _01241_ _01305_ _01306_ VGND VGND VPWR VPWR _01307_ sky130_fd_sc_hd__and4bb_1
XTAP_TAPCELL_ROW_39_745 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_78_433 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_09534_ _03202_ _03203_ _03018_ _03020_ VGND VGND VPWR VPWR _03205_ sky130_fd_sc_hd__o211ai_2
XFILLER_0_64_93 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
X_06746_ _00165_ _00172_ VGND VGND VPWR VPWR _00173_ sky130_fd_sc_hd__xnor2_1
XFILLER_0_78_477 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
X_09465_ _02992_ _02994_ _02995_ VGND VGND VPWR VPWR _03129_ sky130_fd_sc_hd__and3_1
XFILLER_0_66_606 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
X_06677_ _00102_ _00103_ _00104_ VGND VGND VPWR VPWR _00105_ sky130_fd_sc_hd__nand3_4
XFILLER_0_38_319 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XFILLER_0_108_207 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XTAP_TAPCELL_ROW_104_1559 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
X_08416_ _01979_ _01983_ VGND VGND VPWR VPWR _01984_ sky130_fd_sc_hd__xor2_2
XFILLER_0_80_92 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
X_09396_ _02834_ _02893_ _03053_ VGND VGND VPWR VPWR _03054_ sky130_fd_sc_hd__a21oi_4
X_08347_ _01906_ _01907_ _01908_ VGND VGND VPWR VPWR _01909_ sky130_fd_sc_hd__nand3_1
XFILLER_0_116_251 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_104_413 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_73_182 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XTAP_TAPCELL_ROW_59_1005 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
X_08278_ _01652_ net135 _01832_ _01833_ VGND VGND VPWR VPWR _01834_ sky130_fd_sc_hd__o211a_1
XFILLER_0_46_396 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
X_07229_ _00301_ VGND VGND VPWR VPWR _00688_ sky130_fd_sc_hd__clkbuf_4
X_10240_ _03937_ _03973_ _03974_ VGND VGND VPWR VPWR _03975_ sky130_fd_sc_hd__or3_2
XFILLER_0_104_468 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XTAP_TAPCELL_ROW_115_1699 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
X_10171_ _03897_ _03898_ _03860_ VGND VGND VPWR VPWR _03901_ sky130_fd_sc_hd__a21o_1
XPHY_EDGE_ROW_110_Right_110 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_0_89_709 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XTAP_TAPCELL_ROW_83_1301 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_69_499 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_0_56_138 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XFILLER_0_52_344 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XFILLER_0_4_419 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_13_709 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_10507_ _04264_ _04265_ VGND VGND VPWR VPWR _04266_ sky130_fd_sc_hd__nor2_1
XFILLER_0_107_273 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_0_100_35 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XTAP_TAPCELL_ROW_94_1441 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_33_591 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_0_110_427 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
X_10438_ _02104_ _03237_ _03238_ _01588_ VGND VGND VPWR VPWR _04191_ sky130_fd_sc_hd__a22oi_1
X_10369_ _04113_ _04114_ _04103_ VGND VGND VPWR VPWR _04116_ sky130_fd_sc_hd__a21oi_1
XFILLER_0_85_15 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_109_55 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_18_53 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_18_97 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
X_06600_ _00028_ _00026_ VGND VGND VPWR VPWR _00029_ sky130_fd_sc_hd__or2_1
XTAP_TAPCELL_ROW_36_715 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
X_07580_ _01068_ _01069_ _00920_ _00922_ VGND VGND VPWR VPWR _01071_ sky130_fd_sc_hd__a211o_1
XFILLER_0_34_41 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
X_06531_ _05659_ _05307_ _05308_ _05486_ VGND VGND VPWR VPWR _05660_ sky130_fd_sc_hd__a22o_1
X_09250_ _02716_ _02718_ VGND VGND VPWR VPWR _02895_ sky130_fd_sc_hd__nor2_1
XFILLER_0_34_85 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_0_118_516 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XTAP_TAPCELL_ROW_16_461 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
X_08201_ _01746_ _01747_ _01732_ VGND VGND VPWR VPWR _01750_ sky130_fd_sc_hd__a21oi_2
X_06462_ _01978_ _05425_ VGND VGND VPWR VPWR _05592_ sky130_fd_sc_hd__and2_1
X_09181_ _02814_ _02817_ _02818_ VGND VGND VPWR VPWR _02820_ sky130_fd_sc_hd__nand3_1
XFILLER_0_50_51 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_06393_ _05522_ _05523_ VGND VGND VPWR VPWR _05524_ sky130_fd_sc_hd__nor2_1
X_08132_ net20 VGND VGND VPWR VPWR _01674_ sky130_fd_sc_hd__clkbuf_4
XFILLER_0_16_547 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_0_113_221 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_0_113_210 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_71_664 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_70_141 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
X_08063_ _01578_ _01579_ _01597_ VGND VGND VPWR VPWR _01599_ sky130_fd_sc_hd__nand3_2
XFILLER_0_113_243 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_71_697 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
X_07014_ _00378_ _00379_ _00451_ _00452_ VGND VGND VPWR VPWR _00454_ sky130_fd_sc_hd__a2bb2o_1
XFILLER_0_101_438 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_0_59_60 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_08965_ _04716_ _01671_ VGND VGND VPWR VPWR _02583_ sky130_fd_sc_hd__nand2_1
X_07916_ _01432_ _01438_ VGND VGND VPWR VPWR _01439_ sky130_fd_sc_hd__xnor2_2
X_08896_ _02505_ _02506_ _02497_ VGND VGND VPWR VPWR _02508_ sky130_fd_sc_hd__a21o_1
X_07847_ _01240_ _01241_ _01305_ _01306_ VGND VGND VPWR VPWR _01363_ sky130_fd_sc_hd__or4bb_2
X_07778_ _01285_ _01286_ _01283_ VGND VGND VPWR VPWR _01288_ sky130_fd_sc_hd__a21o_1
XFILLER_0_94_701 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
X_09517_ _05319_ _05387_ _01798_ VGND VGND VPWR VPWR _03186_ sky130_fd_sc_hd__and3_1
X_06729_ _05640_ _00048_ VGND VGND VPWR VPWR _00156_ sky130_fd_sc_hd__nand2_1
XFILLER_0_39_617 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_78_296 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_0_38_105 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
X_09448_ _03105_ _03108_ _03109_ VGND VGND VPWR VPWR _03110_ sky130_fd_sc_hd__nand3_4
XFILLER_0_66_469 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XTAP_TAPCELL_ROW_65_1075 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
X_09379_ _03032_ _03034_ _03029_ VGND VGND VPWR VPWR _03035_ sky130_fd_sc_hd__or3b_1
X_11410_ _05176_ _05209_ _05243_ VGND VGND VPWR VPWR _05244_ sky130_fd_sc_hd__o21ai_1
XFILLER_0_74_480 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XTAP_TAPCELL_ROW_117_1728 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
X_11341_ _05168_ _05169_ VGND VGND VPWR VPWR _05171_ sky130_fd_sc_hd__nor2_1
X_11272_ _05063_ _05096_ VGND VGND VPWR VPWR _05097_ sky130_fd_sc_hd__xor2_1
X_10223_ _03955_ _03956_ VGND VGND VPWR VPWR _03957_ sky130_fd_sc_hd__xor2_2
X_10154_ _02976_ _02941_ _03880_ _03881_ VGND VGND VPWR VPWR _03882_ sky130_fd_sc_hd__a22o_1
X_10085_ _03804_ _03805_ VGND VGND VPWR VPWR _03806_ sky130_fd_sc_hd__xnor2_1
XFILLER_0_97_572 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_97_550 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_71_17 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
X_10987_ _04785_ _04786_ _04727_ _04707_ VGND VGND VPWR VPWR _04788_ sky130_fd_sc_hd__a211o_1
XFILLER_0_97_594 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_57_447 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_45_609 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_0_84_288 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XTAP_TAPCELL_ROW_13_420 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_38_672 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_44_108 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_65_480 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_5_717 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_0_37_193 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XTAP_TAPCELL_ROW_41_773 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_111_45 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
Xmax_cap137 net169 VGND VGND VPWR VPWR net137 sky130_fd_sc_hd__buf_1
Xmax_cap148 _00380_ VGND VGND VPWR VPWR net148 sky130_fd_sc_hd__buf_1
Xmax_cap159 _00650_ VGND VGND VPWR VPWR net159 sky130_fd_sc_hd__buf_1
XFILLER_0_96_36 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_0_444 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_0_0_466 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_21_594 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_0_29_30 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_29_63 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
X_08750_ _03091_ _01800_ _02347_ _02348_ VGND VGND VPWR VPWR _02349_ sky130_fd_sc_hd__a22o_1
X_05962_ _03102_ _03146_ VGND VGND VPWR VPWR _03157_ sky130_fd_sc_hd__xnor2_1
X_08681_ _02253_ _02272_ VGND VGND VPWR VPWR _02274_ sky130_fd_sc_hd__xnor2_4
X_05893_ _01913_ _02394_ VGND VGND VPWR VPWR net126 sky130_fd_sc_hd__xor2_4
X_07701_ _01201_ _01202_ VGND VGND VPWR VPWR _01204_ sky130_fd_sc_hd__xnor2_1
XTAP_TAPCELL_ROW_49_873 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
X_07632_ _01106_ _01126_ _01128_ VGND VGND VPWR VPWR _01129_ sky130_fd_sc_hd__nand3_4
XFILLER_0_76_701 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
X_09302_ _02938_ _02949_ _02951_ VGND VGND VPWR VPWR _02952_ sky130_fd_sc_hd__nand3_4
X_07563_ _01051_ _01052_ VGND VGND VPWR VPWR _01053_ sky130_fd_sc_hd__or2_1
XTAP_TAPCELL_ROW_101_1529 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_75_233 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
X_06514_ _05543_ _05642_ VGND VGND VPWR VPWR _05643_ sky130_fd_sc_hd__nand2_1
X_07494_ _00972_ _00976_ _00977_ VGND VGND VPWR VPWR _00978_ sky130_fd_sc_hd__and3_1
X_09233_ _03572_ _02161_ _02873_ _02875_ VGND VGND VPWR VPWR _02877_ sky130_fd_sc_hd__nand4_1
XFILLER_0_8_533 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
X_06445_ _01782_ _04748_ _02251_ _05574_ _05490_ VGND VGND VPWR VPWR _05575_ sky130_fd_sc_hd__a41o_1
X_09164_ _01580_ _00355_ _02627_ _02628_ VGND VGND VPWR VPWR _02801_ sky130_fd_sc_hd__and4_1
XFILLER_0_28_171 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_44_642 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XFILLER_0_9_51 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
X_08115_ _01473_ _01495_ _01654_ _01655_ VGND VGND VPWR VPWR _01656_ sky130_fd_sc_hd__o211a_1
X_06376_ _05504_ _05505_ _05506_ VGND VGND VPWR VPWR _05507_ sky130_fd_sc_hd__nand3_1
XFILLER_0_114_541 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
X_09095_ _02551_ _02553_ VGND VGND VPWR VPWR _02726_ sky130_fd_sc_hd__nor2_1
XFILLER_0_43_185 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_3_271 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_31_347 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_08046_ _00086_ VGND VGND VPWR VPWR _01580_ sky130_fd_sc_hd__clkbuf_4
XFILLER_0_12_550 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XTAP_TAPCELL_ROW_112_1658 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
X_09997_ _00236_ _01441_ _01620_ _01379_ VGND VGND VPWR VPWR _03710_ sky130_fd_sc_hd__a22o_1
XFILLER_0_86_91 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
X_08948_ _02402_ _02564_ VGND VGND VPWR VPWR _02565_ sky130_fd_sc_hd__nor2_1
X_08879_ _02487_ _02488_ VGND VGND VPWR VPWR _02489_ sky130_fd_sc_hd__nor2_2
X_10910_ _04623_ _04702_ _04703_ VGND VGND VPWR VPWR _04704_ sky130_fd_sc_hd__or3_2
XTAP_TAPCELL_ROW_67_1104 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_79_561 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_10841_ _04527_ _04529_ _04627_ _04628_ VGND VGND VPWR VPWR _04630_ sky130_fd_sc_hd__o211a_1
XFILLER_0_39_436 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
X_10772_ _04492_ _04494_ VGND VGND VPWR VPWR _04554_ sky130_fd_sc_hd__nand2_1
XFILLER_0_39_447 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_109_335 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_81_214 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XFILLER_0_81_225 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XFILLER_0_62_450 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_50_601 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_34_141 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XTAP_TAPCELL_ROW_78_1233 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_62_494 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_0_120_522 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_11324_ _05150_ _05152_ VGND VGND VPWR VPWR net117 sky130_fd_sc_hd__xnor2_4
XFILLER_0_105_574 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
X_11255_ _03396_ _02228_ VGND VGND VPWR VPWR _05078_ sky130_fd_sc_hd__nand2_1
XTAP_TAPCELL_ROW_91_1400 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
X_10206_ _03838_ _03840_ VGND VGND VPWR VPWR _03938_ sky130_fd_sc_hd__nand2_1
XFILLER_0_120_599 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
X_11186_ _04990_ _04993_ VGND VGND VPWR VPWR _05003_ sky130_fd_sc_hd__or2b_1
XFILLER_0_100_290 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
X_10137_ _01221_ _01680_ _03861_ _03862_ VGND VGND VPWR VPWR _03863_ sky130_fd_sc_hd__o2bb2a_1
X_10068_ net138 _03786_ _03678_ _03679_ VGND VGND VPWR VPWR _03788_ sky130_fd_sc_hd__o211a_1
XPHY_EDGE_ROW_13_Right_13 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XTAP_TAPCELL_ROW_89_1373 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_58_701 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XTAP_TAPCELL_ROW_46_832 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_46_843 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_57_222 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XFILLER_0_85_564 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
X_06230_ _05360_ _05361_ _05324_ VGND VGND VPWR VPWR _05363_ sky130_fd_sc_hd__o21ai_1
XPHY_EDGE_ROW_22_Right_22 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_0_80_280 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_5_558 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XFILLER_0_13_303 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_41_623 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
X_06161_ _05291_ _05285_ _04444_ VGND VGND VPWR VPWR _05295_ sky130_fd_sc_hd__a21bo_1
XFILLER_0_79_7 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
X_06092_ _00461_ _03026_ _04085_ _01236_ VGND VGND VPWR VPWR _04574_ sky130_fd_sc_hd__a22oi_1
X_09920_ _00411_ _02943_ _03491_ _00546_ VGND VGND VPWR VPWR _03626_ sky130_fd_sc_hd__a22o_1
X_09851_ _03546_ _03547_ _03548_ VGND VGND VPWR VPWR _03551_ sky130_fd_sc_hd__a21o_1
XFILLER_0_0_296 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
X_09782_ _00076_ _03247_ VGND VGND VPWR VPWR _03476_ sky130_fd_sc_hd__nand2_2
X_08802_ _02233_ _02275_ _02404_ VGND VGND VPWR VPWR _02405_ sky130_fd_sc_hd__a21o_2
X_06994_ _00843_ _00301_ _00430_ _02447_ VGND VGND VPWR VPWR _00432_ sky130_fd_sc_hd__a22o_1
XPHY_EDGE_ROW_31_Right_31 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
X_05945_ _02950_ _02961_ VGND VGND VPWR VPWR net127 sky130_fd_sc_hd__nor2_4
X_08733_ net3 _00983_ VGND VGND VPWR VPWR _02331_ sky130_fd_sc_hd__and2_1
XFILLER_0_22_3 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
X_08664_ _02062_ _02066_ VGND VGND VPWR VPWR _02255_ sky130_fd_sc_hd__nand2_1
XFILLER_0_49_701 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
X_05876_ _02208_ VGND VGND VPWR VPWR _02219_ sky130_fd_sc_hd__buf_4
X_08595_ _00985_ _01449_ _02177_ _00308_ VGND VGND VPWR VPWR _02180_ sky130_fd_sc_hd__a22o_1
X_07615_ _02065_ _00565_ _01109_ _00308_ VGND VGND VPWR VPWR _01110_ sky130_fd_sc_hd__a22oi_2
XFILLER_0_119_622 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
X_07546_ _00738_ _00903_ VGND VGND VPWR VPWR _01034_ sky130_fd_sc_hd__nand2_1
XFILLER_0_118_121 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XTAP_TAPCELL_ROW_62_1034 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_24_559 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_118_154 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XPHY_EDGE_ROW_101_Left_223 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
X_09216_ _02836_ _02856_ _02857_ VGND VGND VPWR VPWR _02858_ sky130_fd_sc_hd__nand3_4
XFILLER_0_63_225 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_0_8_363 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_29_480 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_0_29_491 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
X_07477_ _00956_ _00957_ _00958_ VGND VGND VPWR VPWR _00959_ sky130_fd_sc_hd__and3_1
XPHY_EDGE_ROW_40_Right_40 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_0_118_176 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_63_258 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
X_06428_ _05554_ _05555_ _01236_ _05557_ VGND VGND VPWR VPWR _05558_ sky130_fd_sc_hd__and4bb_1
XFILLER_0_8_374 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XFILLER_0_16_141 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
X_09147_ _02770_ _02780_ _02781_ VGND VGND VPWR VPWR _02782_ sky130_fd_sc_hd__and3b_1
XFILLER_0_17_697 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_32_612 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
X_06359_ _05327_ _03080_ _05487_ _05488_ VGND VGND VPWR VPWR _05490_ sky130_fd_sc_hd__and4_1
X_09078_ _02704_ _02706_ VGND VGND VPWR VPWR _02707_ sky130_fd_sc_hd__nand2_1
XFILLER_0_31_111 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_102_533 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
X_08029_ _01412_ _01413_ _01559_ _01560_ VGND VGND VPWR VPWR _01561_ sky130_fd_sc_hd__a211o_1
X_11040_ _04827_ _04844_ VGND VGND VPWR VPWR _04845_ sky130_fd_sc_hd__xnor2_2
XTAP_TAPCELL_ROW_73_1174 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XPHY_EDGE_ROW_110_Left_232 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_0_86_306 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XFILLER_0_86_317 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_0_52_19 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XTAP_TAPCELL_ROW_43_802 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
X_10824_ _04608_ _04609_ _04598_ VGND VGND VPWR VPWR _04611_ sky130_fd_sc_hd__a21oi_2
XFILLER_0_67_553 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_0_94_372 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XFILLER_0_39_255 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_10755_ _04407_ _04409_ _04535_ VGND VGND VPWR VPWR _04536_ sky130_fd_sc_hd__a21o_1
XFILLER_0_82_523 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
X_10686_ _04458_ _04459_ VGND VGND VPWR VPWR _04460_ sky130_fd_sc_hd__xnor2_1
XFILLER_0_82_589 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XFILLER_0_54_247 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_0_23_634 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_105_393 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
X_11307_ _05132_ _05133_ VGND VGND VPWR VPWR _05134_ sky130_fd_sc_hd__nand2_1
XFILLER_0_77_27 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_10_306 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XFILLER_0_120_363 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_120_396 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
X_11238_ _04928_ _04932_ _04994_ VGND VGND VPWR VPWR _05060_ sky130_fd_sc_hd__a21o_1
X_11169_ _04942_ _04984_ VGND VGND VPWR VPWR _04985_ sky130_fd_sc_hd__xnor2_1
XFILLER_0_93_15 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_117_55 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_89_155 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_26_53 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_0_26_75 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_05730_ net1 VGND VGND VPWR VPWR _00624_ sky130_fd_sc_hd__buf_4
XFILLER_0_89_199 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_26_97 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
X_08380_ _05387_ _00686_ _00558_ _05319_ VGND VGND VPWR VPWR _01945_ sky130_fd_sc_hd__a22o_1
XFILLER_0_9_105 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
X_07400_ _00873_ _00874_ VGND VGND VPWR VPWR _00875_ sky130_fd_sc_hd__nand2_1
XFILLER_0_73_501 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_0_9_127 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
X_07331_ _00076_ _00798_ VGND VGND VPWR VPWR _00800_ sky130_fd_sc_hd__nand2_1
XFILLER_0_42_85 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_0_115_113 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
X_07262_ _00722_ _00724_ VGND VGND VPWR VPWR _00725_ sky130_fd_sc_hd__or2_2
XTAP_TAPCELL_ROW_21_529 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_115_157 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
X_09001_ _00610_ _02620_ _02621_ VGND VGND VPWR VPWR _02623_ sky130_fd_sc_hd__a21bo_1
X_07193_ _00645_ _00647_ _00510_ _00607_ VGND VGND VPWR VPWR _00649_ sky130_fd_sc_hd__o211a_1
XFILLER_0_5_333 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_0_14_601 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
X_06213_ _03365_ _05341_ _05345_ _00799_ VGND VGND VPWR VPWR _05346_ sky130_fd_sc_hd__a22o_1
XFILLER_0_103_308 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_14_667 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
X_06144_ _05106_ _05116_ _05127_ VGND VGND VPWR VPWR _05138_ sky130_fd_sc_hd__nand3_2
XFILLER_0_13_155 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
X_06075_ _04314_ _04325_ _04368_ VGND VGND VPWR VPWR _04390_ sky130_fd_sc_hd__a21oi_1
XFILLER_0_6_41 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_1_561 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_41_497 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
X_09903_ _00802_ _05686_ _01674_ _01675_ VGND VGND VPWR VPWR _03608_ sky130_fd_sc_hd__and4_1
X_09834_ _05574_ _02230_ _03481_ _03531_ VGND VGND VPWR VPWR _03532_ sky130_fd_sc_hd__a31o_2
XFILLER_0_6_85 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
X_09765_ _03421_ _03309_ _03455_ _03456_ VGND VGND VPWR VPWR _03457_ sky130_fd_sc_hd__o211ai_4
X_06977_ net29 _02208_ net37 net38 VGND VGND VPWR VPWR _00413_ sky130_fd_sc_hd__and4_1
X_09696_ _03065_ _03067_ _03078_ _03225_ VGND VGND VPWR VPWR _03382_ sky130_fd_sc_hd__o22a_1
X_08716_ _02296_ _02310_ _02311_ VGND VGND VPWR VPWR _02312_ sky130_fd_sc_hd__and3_1
XTAP_TAPCELL_ROW_29_629 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
X_05928_ _02753_ _02775_ VGND VGND VPWR VPWR _02786_ sky130_fd_sc_hd__xnor2_2
X_08647_ _02045_ VGND VGND VPWR VPWR _02236_ sky130_fd_sc_hd__buf_4
XTAP_TAPCELL_ROW_1_276 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
X_05859_ _01519_ _01541_ _01989_ _02022_ VGND VGND VPWR VPWR _02032_ sky130_fd_sc_hd__a211o_1
XFILLER_0_76_350 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_49_575 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
X_08578_ _02160_ VGND VGND VPWR VPWR _02161_ sky130_fd_sc_hd__buf_4
XTAP_TAPCELL_ROW_120_1768 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_120_1757 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_119_452 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
X_07529_ _00909_ _00860_ _01014_ _01015_ VGND VGND VPWR VPWR _01016_ sky130_fd_sc_hd__o211ai_4
X_10540_ _04300_ _04301_ VGND VGND VPWR VPWR _04302_ sky130_fd_sc_hd__xnor2_1
XFILLER_0_36_258 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
X_10471_ _04190_ _04080_ _04225_ _04226_ VGND VGND VPWR VPWR _04228_ sky130_fd_sc_hd__o211ai_2
XFILLER_0_64_589 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XFILLER_0_106_168 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XTAP_TAPCELL_ROW_75_1203 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_20_604 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_20_659 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XTAP_TAPCELL_ROW_9_376 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
X_11023_ _04825_ _04826_ VGND VGND VPWR VPWR _04827_ sky130_fd_sc_hd__xnor2_2
XFILLER_0_99_431 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XTAP_TAPCELL_ROW_86_1343 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_86_1332 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_59_317 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XTAP_TAPCELL_ROW_56_960 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_55_501 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
X_10807_ _02325_ _03478_ _04490_ _04591_ VGND VGND VPWR VPWR _04592_ sky130_fd_sc_hd__a31o_1
X_10738_ _04514_ _04515_ _04425_ _04427_ VGND VGND VPWR VPWR _04517_ sky130_fd_sc_hd__a211oi_2
XFILLER_0_55_567 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_43_707 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_0_103_68 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_82_397 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_0_70_515 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_12_77 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
X_10669_ _04361_ _04362_ _04440_ _04441_ VGND VGND VPWR VPWR _04442_ sky130_fd_sc_hd__o211ai_4
XFILLER_0_112_127 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
Xoutput106 net106 VGND VGND VPWR VPWR product[47] sky130_fd_sc_hd__clkbuf_4
XTAP_TAPCELL_ROW_97_1472 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_2_347 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
Xoutput128 net128 VGND VGND VPWR VPWR product[9] sky130_fd_sc_hd__buf_2
Xoutput117 net117 VGND VGND VPWR VPWR product[57] sky130_fd_sc_hd__clkbuf_4
XFILLER_0_56_9 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
X_06900_ _00326_ _00327_ _00231_ VGND VGND VPWR VPWR _00329_ sky130_fd_sc_hd__a21oi_1
X_07880_ _01396_ _01397_ _01385_ VGND VGND VPWR VPWR _01399_ sky130_fd_sc_hd__o21a_1
X_06831_ _00232_ _00233_ _00255_ _00256_ VGND VGND VPWR VPWR _00257_ sky130_fd_sc_hd__o211a_1
X_09550_ _02915_ _03060_ _03221_ VGND VGND VPWR VPWR _03222_ sky130_fd_sc_hd__a21boi_4
X_06762_ _05695_ VGND VGND VPWR VPWR _00189_ sky130_fd_sc_hd__clkbuf_4
X_09481_ _02987_ _02989_ VGND VGND VPWR VPWR _03147_ sky130_fd_sc_hd__nand2_1
X_08501_ _01882_ _01884_ _02074_ _02075_ VGND VGND VPWR VPWR _02077_ sky130_fd_sc_hd__o211a_1
X_05713_ _00428_ VGND VGND VPWR VPWR _00439_ sky130_fd_sc_hd__buf_4
XFILLER_0_77_147 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_06693_ _00018_ _00020_ _00119_ _00120_ VGND VGND VPWR VPWR _00121_ sky130_fd_sc_hd__o211a_1
X_08432_ _01998_ _01999_ _01975_ VGND VGND VPWR VPWR _02002_ sky130_fd_sc_hd__a21oi_2
XTAP_TAPCELL_ROW_106_1590 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_93_629 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_77_169 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_0_53_95 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_86_681 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
X_08363_ _01923_ _01925_ _01917_ VGND VGND VPWR VPWR _01927_ sky130_fd_sc_hd__a21o_1
X_08294_ _00908_ _02666_ _01675_ VGND VGND VPWR VPWR _01851_ sky130_fd_sc_hd__and3_1
X_07314_ _00771_ _00780_ VGND VGND VPWR VPWR _00781_ sky130_fd_sc_hd__xnor2_1
XTAP_TAPCELL_ROW_34_687 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_116_433 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_6_642 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
X_07245_ _00563_ _00573_ _00572_ VGND VGND VPWR VPWR _00706_ sky130_fd_sc_hd__a21bo_1
XFILLER_0_33_206 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_116_477 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_0_104_617 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_103_127 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XFILLER_0_14_464 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
X_07176_ _00500_ _00508_ VGND VGND VPWR VPWR _00630_ sky130_fd_sc_hd__nand2_1
X_06127_ _04933_ _04943_ VGND VGND VPWR VPWR _04954_ sky130_fd_sc_hd__and2b_1
XFILLER_0_41_294 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
X_06058_ _03539_ _03529_ _03550_ VGND VGND VPWR VPWR _04205_ sky130_fd_sc_hd__or3_1
XFILLER_0_10_681 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XTAP_TAPCELL_ROW_6_335 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_70_1133 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_109_1619 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
X_09817_ _03464_ _03465_ _03512_ _03513_ VGND VGND VPWR VPWR _03514_ sky130_fd_sc_hd__nor4_1
X_09748_ _03426_ _03437_ VGND VGND VPWR VPWR _03438_ sky130_fd_sc_hd__xnor2_2
XFILLER_0_69_615 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_69_604 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_96_445 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
X_09679_ _03316_ _03317_ _03360_ _03361_ VGND VGND VPWR VPWR _03363_ sky130_fd_sc_hd__a22oi_2
XFILLER_0_56_309 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XTAP_TAPCELL_ROW_53_930 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_81_1273 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_37_567 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_0_107_444 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
X_10523_ _04280_ _04282_ _04276_ _04277_ VGND VGND VPWR VPWR _04284_ sky130_fd_sc_hd__a211o_1
Xinput19 mcand[26] VGND VGND VPWR VPWR net19 sky130_fd_sc_hd__buf_4
X_10454_ _04108_ _04110_ VGND VGND VPWR VPWR _04209_ sky130_fd_sc_hd__nand2_1
X_10385_ _04131_ _04132_ _04038_ _04019_ VGND VGND VPWR VPWR _04134_ sky130_fd_sc_hd__a211o_1
XFILLER_0_60_570 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_0_58_29 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XFILLER_0_20_401 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_0_32_294 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_0_20_489 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_11006_ _04734_ _04736_ _04643_ VGND VGND VPWR VPWR _04808_ sky130_fd_sc_hd__o21ai_2
XFILLER_0_87_412 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_87_445 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_0_87_489 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_59_169 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_59_158 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_28_512 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XTAP_TAPCELL_ROW_99_1501 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_7_439 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_7_417 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XFILLER_0_83_673 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_82_150 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XTAP_TAPCELL_ROW_31_646 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_55_397 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_43_559 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_113_447 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_70_378 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
X_07030_ _00466_ _00469_ _00470_ VGND VGND VPWR VPWR _00471_ sky130_fd_sc_hd__a21oi_2
XFILLER_0_2_133 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_0_100_119 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_0_61_7 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_0_2_177 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
X_08981_ _05419_ _02064_ _02598_ _02599_ VGND VGND VPWR VPWR _02601_ sky130_fd_sc_hd__a22o_1
XFILLER_0_48_51 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
X_07932_ _01452_ _01453_ _01454_ VGND VGND VPWR VPWR _01457_ sky130_fd_sc_hd__a21o_1
X_07863_ _01380_ _01213_ VGND VGND VPWR VPWR _01381_ sky130_fd_sc_hd__nor2_1
XTAP_TAPCELL_ROW_3_305 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
X_09602_ _03275_ _03276_ _03163_ _03165_ VGND VGND VPWR VPWR _03279_ sky130_fd_sc_hd__o211a_1
X_06814_ _00239_ VGND VGND VPWR VPWR _00240_ sky130_fd_sc_hd__inv_2
XFILLER_0_78_401 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
X_09533_ _03018_ _03020_ _03202_ _03203_ VGND VGND VPWR VPWR _03204_ sky130_fd_sc_hd__a211o_1
XFILLER_0_64_50 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
X_07794_ _01303_ _01304_ _01131_ _01156_ VGND VGND VPWR VPWR _01306_ sky130_fd_sc_hd__a211o_1
XTAP_TAPCELL_ROW_39_746 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_78_445 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
X_06745_ _00170_ _00171_ VGND VGND VPWR VPWR _00172_ sky130_fd_sc_hd__xnor2_1
XFILLER_0_78_489 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
X_09464_ _03126_ _03127_ VGND VGND VPWR VPWR _03128_ sky130_fd_sc_hd__or2b_2
X_06676_ _05691_ _00002_ _00001_ VGND VGND VPWR VPWR _00104_ sky130_fd_sc_hd__a21bo_1
XFILLER_0_38_309 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_0_109_709 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_09395_ _02890_ _02892_ VGND VGND VPWR VPWR _03053_ sky130_fd_sc_hd__nor2_1
XFILLER_0_65_139 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
X_08415_ _01980_ _01981_ _01982_ VGND VGND VPWR VPWR _01983_ sky130_fd_sc_hd__a21bo_1
X_08346_ _05008_ _05585_ _00150_ _00349_ VGND VGND VPWR VPWR _01908_ sky130_fd_sc_hd__nand4_1
XFILLER_0_73_161 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_73_194 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_61_345 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
X_08277_ net141 _01713_ _01830_ _01831_ VGND VGND VPWR VPWR _01833_ sky130_fd_sc_hd__o22ai_2
XFILLER_0_61_367 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
X_07228_ _01662_ _00686_ VGND VGND VPWR VPWR _00687_ sky130_fd_sc_hd__nand2_1
X_07159_ net15 VGND VGND VPWR VPWR _00611_ sky130_fd_sc_hd__clkbuf_4
X_10170_ _03860_ _03897_ _03898_ VGND VGND VPWR VPWR _03899_ sky130_fd_sc_hd__nand3_4
XFILLER_0_100_642 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XFILLER_0_88_209 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_96_220 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XTAP_TAPCELL_ROW_83_1302 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_96_253 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_0_96_275 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XPHY_EDGE_ROW_69_Right_69 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_0_65_651 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_65_673 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
X_10506_ _04160_ _04163_ _04159_ VGND VGND VPWR VPWR _04265_ sky130_fd_sc_hd__a21o_1
XFILLER_0_110_406 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
X_10437_ _03935_ net161 _04077_ VGND VGND VPWR VPWR _04190_ sky130_fd_sc_hd__nor3_1
XTAP_TAPCELL_ROW_94_1431 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_94_1442 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XPHY_EDGE_ROW_78_Right_78 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_0_0_615 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
X_10368_ _04103_ _04113_ _04114_ VGND VGND VPWR VPWR _04115_ sky130_fd_sc_hd__and3_1
XFILLER_0_20_253 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_10299_ _03855_ _03975_ _03977_ VGND VGND VPWR VPWR _04039_ sky130_fd_sc_hd__nand3_2
XFILLER_0_85_27 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_18_65 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XTAP_TAPCELL_ROW_36_716 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XPHY_EDGE_ROW_87_Right_87 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
X_06530_ _02000_ VGND VGND VPWR VPWR _05659_ sky130_fd_sc_hd__buf_4
X_06461_ _05588_ _05590_ VGND VGND VPWR VPWR _05591_ sky130_fd_sc_hd__xor2_2
XTAP_TAPCELL_ROW_16_462 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
X_08200_ _01732_ _01746_ _01747_ VGND VGND VPWR VPWR _01748_ sky130_fd_sc_hd__and3_2
X_09180_ _02646_ _02325_ _02815_ _02816_ VGND VGND VPWR VPWR _02818_ sky130_fd_sc_hd__nand4_2
XFILLER_0_7_225 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
X_06392_ _05520_ _05521_ _05458_ VGND VGND VPWR VPWR _05523_ sky130_fd_sc_hd__a21oi_1
XFILLER_0_114_701 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
X_08131_ _01671_ VGND VGND VPWR VPWR _01673_ sky130_fd_sc_hd__clkbuf_4
XFILLER_0_83_492 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_0_70_120 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_0_55_183 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_0_50_85 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
X_08062_ _01578_ _01579_ _01597_ VGND VGND VPWR VPWR _01598_ sky130_fd_sc_hd__a21o_2
XFILLER_0_31_518 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_43_345 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XPHY_EDGE_ROW_96_Right_96 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_0_70_197 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
X_07013_ _00378_ _00379_ _00451_ _00452_ VGND VGND VPWR VPWR _00453_ sky130_fd_sc_hd__or4bb_4
XFILLER_0_113_288 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_0_101_406 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_59_83 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_11_253 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
X_08964_ _01850_ _02580_ _02581_ VGND VGND VPWR VPWR _02582_ sky130_fd_sc_hd__a21bo_1
X_07915_ _01434_ _01437_ VGND VGND VPWR VPWR _01438_ sky130_fd_sc_hd__xor2_2
X_08895_ _02497_ _02505_ _02506_ VGND VGND VPWR VPWR _02507_ sky130_fd_sc_hd__nand3_1
X_07846_ _01332_ _01360_ VGND VGND VPWR VPWR _01362_ sky130_fd_sc_hd__and2_1
X_07777_ _01283_ _01285_ _01286_ VGND VGND VPWR VPWR _01287_ sky130_fd_sc_hd__nand3_1
XFILLER_0_94_713 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_0_78_253 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
X_09516_ _03028_ _03038_ _03036_ VGND VGND VPWR VPWR _03185_ sky130_fd_sc_hd__a21bo_1
X_06728_ _00135_ _00154_ VGND VGND VPWR VPWR _00155_ sky130_fd_sc_hd__xnor2_2
XFILLER_0_39_607 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_93_223 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_93_212 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
X_09447_ _00409_ _02947_ _03106_ _03107_ VGND VGND VPWR VPWR _03109_ sky130_fd_sc_hd__nand4_4
XTAP_TAPCELL_ROW_65_1076 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_38_139 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
X_06659_ _00086_ VGND VGND VPWR VPWR _00087_ sky130_fd_sc_hd__clkbuf_4
XFILLER_0_74_470 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
X_09378_ _04802_ _03124_ _01805_ _01987_ VGND VGND VPWR VPWR _03034_ sky130_fd_sc_hd__and4_1
XFILLER_0_47_673 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_117_561 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_0_74_492 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
X_08329_ _01867_ _01887_ _01888_ VGND VGND VPWR VPWR _01889_ sky130_fd_sc_hd__nor3_1
XTAP_TAPCELL_ROW_117_1729 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_104_222 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_0_104_211 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
X_11340_ _05156_ _05128_ _05167_ VGND VGND VPWR VPWR _05169_ sky130_fd_sc_hd__a21oi_1
X_11271_ _05093_ _05094_ VGND VGND VPWR VPWR _05096_ sky130_fd_sc_hd__xnor2_1
X_10222_ _03574_ _01903_ VGND VGND VPWR VPWR _03956_ sky130_fd_sc_hd__nand2_1
X_10153_ _01762_ _01943_ _03490_ _03491_ VGND VGND VPWR VPWR _03881_ sky130_fd_sc_hd__nand4_2
XFILLER_0_100_494 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_100_483 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
X_10084_ net6 _02692_ VGND VGND VPWR VPWR _03805_ sky130_fd_sc_hd__and2_1
X_10986_ _04727_ _04707_ _04785_ _04786_ VGND VGND VPWR VPWR _04787_ sky130_fd_sc_hd__o211ai_4
XFILLER_0_85_713 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_84_223 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XTAP_TAPCELL_ROW_13_421 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_53_643 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XTAP_TAPCELL_ROW_41_774 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_111_57 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_52_175 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
Xmax_cap138 _03785_ VGND VGND VPWR VPWR net138 sky130_fd_sc_hd__buf_1
XFILLER_0_96_15 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_52_197 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_21_540 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
Xmax_cap149 _00111_ VGND VGND VPWR VPWR net149 sky130_fd_sc_hd__clkbuf_2
XFILLER_0_110_225 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_0_29_42 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
X_05961_ _03113_ _03135_ VGND VGND VPWR VPWR _03146_ sky130_fd_sc_hd__and2b_1
X_07700_ _01052_ _00901_ _01049_ VGND VGND VPWR VPWR _01202_ sky130_fd_sc_hd__and3b_1
X_08680_ _02270_ _02271_ VGND VGND VPWR VPWR _02272_ sky130_fd_sc_hd__xnor2_4
X_05892_ _02372_ _02383_ VGND VGND VPWR VPWR _02394_ sky130_fd_sc_hd__xor2_4
XTAP_TAPCELL_ROW_49_874 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
X_07631_ _01123_ _01124_ _01125_ VGND VGND VPWR VPWR _01128_ sky130_fd_sc_hd__a21o_1
X_07562_ _01037_ _01038_ _01048_ VGND VGND VPWR VPWR _01052_ sky130_fd_sc_hd__a21oi_1
XFILLER_0_45_85 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_76_713 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
X_09301_ _02946_ _02948_ _02940_ VGND VGND VPWR VPWR _02951_ sky130_fd_sc_hd__a21o_1
X_06513_ _05640_ _05641_ VGND VGND VPWR VPWR _05642_ sky130_fd_sc_hd__nor2_1
XTAP_TAPCELL_ROW_101_1519 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_75_223 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
X_07493_ _03080_ _05693_ _00973_ _00975_ VGND VGND VPWR VPWR _00977_ sky130_fd_sc_hd__a22o_1
X_09232_ _03091_ _02161_ _02873_ _02875_ VGND VGND VPWR VPWR _02876_ sky130_fd_sc_hd__a22o_1
XFILLER_0_8_545 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_29_673 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
X_06444_ _04922_ VGND VGND VPWR VPWR _05574_ sky130_fd_sc_hd__buf_4
X_09163_ _01759_ _01582_ _00344_ _00346_ VGND VGND VPWR VPWR _02800_ sky130_fd_sc_hd__and4_1
XFILLER_0_8_589 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
X_06375_ _05422_ _05426_ _05424_ VGND VGND VPWR VPWR _05506_ sky130_fd_sc_hd__a21bo_1
XFILLER_0_44_621 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_08114_ _01531_ _01532_ _01652_ _01653_ VGND VGND VPWR VPWR _01655_ sky130_fd_sc_hd__o22ai_2
XFILLER_0_44_676 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
X_09094_ _02617_ _02724_ VGND VGND VPWR VPWR _02725_ sky130_fd_sc_hd__xor2_4
XFILLER_0_16_389 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_31_315 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
X_08045_ _01431_ _01439_ VGND VGND VPWR VPWR _01579_ sky130_fd_sc_hd__nand2_1
XFILLER_0_31_337 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_0_43_197 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XTAP_TAPCELL_ROW_112_1659 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
X_09996_ _02141_ _00623_ _03570_ _03571_ VGND VGND VPWR VPWR _03709_ sky130_fd_sc_hd__and4_1
X_08947_ _02403_ _02563_ VGND VGND VPWR VPWR _02564_ sky130_fd_sc_hd__xnor2_1
X_08878_ _02485_ _02486_ _02450_ VGND VGND VPWR VPWR _02488_ sky130_fd_sc_hd__a21oi_1
XTAP_TAPCELL_ROW_67_1105 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
X_07829_ _01340_ _01341_ _00351_ net19 VGND VGND VPWR VPWR _01343_ sky130_fd_sc_hd__and4bb_1
X_10840_ _04625_ _04626_ _04521_ _04523_ VGND VGND VPWR VPWR _04628_ sky130_fd_sc_hd__o211ai_2
XFILLER_0_66_212 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
X_10771_ _04534_ _04536_ VGND VGND VPWR VPWR _04553_ sky130_fd_sc_hd__nand2_1
XFILLER_0_66_223 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_0_26_109 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_0_19_183 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XFILLER_0_35_643 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XFILLER_0_117_391 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XTAP_TAPCELL_ROW_78_1234 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_50_613 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_34_175 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
X_11323_ _05101_ _05151_ _05099_ VGND VGND VPWR VPWR _05152_ sky130_fd_sc_hd__a21oi_2
XFILLER_0_105_586 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
X_11254_ _05075_ _05076_ VGND VGND VPWR VPWR _05077_ sky130_fd_sc_hd__xnor2_1
XTAP_TAPCELL_ROW_91_1401 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_120_589 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_10205_ _03935_ _03936_ VGND VGND VPWR VPWR _03937_ sky130_fd_sc_hd__nand2_1
X_11185_ _04940_ _04989_ VGND VGND VPWR VPWR _05002_ sky130_fd_sc_hd__nand2_1
XFILLER_0_100_280 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
X_10136_ _00089_ _00421_ _02036_ _01499_ VGND VGND VPWR VPWR _03862_ sky130_fd_sc_hd__and4_1
X_10067_ _03678_ _03679_ net138 _03786_ VGND VGND VPWR VPWR _03787_ sky130_fd_sc_hd__a211oi_4
XTAP_TAPCELL_ROW_89_1374 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_89_337 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_0_82_39 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XTAP_TAPCELL_ROW_46_833 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_15_55 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
X_10969_ _04765_ _04766_ _04756_ VGND VGND VPWR VPWR _04768_ sky130_fd_sc_hd__a21oi_1
XFILLER_0_97_381 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_85_576 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XTAP_TAPCELL_ROW_26_590 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_110_3 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_86_9 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_0_13_326 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XFILLER_0_25_175 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
X_06160_ _04444_ _05285_ _05291_ VGND VGND VPWR VPWR _05294_ sky130_fd_sc_hd__nand3b_2
XFILLER_0_80_292 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_06091_ _02666_ _00362_ _04531_ _04552_ VGND VGND VPWR VPWR _04563_ sky130_fd_sc_hd__and4_1
XFILLER_0_25_197 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_0_40_156 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_41_679 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_0_253 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
X_09850_ _03546_ _03547_ _03548_ VGND VGND VPWR VPWR _03549_ sky130_fd_sc_hd__nand3_2
X_09781_ _03472_ _03473_ VGND VGND VPWR VPWR _03475_ sky130_fd_sc_hd__xnor2_4
X_08801_ _02274_ _02234_ VGND VGND VPWR VPWR _02404_ sky130_fd_sc_hd__and2b_1
X_06993_ _00799_ _03365_ _00301_ _00430_ VGND VGND VPWR VPWR _00431_ sky130_fd_sc_hd__nand4_1
X_05944_ _02928_ _02939_ _01913_ _02394_ VGND VGND VPWR VPWR _02961_ sky130_fd_sc_hd__o2bb2a_1
XFILLER_0_56_73 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
X_08732_ _05307_ _05305_ _01109_ _01620_ VGND VGND VPWR VPWR _02330_ sky130_fd_sc_hd__nand4_1
X_08663_ _02092_ _02100_ _02099_ VGND VGND VPWR VPWR _02254_ sky130_fd_sc_hd__a21oi_1
XFILLER_0_15_3 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
X_05875_ net30 VGND VGND VPWR VPWR _02208_ sky130_fd_sc_hd__clkbuf_4
X_08594_ _00974_ _00985_ _01449_ VGND VGND VPWR VPWR _02179_ sky130_fd_sc_hd__and3_1
XFILLER_0_49_713 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
X_07614_ net47 VGND VGND VPWR VPWR _01109_ sky130_fd_sc_hd__clkbuf_4
XFILLER_0_72_83 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
X_07545_ _00907_ _01016_ _01017_ VGND VGND VPWR VPWR _01033_ sky130_fd_sc_hd__nand3_1
XFILLER_0_119_634 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_76_576 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_63_204 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XTAP_TAPCELL_ROW_62_1035 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
X_07476_ net3 _05425_ VGND VGND VPWR VPWR _00958_ sky130_fd_sc_hd__and2_1
XFILLER_0_118_133 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
X_09215_ _02854_ _02855_ _02846_ VGND VGND VPWR VPWR _02857_ sky130_fd_sc_hd__a21o_1
X_06427_ net6 VGND VGND VPWR VPWR _05557_ sky130_fd_sc_hd__buf_4
X_09146_ _02778_ _02779_ _02771_ VGND VGND VPWR VPWR _02781_ sky130_fd_sc_hd__a21o_1
X_06358_ _05486_ _05410_ _05487_ _05488_ VGND VGND VPWR VPWR _05489_ sky130_fd_sc_hd__a22oi_1
XFILLER_0_102_512 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XFILLER_0_71_281 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
X_09077_ _00319_ _00340_ _02705_ _02185_ VGND VGND VPWR VPWR _02706_ sky130_fd_sc_hd__nand4_1
XFILLER_0_32_668 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_06289_ _05418_ _05420_ VGND VGND VPWR VPWR _05421_ sky130_fd_sc_hd__xnor2_2
X_08028_ _05008_ net9 _01557_ _01558_ VGND VGND VPWR VPWR _01560_ sky130_fd_sc_hd__and4_1
XFILLER_0_102_589 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XTAP_TAPCELL_ROW_73_1175 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
X_09979_ _02177_ VGND VGND VPWR VPWR _03690_ sky130_fd_sc_hd__buf_4
XFILLER_0_98_167 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XPHY_EDGE_ROW_105_Right_105 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
X_10823_ _04598_ _04608_ _04609_ VGND VGND VPWR VPWR _04610_ sky130_fd_sc_hd__and3_2
XTAP_TAPCELL_ROW_43_803 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_109_111 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_39_278 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
X_10754_ _02976_ _03675_ _04410_ VGND VGND VPWR VPWR _04535_ sky130_fd_sc_hd__and3_1
XFILLER_0_109_166 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
X_10685_ _04367_ _03027_ _00042_ VGND VGND VPWR VPWR _04459_ sky130_fd_sc_hd__and3b_1
XFILLER_0_70_719 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_50_410 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_0_112_309 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_105_350 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_50_421 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_22_123 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
X_11306_ _04374_ _02228_ _05131_ VGND VGND VPWR VPWR _05133_ sky130_fd_sc_hd__nand3_1
XFILLER_0_120_375 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
X_11237_ _05057_ _05058_ VGND VGND VPWR VPWR _05059_ sky130_fd_sc_hd__nor2_1
X_11168_ _04981_ _04983_ VGND VGND VPWR VPWR _04984_ sky130_fd_sc_hd__xnor2_1
X_10119_ _03835_ _03841_ _03842_ VGND VGND VPWR VPWR _03843_ sky130_fd_sc_hd__nand3_2
XFILLER_0_93_27 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
X_11099_ _04907_ _04908_ VGND VGND VPWR VPWR _04909_ sky130_fd_sc_hd__nor2_1
XFILLER_0_89_167 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_58_576 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_0_42_42 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
X_07330_ _05655_ VGND VGND VPWR VPWR _00798_ sky130_fd_sc_hd__buf_4
XFILLER_0_73_535 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_58_587 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XTAP_TAPCELL_ROW_21_519 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_73_568 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_09000_ _05686_ _00609_ _01060_ _00802_ VGND VGND VPWR VPWR _02621_ sky130_fd_sc_hd__a22o_1
X_07261_ _00720_ _00721_ _00606_ VGND VGND VPWR VPWR _00724_ sky130_fd_sc_hd__o21a_1
XFILLER_0_115_125 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
X_07192_ _00510_ _00607_ _00645_ _00647_ VGND VGND VPWR VPWR _00648_ sky130_fd_sc_hd__a211oi_2
XFILLER_0_26_451 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_26_473 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
X_06212_ _05342_ VGND VGND VPWR VPWR _05345_ sky130_fd_sc_hd__clkbuf_4
XFILLER_0_115_169 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_0_53_281 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_0_14_635 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_06143_ _03812_ _03922_ _03911_ VGND VGND VPWR VPWR _05127_ sky130_fd_sc_hd__a21bo_1
XFILLER_0_13_167 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_14_679 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
X_06074_ _04314_ _04325_ _04368_ VGND VGND VPWR VPWR _04379_ sky130_fd_sc_hd__and3_1
X_09902_ _01414_ _01353_ _03238_ _00084_ VGND VGND VPWR VPWR _03607_ sky130_fd_sc_hd__a22oi_1
XFILLER_0_6_53 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_1_573 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
X_09833_ _03477_ _03480_ VGND VGND VPWR VPWR _03531_ sky130_fd_sc_hd__and2b_1
XFILLER_0_67_83 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_6_97 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
X_09764_ _03453_ _03454_ _03438_ VGND VGND VPWR VPWR _03456_ sky130_fd_sc_hd__a21o_1
XTAP_TAPCELL_ROW_29_619 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
X_06976_ _01662_ _00089_ _00296_ _00295_ _00411_ VGND VGND VPWR VPWR _00412_ sky130_fd_sc_hd__a32o_1
XFILLER_0_83_60 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
X_09695_ _03378_ _03380_ VGND VGND VPWR VPWR _03381_ sky130_fd_sc_hd__xnor2_4
X_08715_ _02307_ _02308_ _02309_ VGND VGND VPWR VPWR _02311_ sky130_fd_sc_hd__a21o_1
X_05927_ net33 _02764_ VGND VGND VPWR VPWR _02775_ sky130_fd_sc_hd__nand2_1
X_08646_ _02040_ _02042_ VGND VGND VPWR VPWR _02235_ sky130_fd_sc_hd__or2b_1
X_05858_ _00810_ _01497_ _01956_ _02011_ VGND VGND VPWR VPWR _02022_ sky130_fd_sc_hd__o2bb2a_1
XTAP_TAPCELL_ROW_1_277 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_95_159 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_0_76_362 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
X_05789_ _00635_ _00472_ _00384_ _00657_ VGND VGND VPWR VPWR _01269_ sky130_fd_sc_hd__a22oi_1
X_08577_ net52 VGND VGND VPWR VPWR _02160_ sky130_fd_sc_hd__buf_4
XTAP_TAPCELL_ROW_120_1758 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_91_321 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_0_49_587 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
X_07528_ _00947_ _00948_ _01012_ _01013_ VGND VGND VPWR VPWR _01015_ sky130_fd_sc_hd__o22ai_4
XFILLER_0_119_486 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_107_637 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_91_332 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_0_9_673 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
X_07459_ _00771_ _00779_ _00778_ VGND VGND VPWR VPWR _00939_ sky130_fd_sc_hd__a21o_1
X_10470_ _04223_ _04224_ _04206_ VGND VGND VPWR VPWR _04226_ sky130_fd_sc_hd__o21ai_2
XFILLER_0_51_207 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_09129_ _04716_ _02045_ VGND VGND VPWR VPWR _02762_ sky130_fd_sc_hd__nand2_1
XFILLER_0_44_270 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_121_139 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_114_180 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XTAP_TAPCELL_ROW_75_1204 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_20_616 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_0_32_487 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_0_102_386 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XTAP_TAPCELL_ROW_9_377 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
X_11022_ _04767_ _04769_ VGND VGND VPWR VPWR _04826_ sky130_fd_sc_hd__and2b_1
XFILLER_0_99_443 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XTAP_TAPCELL_ROW_86_1333 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_56_961 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
X_10806_ _04488_ _04489_ VGND VGND VPWR VPWR _04591_ sky130_fd_sc_hd__and2b_1
X_10737_ _04425_ _04427_ _04514_ _04515_ VGND VGND VPWR VPWR _04516_ sky130_fd_sc_hd__o211a_1
XFILLER_0_6_109 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_27_237 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_0_82_365 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
X_10668_ _04438_ _04439_ _04293_ _04363_ VGND VGND VPWR VPWR _04441_ sky130_fd_sc_hd__o211ai_4
XFILLER_0_106_670 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_88_27 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_23_410 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_0_35_281 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_112_139 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
X_10599_ _00042_ _03807_ _03027_ _05637_ VGND VGND VPWR VPWR _04366_ sky130_fd_sc_hd__a22oi_1
XTAP_TAPCELL_ROW_97_1473 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
Xoutput107 net107 VGND VGND VPWR VPWR product[48] sky130_fd_sc_hd__clkbuf_4
Xoutput118 net118 VGND VGND VPWR VPWR product[58] sky130_fd_sc_hd__clkbuf_4
XFILLER_0_120_172 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_10_148 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
X_06830_ _00174_ _00234_ _00254_ VGND VGND VPWR VPWR _00256_ sky130_fd_sc_hd__nand3_2
X_06761_ _01662_ _00187_ VGND VGND VPWR VPWR _00188_ sky130_fd_sc_hd__nand2_1
X_09480_ _03134_ _03144_ VGND VGND VPWR VPWR _03145_ sky130_fd_sc_hd__xnor2_2
X_08500_ _02071_ _02072_ _01877_ _01879_ VGND VGND VPWR VPWR _02075_ sky130_fd_sc_hd__o211ai_2
X_06692_ _00117_ _00118_ _05646_ VGND VGND VPWR VPWR _00120_ sky130_fd_sc_hd__o21bai_1
X_05712_ net23 VGND VGND VPWR VPWR _00428_ sky130_fd_sc_hd__buf_4
XFILLER_0_53_52 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
X_08431_ _01975_ _01998_ _01999_ VGND VGND VPWR VPWR _02001_ sky130_fd_sc_hd__and3_2
XTAP_TAPCELL_ROW_106_1591 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_86_693 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_0_58_373 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
X_08362_ _01917_ _01923_ _01925_ VGND VGND VPWR VPWR _01926_ sky130_fd_sc_hd__nand3_1
XFILLER_0_46_502 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_85_181 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
X_08293_ _01674_ VGND VGND VPWR VPWR _01850_ sky130_fd_sc_hd__clkbuf_4
XFILLER_0_6_610 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
X_07313_ _00778_ _00779_ VGND VGND VPWR VPWR _00780_ sky130_fd_sc_hd__and2b_1
XTAP_TAPCELL_ROW_34_688 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_46_546 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
X_07244_ _00702_ _00703_ _00693_ VGND VGND VPWR VPWR _00705_ sky130_fd_sc_hd__a21o_1
XFILLER_0_33_218 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_0_34_719 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_103_106 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_0_14_421 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
X_07175_ _00618_ _00628_ VGND VGND VPWR VPWR _00629_ sky130_fd_sc_hd__xor2_1
X_06126_ _00340_ _03736_ _04922_ _00319_ VGND VGND VPWR VPWR _04943_ sky130_fd_sc_hd__a22o_1
X_06057_ _04161_ _04172_ _03048_ VGND VGND VPWR VPWR _04194_ sky130_fd_sc_hd__a21oi_1
XTAP_TAPCELL_ROW_70_1134 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_10_693 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XTAP_TAPCELL_ROW_6_336 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
X_09816_ _03510_ _03511_ _03466_ _03467_ VGND VGND VPWR VPWR _03513_ sky130_fd_sc_hd__o211a_1
X_09747_ _03435_ _03436_ VGND VGND VPWR VPWR _03437_ sky130_fd_sc_hd__or2b_1
X_06959_ _00392_ _00269_ VGND VGND VPWR VPWR _00393_ sky130_fd_sc_hd__nand2_1
X_09678_ _03316_ _03317_ _03360_ _03361_ VGND VGND VPWR VPWR _03362_ sky130_fd_sc_hd__and4_1
XFILLER_0_96_457 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XTAP_TAPCELL_ROW_53_920 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
X_08629_ _02214_ _02215_ _02030_ VGND VGND VPWR VPWR _02217_ sky130_fd_sc_hd__a21o_1
XFILLER_0_92_641 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XTAP_TAPCELL_ROW_81_1274 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
X_10522_ _04276_ _04277_ _04280_ _04282_ VGND VGND VPWR VPWR _04283_ sky130_fd_sc_hd__o211a_1
XFILLER_0_64_365 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XFILLER_0_17_281 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_0_45_590 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
X_10453_ _04064_ _04072_ _04071_ VGND VGND VPWR VPWR _04208_ sky130_fd_sc_hd__a21o_1
XFILLER_0_60_560 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_0_32_240 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
X_10384_ _04038_ _04019_ _04131_ _04132_ VGND VGND VPWR VPWR _04133_ sky130_fd_sc_hd__o211ai_4
XFILLER_0_103_673 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_20_468 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_11005_ _04805_ _04806_ VGND VGND VPWR VPWR _04807_ sky130_fd_sc_hd__or2_1
XFILLER_0_74_29 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_59_137 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_0_28_524 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XTAP_TAPCELL_ROW_99_1502 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_67_181 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_55_332 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_0_83_685 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_82_162 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_16_719 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_23_99 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XTAP_TAPCELL_ROW_31_647 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_100_109 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_0_11_446 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XFILLER_0_2_189 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
X_08980_ _05589_ _05497_ _00894_ _02061_ VGND VGND VPWR VPWR _02599_ sky130_fd_sc_hd__nand4_2
XFILLER_0_48_41 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
X_07931_ _01452_ _01453_ _01454_ VGND VGND VPWR VPWR _01456_ sky130_fd_sc_hd__nand3_1
XFILLER_0_48_85 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
X_07862_ _03736_ _04922_ _01379_ _00236_ VGND VGND VPWR VPWR _01380_ sky130_fd_sc_hd__and4_1
X_09601_ _03163_ _03165_ _03275_ _03276_ VGND VGND VPWR VPWR _03278_ sky130_fd_sc_hd__a211oi_2
X_06813_ _00384_ _01760_ _00152_ _00237_ VGND VGND VPWR VPWR _00239_ sky130_fd_sc_hd__and4_1
X_09532_ _03199_ _03200_ _03185_ VGND VGND VPWR VPWR _03203_ sky130_fd_sc_hd__a21oi_1
XFILLER_0_64_62 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
X_07793_ _01131_ _01156_ _01303_ _01304_ VGND VGND VPWR VPWR _01305_ sky130_fd_sc_hd__o211ai_4
XTAP_TAPCELL_ROW_39_747 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
X_06744_ _00060_ _00062_ VGND VGND VPWR VPWR _00171_ sky130_fd_sc_hd__and2_1
XFILLER_0_93_405 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_78_457 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_09463_ _03123_ _03125_ _03084_ _03085_ VGND VGND VPWR VPWR _03127_ sky130_fd_sc_hd__o211ai_2
X_06675_ _00100_ _00101_ _00092_ VGND VGND VPWR VPWR _00103_ sky130_fd_sc_hd__a21o_1
XFILLER_0_93_438 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_0_93_416 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
X_09394_ _03050_ _03051_ VGND VGND VPWR VPWR _03052_ sky130_fd_sc_hd__nand2_2
XFILLER_0_59_671 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_19_502 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XFILLER_0_19_513 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
X_08414_ _02065_ _01284_ _01449_ _00308_ VGND VGND VPWR VPWR _01982_ sky130_fd_sc_hd__a22o_1
XFILLER_0_93_449 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_80_83 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_74_630 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_08345_ _05343_ _00485_ _00235_ _05030_ VGND VGND VPWR VPWR _01907_ sky130_fd_sc_hd__a22o_1
XFILLER_0_19_557 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_0_46_321 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_0_46_332 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_0_104_90 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_73_140 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_0_46_365 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_08276_ net141 _01713_ _01830_ _01831_ VGND VGND VPWR VPWR _01832_ sky130_fd_sc_hd__or4_1
XFILLER_0_104_437 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
X_07227_ _00423_ VGND VGND VPWR VPWR _00686_ sky130_fd_sc_hd__clkbuf_4
XFILLER_0_104_459 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
X_07158_ _00609_ VGND VGND VPWR VPWR _00610_ sky130_fd_sc_hd__clkbuf_4
XFILLER_0_14_273 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
X_06109_ _04716_ _03627_ _03758_ _03747_ _04748_ VGND VGND VPWR VPWR _04759_ sky130_fd_sc_hd__a32o_1
X_07089_ _00532_ _00534_ VGND VGND VPWR VPWR _00535_ sky130_fd_sc_hd__xnor2_1
XFILLER_0_100_654 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_100_698 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XTAP_TAPCELL_ROW_83_1303 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_96_232 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_0_65_685 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_64_173 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_52_324 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_0_37_398 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
X_10505_ _04262_ _04263_ VGND VGND VPWR VPWR _04264_ sky130_fd_sc_hd__xnor2_1
XFILLER_0_107_9 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_80_655 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
X_10436_ _04102_ _04120_ _04121_ VGND VGND VPWR VPWR _04189_ sky130_fd_sc_hd__nor3_1
XFILLER_0_100_15 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XTAP_TAPCELL_ROW_94_1432 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_80_699 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_110_418 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XTAP_TAPCELL_ROW_94_1443 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
X_10367_ _04111_ _04112_ _04104_ VGND VGND VPWR VPWR _04114_ sky130_fd_sc_hd__a21o_1
X_10298_ _04017_ VGND VGND VPWR VPWR _04038_ sky130_fd_sc_hd__inv_2
XFILLER_0_85_39 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_20_298 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_109_57 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_18_77 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XTAP_TAPCELL_ROW_36_706 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_36_717 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_87_243 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_0_87_232 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_0_75_405 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
X_06460_ _02677_ _05589_ VGND VGND VPWR VPWR _05590_ sky130_fd_sc_hd__nand2_1
XFILLER_0_34_76 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XTAP_TAPCELL_ROW_103_1550 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_75_449 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XTAP_TAPCELL_ROW_16_463 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_28_321 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_90_419 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
X_08130_ net22 VGND VGND VPWR VPWR _01671_ sky130_fd_sc_hd__clkbuf_4
XPHY_EDGE_ROW_78_Left_200 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_0_55_140 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_28_365 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
X_06391_ _05458_ _05520_ _05521_ VGND VGND VPWR VPWR _05522_ sky130_fd_sc_hd__and3_1
XFILLER_0_83_482 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_0_114_713 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
X_08061_ _01587_ _01595_ VGND VGND VPWR VPWR _01597_ sky130_fd_sc_hd__xnor2_2
XFILLER_0_70_165 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
X_07012_ _00448_ _00449_ _00317_ _00380_ VGND VGND VPWR VPWR _00452_ sky130_fd_sc_hd__a211o_1
XFILLER_0_59_95 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XTAP_TAPCELL_ROW_114_1690 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
X_08963_ _05659_ _02036_ _01499_ _05486_ VGND VGND VPWR VPWR _02581_ sky130_fd_sc_hd__a22o_1
X_07914_ _00983_ _01435_ _01436_ VGND VGND VPWR VPWR _01437_ sky130_fd_sc_hd__a21bo_1
X_08894_ _02501_ _02503_ _02504_ VGND VGND VPWR VPWR _02506_ sky130_fd_sc_hd__a21o_1
X_07845_ _01332_ _01360_ VGND VGND VPWR VPWR _01361_ sky130_fd_sc_hd__nor2_1
X_07776_ _00537_ _01114_ net51 net1 VGND VGND VPWR VPWR _01286_ sky130_fd_sc_hd__a22o_1
X_09515_ _03041_ _03183_ VGND VGND VPWR VPWR _03184_ sky130_fd_sc_hd__xor2_1
X_06727_ _00149_ _00153_ VGND VGND VPWR VPWR _00154_ sky130_fd_sc_hd__xnor2_2
X_09446_ _00409_ _02941_ _03106_ _03107_ VGND VGND VPWR VPWR _03108_ sky130_fd_sc_hd__a22o_1
XFILLER_0_66_438 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XTAP_TAPCELL_ROW_65_1077 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
X_06658_ net38 VGND VGND VPWR VPWR _00086_ sky130_fd_sc_hd__clkbuf_4
X_09377_ _03029_ _03031_ _03032_ VGND VGND VPWR VPWR _03033_ sky130_fd_sc_hd__a21bo_1
X_06589_ _05612_ _05614_ _00016_ _00017_ VGND VGND VPWR VPWR _00018_ sky130_fd_sc_hd__o211a_1
XFILLER_0_62_633 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_08328_ _01885_ _01886_ _01701_ _01703_ VGND VGND VPWR VPWR _01888_ sky130_fd_sc_hd__a211oi_2
XTAP_TAPCELL_ROW_117_1719 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
X_08259_ _01802_ _01811_ _01812_ VGND VGND VPWR VPWR _01813_ sky130_fd_sc_hd__nand3_2
XFILLER_0_46_195 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_62_699 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_61_176 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_120_716 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
X_11270_ _05046_ _05048_ _05044_ VGND VGND VPWR VPWR _05094_ sky130_fd_sc_hd__a21o_1
XFILLER_0_30_530 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
X_10221_ _02813_ _03952_ _03953_ VGND VGND VPWR VPWR _03955_ sky130_fd_sc_hd__a21bo_1
XFILLER_0_100_451 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
X_10152_ _01943_ _00894_ _02944_ _01762_ VGND VGND VPWR VPWR _03880_ sky130_fd_sc_hd__a22o_1
X_10083_ _03802_ _03803_ VGND VGND VPWR VPWR _03804_ sky130_fd_sc_hd__nand2_1
X_10985_ _04783_ _04784_ _04728_ _04700_ VGND VGND VPWR VPWR _04786_ sky130_fd_sc_hd__a211o_1
XFILLER_0_84_235 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XTAP_TAPCELL_ROW_13_422 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_108_562 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_0_108_551 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_0_52_110 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XTAP_TAPCELL_ROW_41_775 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_20_12 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_111_69 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
Xmax_cap139 _03648_ VGND VGND VPWR VPWR net139 sky130_fd_sc_hd__buf_1
X_11399_ _04040_ _05033_ VGND VGND VPWR VPWR _05232_ sky130_fd_sc_hd__nand2_1
X_10419_ _03827_ _00754_ VGND VGND VPWR VPWR _04170_ sky130_fd_sc_hd__nand2_1
XFILLER_0_96_27 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_29_54 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
X_05960_ _00581_ _01771_ _03124_ _00679_ VGND VGND VPWR VPWR _03135_ sky130_fd_sc_hd__a22o_1
XPHY_EDGE_ROW_119_Right_119 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
X_05891_ _01858_ _01880_ VGND VGND VPWR VPWR _02383_ sky130_fd_sc_hd__nand2_2
XTAP_TAPCELL_ROW_49_875 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
X_07630_ _01123_ _01124_ _01125_ VGND VGND VPWR VPWR _01126_ sky130_fd_sc_hd__nand3_4
X_07561_ _01049_ VGND VGND VPWR VPWR _01051_ sky130_fd_sc_hd__inv_2
XFILLER_0_88_585 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
X_09300_ _02940_ _02946_ _02948_ VGND VGND VPWR VPWR _02949_ sky130_fd_sc_hd__nand3_4
X_06512_ _05638_ _05639_ _05555_ _05558_ VGND VGND VPWR VPWR _05641_ sky130_fd_sc_hd__a211oi_1
XFILLER_0_0_22 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XFILLER_0_8_502 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_29_630 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
X_07492_ _02764_ _00294_ _00973_ _00975_ VGND VGND VPWR VPWR _00976_ sky130_fd_sc_hd__nand4_2
XFILLER_0_91_717 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
X_09231_ _04770_ _04781_ _02177_ _02529_ VGND VGND VPWR VPWR _02875_ sky130_fd_sc_hd__nand4_2
XFILLER_0_0_99 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
X_06443_ _05493_ _05512_ _05513_ VGND VGND VPWR VPWR _05573_ sky130_fd_sc_hd__nor3_2
XFILLER_0_44_600 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_09162_ _02796_ _02798_ VGND VGND VPWR VPWR _02799_ sky130_fd_sc_hd__xor2_2
XFILLER_0_8_557 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_16_313 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
X_06374_ _05501_ _05503_ _05500_ VGND VGND VPWR VPWR _05505_ sky130_fd_sc_hd__a21o_1
XFILLER_0_29_685 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_114_521 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
X_08113_ _01531_ _01532_ _01652_ _01653_ VGND VGND VPWR VPWR _01654_ sky130_fd_sc_hd__or4_1
XFILLER_0_28_195 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_44_655 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
X_09093_ _02720_ _02723_ VGND VGND VPWR VPWR _02724_ sky130_fd_sc_hd__xor2_4
XFILLER_0_16_379 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XFILLER_0_43_154 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_101_204 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_12_530 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
X_08044_ _01432_ _01438_ VGND VGND VPWR VPWR _01578_ sky130_fd_sc_hd__or2b_1
X_09995_ _00344_ _00346_ _02837_ _02667_ VGND VGND VPWR VPWR _03708_ sky130_fd_sc_hd__and4_1
XFILLER_0_86_82 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
X_08946_ _02560_ _02562_ VGND VGND VPWR VPWR _02563_ sky130_fd_sc_hd__xor2_2
X_08877_ _02450_ _02485_ _02486_ VGND VGND VPWR VPWR _02487_ sky130_fd_sc_hd__and3_1
X_07828_ _00362_ net19 _01340_ _01341_ VGND VGND VPWR VPWR _01342_ sky130_fd_sc_hd__o2bb2a_1
X_07759_ _01107_ _01110_ _01108_ VGND VGND VPWR VPWR _01267_ sky130_fd_sc_hd__o21ba_1
X_10770_ _04532_ _04533_ VGND VGND VPWR VPWR _04551_ sky130_fd_sc_hd__or2b_1
XFILLER_0_94_533 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_39_449 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_0_109_337 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
X_09429_ _05574_ _01856_ VGND VGND VPWR VPWR _03089_ sky130_fd_sc_hd__nand2_2
XFILLER_0_81_249 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_74_290 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XFILLER_0_35_655 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_105_543 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XTAP_TAPCELL_ROW_78_1235 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_34_165 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
X_11322_ _05103_ _05107_ VGND VGND VPWR VPWR _05151_ sky130_fd_sc_hd__nand2_1
X_11253_ _05032_ _05034_ _05031_ VGND VGND VPWR VPWR _05076_ sky130_fd_sc_hd__o21ai_1
XTAP_TAPCELL_ROW_91_1402 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
X_10204_ _03934_ _03933_ VGND VGND VPWR VPWR _03936_ sky130_fd_sc_hd__or2b_1
X_11184_ _04997_ _05001_ VGND VGND VPWR VPWR net114 sky130_fd_sc_hd__xnor2_4
X_10135_ _00546_ _03237_ _03238_ _00087_ VGND VGND VPWR VPWR _03861_ sky130_fd_sc_hd__a22oi_1
X_10066_ _03741_ _03742_ _03783_ _03784_ VGND VGND VPWR VPWR _03786_ sky130_fd_sc_hd__o22a_1
XFILLER_0_89_305 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_0_89_316 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XTAP_TAPCELL_ROW_89_1375 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_46_834 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
X_10968_ _04756_ _04765_ _04766_ VGND VGND VPWR VPWR _04767_ sky130_fd_sc_hd__and3_1
XFILLER_0_97_393 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XFILLER_0_85_522 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_57_235 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XTAP_TAPCELL_ROW_26_591 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_45_419 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
X_10899_ _04689_ _04690_ _04605_ _04608_ VGND VGND VPWR VPWR _04692_ sky130_fd_sc_hd__o211ai_1
XFILLER_0_72_238 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_72_205 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XFILLER_0_5_505 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_0_53_474 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_31_99 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_103_3 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_25_187 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_0_40_113 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
X_06090_ _04542_ VGND VGND VPWR VPWR _04552_ sky130_fd_sc_hd__clkbuf_8
XFILLER_0_111_546 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_111_535 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_40_168 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_0_21_371 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
X_08800_ _01192_ _02228_ _02250_ _02249_ VGND VGND VPWR VPWR _02403_ sky130_fd_sc_hd__a31o_1
XFILLER_0_21_393 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
X_09780_ _03240_ _03242_ VGND VGND VPWR VPWR _03473_ sky130_fd_sc_hd__or2_2
XPHY_EDGE_ROW_7_Right_7 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
X_06992_ net45 VGND VGND VPWR VPWR _00430_ sky130_fd_sc_hd__buf_2
X_05943_ _01913_ _02394_ _02928_ _02939_ VGND VGND VPWR VPWR _02950_ sky130_fd_sc_hd__and4bb_2
X_08731_ _04074_ _01109_ _01278_ _03015_ VGND VGND VPWR VPWR _02329_ sky130_fd_sc_hd__a22o_1
X_08662_ _02250_ _02252_ VGND VGND VPWR VPWR _02253_ sky130_fd_sc_hd__xor2_4
XFILLER_0_56_85 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_07613_ _02054_ _03201_ _00565_ _00695_ VGND VGND VPWR VPWR _01108_ sky130_fd_sc_hd__and4_1
X_05874_ net29 VGND VGND VPWR VPWR _02197_ sky130_fd_sc_hd__buf_4
XFILLER_0_76_511 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
X_08593_ _02177_ VGND VGND VPWR VPWR _02178_ sky130_fd_sc_hd__clkbuf_8
XFILLER_0_88_382 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_76_533 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
X_07544_ _00867_ _00890_ net132 _01024_ VGND VGND VPWR VPWR _01032_ sky130_fd_sc_hd__a211oi_1
XFILLER_0_119_646 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XTAP_TAPCELL_ROW_62_1036 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
X_07475_ _04542_ _05502_ _05593_ _04520_ VGND VGND VPWR VPWR _00957_ sky130_fd_sc_hd__a22o_1
XFILLER_0_36_419 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
X_09214_ _02846_ _02854_ _02855_ VGND VGND VPWR VPWR _02856_ sky130_fd_sc_hd__nand3_4
X_06426_ _00373_ _05467_ _05554_ _05555_ VGND VGND VPWR VPWR _05556_ sky130_fd_sc_hd__o2bb2a_1
XFILLER_0_91_569 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XFILLER_0_8_365 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_16_132 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_09145_ _02771_ _02778_ _02779_ VGND VGND VPWR VPWR _02780_ sky130_fd_sc_hd__nand3_2
X_06357_ _01771_ _02000_ _02219_ _03376_ VGND VGND VPWR VPWR _05488_ sky130_fd_sc_hd__nand4_1
XFILLER_0_114_362 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
X_09076_ net56 VGND VGND VPWR VPWR _02705_ sky130_fd_sc_hd__clkbuf_4
XPHY_EDGE_ROW_15_Left_137 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_0_31_113 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
X_06288_ _01050_ _05419_ VGND VGND VPWR VPWR _05420_ sky130_fd_sc_hd__nand2_1
XFILLER_0_102_524 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
X_08027_ _05689_ _00033_ _01557_ _01558_ VGND VGND VPWR VPWR _01559_ sky130_fd_sc_hd__a22oi_2
X_09978_ _05388_ _02178_ _03171_ _05320_ VGND VGND VPWR VPWR _03689_ sky130_fd_sc_hd__a22o_1
XTAP_TAPCELL_ROW_73_1176 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
X_08929_ _02356_ _02370_ _02543_ VGND VGND VPWR VPWR _02544_ sky130_fd_sc_hd__o21a_2
XPHY_EDGE_ROW_24_Left_146 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_0_98_135 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
X_10822_ _04605_ _04606_ _04599_ VGND VGND VPWR VPWR _04609_ sky130_fd_sc_hd__a21o_1
XFILLER_0_79_393 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XTAP_TAPCELL_ROW_43_804 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
X_10753_ _04532_ _04533_ VGND VGND VPWR VPWR _04534_ sky130_fd_sc_hd__xnor2_1
XFILLER_0_55_717 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_0_109_123 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_67_599 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XTAP_TAPCELL_ROW_23_550 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
X_10684_ _04370_ _04371_ VGND VGND VPWR VPWR _04458_ sky130_fd_sc_hd__nand2_1
XPHY_EDGE_ROW_33_Left_155 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_0_105_362 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_11305_ _04374_ _02227_ _05131_ VGND VGND VPWR VPWR _05132_ sky130_fd_sc_hd__a21o_1
XFILLER_0_50_466 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_0_22_135 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
X_11236_ _05002_ _05003_ _05056_ VGND VGND VPWR VPWR _05058_ sky130_fd_sc_hd__a21oi_1
XFILLER_0_30_190 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
X_11167_ _04895_ _04897_ _04982_ VGND VGND VPWR VPWR _04983_ sky130_fd_sc_hd__a21o_1
X_10118_ _03839_ _03840_ _03836_ VGND VGND VPWR VPWR _03842_ sky130_fd_sc_hd__a21o_1
XFILLER_0_93_39 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XPHY_EDGE_ROW_42_Left_164 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
X_11098_ _02840_ _02236_ VGND VGND VPWR VPWR _04908_ sky130_fd_sc_hd__and2_1
XFILLER_0_89_102 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_0_117_57 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
X_10049_ _03564_ _03566_ _03765_ _03766_ VGND VGND VPWR VPWR _03767_ sky130_fd_sc_hd__a211o_2
XFILLER_0_58_500 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_85_374 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_18_419 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_42_54 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_73_547 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XPHY_EDGE_ROW_51_Left_173 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
X_07260_ _00606_ _00720_ _00721_ VGND VGND VPWR VPWR _00722_ sky130_fd_sc_hd__nor3_2
XFILLER_0_5_313 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_0_116_649 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_60_219 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
X_07191_ _00643_ _00644_ _00608_ _00542_ VGND VGND VPWR VPWR _00647_ sky130_fd_sc_hd__a211oi_2
XFILLER_0_26_463 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
X_06211_ _03310_ _03321_ _05341_ _05343_ VGND VGND VPWR VPWR _05344_ sky130_fd_sc_hd__nand4_2
XFILLER_0_14_625 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
X_06142_ _05084_ _05095_ _04965_ VGND VGND VPWR VPWR _05116_ sky130_fd_sc_hd__a21o_1
X_06073_ _02928_ _04357_ VGND VGND VPWR VPWR _04368_ sky130_fd_sc_hd__and2b_1
XFILLER_0_41_444 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_0_111_343 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_111_332 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
X_09901_ _03505_ _03508_ VGND VGND VPWR VPWR _03606_ sky130_fd_sc_hd__or2_1
XFILLER_0_6_65 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_1_585 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
X_09832_ _03527_ _03530_ VGND VGND VPWR VPWR net97 sky130_fd_sc_hd__xnor2_1
XPHY_EDGE_ROW_60_Left_182 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
X_09763_ _03438_ _03453_ _03454_ VGND VGND VPWR VPWR _03455_ sky130_fd_sc_hd__nand3_2
X_08714_ _02307_ _02308_ _02309_ VGND VGND VPWR VPWR _02310_ sky130_fd_sc_hd__nand3_1
X_06975_ _05693_ VGND VGND VPWR VPWR _00411_ sky130_fd_sc_hd__clkbuf_4
X_09694_ _03079_ _03224_ _03379_ VGND VGND VPWR VPWR _03380_ sky130_fd_sc_hd__a21oi_4
X_05926_ net31 VGND VGND VPWR VPWR _02764_ sky130_fd_sc_hd__buf_4
XFILLER_0_95_105 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
X_08645_ _02086_ _02126_ _02125_ VGND VGND VPWR VPWR _02234_ sky130_fd_sc_hd__a21bo_2
X_05857_ _00646_ _01508_ _02000_ _00624_ VGND VGND VPWR VPWR _02011_ sky130_fd_sc_hd__a22oi_1
XFILLER_0_95_138 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XTAP_TAPCELL_ROW_1_278 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
X_08576_ _01969_ _01970_ VGND VGND VPWR VPWR _02159_ sky130_fd_sc_hd__nand2_1
X_05788_ _00635_ _00657_ _00472_ _01247_ VGND VGND VPWR VPWR _01258_ sky130_fd_sc_hd__and4_1
X_07527_ _00947_ _00948_ _01012_ _01013_ VGND VGND VPWR VPWR _01014_ sky130_fd_sc_hd__or4_2
XTAP_TAPCELL_ROW_120_1759 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_9_641 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_107_605 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_9_685 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
X_07458_ _00935_ _00936_ _00928_ VGND VGND VPWR VPWR _00938_ sky130_fd_sc_hd__a21o_1
XFILLER_0_106_137 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
X_06409_ net7 VGND VGND VPWR VPWR _05539_ sky130_fd_sc_hd__buf_4
XFILLER_0_8_195 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
X_07389_ _00860_ _00861_ _00716_ _00718_ VGND VGND VPWR VPWR _00863_ sky130_fd_sc_hd__o211ai_4
X_09128_ _02759_ _02760_ VGND VGND VPWR VPWR _02761_ sky130_fd_sc_hd__xnor2_1
XFILLER_0_72_580 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_44_282 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_115_671 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XTAP_TAPCELL_ROW_75_1205 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
X_09059_ _02683_ _02684_ _02663_ VGND VGND VPWR VPWR _02686_ sky130_fd_sc_hd__a21o_1
XFILLER_0_32_477 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_0_102_365 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
X_11021_ _04822_ _04823_ VGND VGND VPWR VPWR _04825_ sky130_fd_sc_hd__xnor2_2
XTAP_TAPCELL_ROW_9_378 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_87_617 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XTAP_TAPCELL_ROW_86_1334 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_86_127 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XTAP_TAPCELL_ROW_56_962 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
X_10805_ _04588_ _04589_ VGND VGND VPWR VPWR _04590_ sky130_fd_sc_hd__xnor2_1
XFILLER_0_103_15 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_94_171 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_0_55_525 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
X_10736_ _04512_ _04513_ _04421_ _04423_ VGND VGND VPWR VPWR _04515_ sky130_fd_sc_hd__o211ai_2
XFILLER_0_12_13 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
X_10667_ _04293_ _04363_ _04438_ _04439_ VGND VGND VPWR VPWR _04440_ sky130_fd_sc_hd__a211o_1
X_10598_ _04263_ _04262_ VGND VGND VPWR VPWR _04365_ sky130_fd_sc_hd__or2b_1
XFILLER_0_106_682 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XTAP_TAPCELL_ROW_97_1474 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_2_327 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XFILLER_0_2_338 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_23_466 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
Xoutput119 net119 VGND VGND VPWR VPWR product[59] sky130_fd_sc_hd__buf_2
XFILLER_0_11_617 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
Xoutput108 net108 VGND VGND VPWR VPWR product[49] sky130_fd_sc_hd__clkbuf_4
X_11219_ _03294_ _02228_ VGND VGND VPWR VPWR _05039_ sky130_fd_sc_hd__nand2_1
Xoutput90 net90 VGND VGND VPWR VPWR product[32] sky130_fd_sc_hd__clkbuf_4
XFILLER_0_37_21 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_37_43 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_37_65 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
X_06760_ _05423_ VGND VGND VPWR VPWR _00187_ sky130_fd_sc_hd__clkbuf_4
X_05711_ _00319_ _00340_ _00384_ _00406_ VGND VGND VPWR VPWR _00417_ sky130_fd_sc_hd__and4_1
X_06691_ _00117_ _00118_ _05646_ VGND VGND VPWR VPWR _00119_ sky130_fd_sc_hd__or3b_1
X_08430_ _01995_ _01996_ _01997_ VGND VGND VPWR VPWR _01999_ sky130_fd_sc_hd__a21o_1
XTAP_TAPCELL_ROW_106_1581 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_106_1592 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_85_160 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_73_311 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
X_08361_ _01921_ _01922_ _01918_ VGND VGND VPWR VPWR _01925_ sky130_fd_sc_hd__a21o_1
XFILLER_0_18_216 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_0_46_525 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_0_116_402 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
X_08292_ net24 VGND VGND VPWR VPWR _01849_ sky130_fd_sc_hd__buf_4
XFILLER_0_18_249 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
X_07312_ _00775_ _00776_ _00772_ VGND VGND VPWR VPWR _00779_ sky130_fd_sc_hd__a21o_1
XTAP_TAPCELL_ROW_34_689 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_46_558 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_0_6_622 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
X_07243_ _00693_ _00702_ _00703_ VGND VGND VPWR VPWR _00704_ sky130_fd_sc_hd__nand3_1
XFILLER_0_73_399 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_07174_ _00626_ _00627_ VGND VGND VPWR VPWR _00628_ sky130_fd_sc_hd__xor2_2
XFILLER_0_6_699 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_14_433 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_0_75_3 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XFILLER_0_14_477 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
X_06125_ _00319_ _00340_ _03736_ _04922_ VGND VGND VPWR VPWR _04933_ sky130_fd_sc_hd__and4_1
XFILLER_0_41_285 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_111_162 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_0_78_61 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_1_371 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
X_06056_ _03048_ _04161_ _04172_ VGND VGND VPWR VPWR _04183_ sky130_fd_sc_hd__and3_1
X_09815_ _03466_ _03467_ _03510_ _03511_ VGND VGND VPWR VPWR _03512_ sky130_fd_sc_hd__a211oi_4
XTAP_TAPCELL_ROW_70_1135 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_6_337 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_94_82 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
X_09746_ _03432_ _03434_ _03427_ _03428_ VGND VGND VPWR VPWR _03436_ sky130_fd_sc_hd__a211o_1
X_06958_ _05416_ VGND VGND VPWR VPWR _00392_ sky130_fd_sc_hd__clkbuf_4
XFILLER_0_96_403 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
X_09677_ _03358_ _03359_ _03318_ _03319_ VGND VGND VPWR VPWR _03361_ sky130_fd_sc_hd__a211o_1
X_05909_ _00668_ _01039_ _02557_ _02568_ VGND VGND VPWR VPWR _02578_ sky130_fd_sc_hd__o2bb2a_1
XFILLER_0_69_639 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_08628_ _02030_ _02214_ _02215_ VGND VGND VPWR VPWR _02216_ sky130_fd_sc_hd__nand3_2
X_06889_ _00207_ _00282_ _00315_ _00316_ VGND VGND VPWR VPWR _00317_ sky130_fd_sc_hd__a211oi_4
XFILLER_0_96_469 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XTAP_TAPCELL_ROW_53_921 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_49_352 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
X_08559_ _02135_ _02139_ VGND VGND VPWR VPWR _02140_ sky130_fd_sc_hd__xor2_2
XFILLER_0_37_503 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_92_653 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XTAP_TAPCELL_ROW_81_1275 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_76_193 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_0_64_322 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_37_558 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
X_10521_ _00356_ _03440_ _04278_ _04279_ VGND VGND VPWR VPWR _04282_ sky130_fd_sc_hd__nand4_1
XFILLER_0_25_709 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_92_697 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_0_24_219 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
X_10452_ _04103_ _04113_ _04114_ VGND VGND VPWR VPWR _04207_ sky130_fd_sc_hd__nand3_1
X_10383_ _04128_ _04130_ _04039_ _04022_ VGND VGND VPWR VPWR _04132_ sky130_fd_sc_hd__o211ai_4
XFILLER_0_20_414 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_0_103_685 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_102_162 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
X_11004_ _04804_ _03178_ _00754_ _04801_ VGND VGND VPWR VPWR _04806_ sky130_fd_sc_hd__and4b_1
XFILLER_0_59_105 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_0_87_469 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_83_631 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_83_620 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XFILLER_0_67_193 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_55_322 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_0_55_311 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_0_23_78 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_28_558 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
X_10719_ _02645_ _02227_ VGND VGND VPWR VPWR _04496_ sky130_fd_sc_hd__nand2_1
XTAP_TAPCELL_ROW_99_1503 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_82_141 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XTAP_TAPCELL_ROW_31_648 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_83_697 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_15_219 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_0_113_449 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_51_561 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_11_414 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XTAP_TAPCELL_ROW_11_394 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_23_274 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
X_07930_ _01283_ _01286_ _01285_ VGND VGND VPWR VPWR _01454_ sky130_fd_sc_hd__a21bo_1
X_07861_ _00485_ VGND VGND VPWR VPWR _01379_ sky130_fd_sc_hd__clkbuf_4
X_09600_ _03273_ _03274_ _03254_ VGND VGND VPWR VPWR _03276_ sky130_fd_sc_hd__o21a_1
X_06812_ _01192_ _00152_ _00237_ _01171_ VGND VGND VPWR VPWR _00238_ sky130_fd_sc_hd__a22o_2
X_07792_ _01264_ _01265_ _01300_ _01301_ VGND VGND VPWR VPWR _01304_ sky130_fd_sc_hd__o22ai_4
XFILLER_0_3_55 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XTAP_TAPCELL_ROW_108_1610 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
X_09531_ _03185_ _03199_ _03200_ VGND VGND VPWR VPWR _03202_ sky130_fd_sc_hd__and3_1
X_06743_ _00166_ _00169_ VGND VGND VPWR VPWR _00170_ sky130_fd_sc_hd__xnor2_2
XTAP_TAPCELL_ROW_39_748 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_64_85 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_09462_ _03084_ _03085_ _03123_ _03125_ VGND VGND VPWR VPWR _03126_ sky130_fd_sc_hd__a211oi_1
X_06674_ _00092_ _00100_ _00101_ VGND VGND VPWR VPWR _00102_ sky130_fd_sc_hd__nand3_2
X_09393_ _03002_ _03003_ _03047_ _03049_ VGND VGND VPWR VPWR _03051_ sky130_fd_sc_hd__a22o_1
XTAP_TAPCELL_ROW_19_494 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
X_08413_ _00308_ _02065_ _01284_ VGND VGND VPWR VPWR _01981_ sky130_fd_sc_hd__and3_1
X_08344_ _03834_ net13 VGND VGND VPWR VPWR _01906_ sky130_fd_sc_hd__and2_1
XFILLER_0_116_221 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XFILLER_0_46_344 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
X_08275_ _01828_ _01829_ _01647_ _01714_ VGND VGND VPWR VPWR _01831_ sky130_fd_sc_hd__o211a_1
XFILLER_0_27_591 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XTAP_TAPCELL_ROW_119_1750 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_116_287 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
X_07226_ _00675_ _00684_ VGND VGND VPWR VPWR _00685_ sky130_fd_sc_hd__xor2_2
XFILLER_0_104_449 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
X_07157_ net14 VGND VGND VPWR VPWR _00609_ sky130_fd_sc_hd__clkbuf_4
XFILLER_0_30_701 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_100_611 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_06108_ _04737_ VGND VGND VPWR VPWR _04748_ sky130_fd_sc_hd__buf_4
X_07088_ _00533_ _05310_ VGND VGND VPWR VPWR _00534_ sky130_fd_sc_hd__nand2_1
XFILLER_0_100_666 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
X_06039_ _03965_ _03976_ _03725_ VGND VGND VPWR VPWR _03998_ sky130_fd_sc_hd__o21ai_1
X_09729_ _03415_ _03416_ _03312_ VGND VGND VPWR VPWR _03417_ sky130_fd_sc_hd__a21o_1
XTAP_TAPCELL_ROW_83_1304 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_69_447 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_92_461 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_0_64_141 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_25_517 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_0_37_366 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_80_645 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_0_65_697 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_64_185 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XPHY_EDGE_ROW_7_Left_129 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_0_25_528 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
X_10504_ _04155_ _04158_ VGND VGND VPWR VPWR _04263_ sky130_fd_sc_hd__and2_1
XFILLER_0_80_667 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_40_509 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
X_10435_ net144 _04187_ VGND VGND VPWR VPWR _04188_ sky130_fd_sc_hd__xnor2_1
XFILLER_0_100_27 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_33_561 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XTAP_TAPCELL_ROW_94_1433 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
X_10366_ _04104_ _04111_ _04112_ VGND VGND VPWR VPWR _04113_ sky130_fd_sc_hd__nand3_4
XFILLER_0_0_639 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
X_10297_ _04035_ _04037_ VGND VGND VPWR VPWR net102 sky130_fd_sc_hd__xor2_4
XFILLER_0_20_277 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_109_69 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_88_701 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XTAP_TAPCELL_ROW_36_707 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_36_718 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_75_417 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XTAP_TAPCELL_ROW_103_1551 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_87_299 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_75_439 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XTAP_TAPCELL_ROW_16_464 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_50_21 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
X_06390_ _05518_ _05519_ _05439_ net151 VGND VGND VPWR VPWR _05521_ sky130_fd_sc_hd__a211o_1
XFILLER_0_56_697 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_0_55_196 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
X_08060_ _01593_ _01594_ VGND VGND VPWR VPWR _01595_ sky130_fd_sc_hd__xor2_2
XFILLER_0_113_246 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XFILLER_0_12_701 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
X_07011_ _00317_ net148 _00448_ _00449_ VGND VGND VPWR VPWR _00451_ sky130_fd_sc_hd__o211ai_4
XFILLER_0_51_391 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XTAP_TAPCELL_ROW_114_1691 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
X_08962_ _05486_ _05659_ _01499_ VGND VGND VPWR VPWR _02580_ sky130_fd_sc_hd__and3_1
X_08893_ _02501_ _02503_ _02504_ VGND VGND VPWR VPWR _02505_ sky130_fd_sc_hd__nand3_1
X_07913_ _02208_ net45 net46 _02699_ VGND VGND VPWR VPWR _01436_ sky130_fd_sc_hd__a22o_1
X_07844_ _01333_ _01359_ VGND VGND VPWR VPWR _01360_ sky130_fd_sc_hd__xnor2_1
XFILLER_0_38_3 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_78_211 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
X_07775_ _02447_ _00843_ _01114_ _01284_ VGND VGND VPWR VPWR _01285_ sky130_fd_sc_hd__nand4_1
X_09514_ _03181_ _03182_ VGND VGND VPWR VPWR _03183_ sky130_fd_sc_hd__or2_1
X_06726_ _01181_ _00152_ VGND VGND VPWR VPWR _00153_ sky130_fd_sc_hd__nand2_1
X_09445_ _00084_ _01414_ _02943_ _02944_ VGND VGND VPWR VPWR _03107_ sky130_fd_sc_hd__nand4_4
X_06657_ _01050_ _00084_ VGND VGND VPWR VPWR _00085_ sky130_fd_sc_hd__nand2_1
XFILLER_0_93_225 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XTAP_TAPCELL_ROW_65_1078 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_74_450 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
X_09376_ _05410_ _02692_ VGND VGND VPWR VPWR _03032_ sky130_fd_sc_hd__nand2_1
XFILLER_0_19_366 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
X_06588_ _00014_ _00015_ _05648_ VGND VGND VPWR VPWR _00017_ sky130_fd_sc_hd__o21ai_1
XFILLER_0_47_697 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
X_08327_ _01701_ _01703_ _01885_ _01886_ VGND VGND VPWR VPWR _01887_ sky130_fd_sc_hd__o211a_1
X_08258_ _01808_ _01809_ _01810_ VGND VGND VPWR VPWR _01812_ sky130_fd_sc_hd__a21o_1
XFILLER_0_15_561 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
X_07209_ _05589_ _04585_ _00531_ _00530_ VGND VGND VPWR VPWR _00666_ sky130_fd_sc_hd__a31o_1
X_10220_ _00609_ _02812_ _00748_ _01605_ VGND VGND VPWR VPWR _03953_ sky130_fd_sc_hd__a22o_1
X_08189_ _05502_ _00035_ _05635_ _05425_ VGND VGND VPWR VPWR _01736_ sky130_fd_sc_hd__a22o_1
XFILLER_0_112_290 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
X_10151_ _02325_ _00753_ _03704_ _03702_ _00496_ VGND VGND VPWR VPWR _03879_ sky130_fd_sc_hd__a32o_1
XFILLER_0_100_474 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XFILLER_0_100_463 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
X_10082_ _05464_ _05553_ _03030_ _02705_ VGND VGND VPWR VPWR _03803_ sky130_fd_sc_hd__nand4_1
X_10984_ _04728_ _04700_ _04783_ _04784_ VGND VGND VPWR VPWR _04785_ sky130_fd_sc_hd__o211ai_4
XFILLER_0_97_564 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_29_108 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XTAP_TAPCELL_ROW_13_423 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_5_709 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_37_152 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_38_686 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XTAP_TAPCELL_ROW_41_776 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_53_656 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_4_219 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_0_20_24 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_0_80_475 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_111_717 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_0_0_403 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XFILLER_0_40_339 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
X_11398_ _05022_ _04873_ _05230_ VGND VGND VPWR VPWR _05231_ sky130_fd_sc_hd__and3_1
X_10418_ _03294_ _04167_ _04168_ VGND VGND VPWR VPWR _04169_ sky130_fd_sc_hd__a21bo_1
X_10349_ _04092_ _04093_ VGND VGND VPWR VPWR _04094_ sky130_fd_sc_hd__xnor2_2
XFILLER_0_29_88 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
X_05890_ _01793_ _02361_ VGND VGND VPWR VPWR _02372_ sky130_fd_sc_hd__xnor2_4
XFILLER_0_88_520 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XTAP_TAPCELL_ROW_49_876 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_45_43 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_88_553 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_88_531 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
X_07560_ _01037_ _01038_ _01048_ VGND VGND VPWR VPWR _01049_ sky130_fd_sc_hd__nand3_2
XFILLER_0_45_98 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_75_203 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
X_06511_ _05555_ _05558_ _05638_ _05639_ VGND VGND VPWR VPWR _05640_ sky130_fd_sc_hd__o211a_2
XFILLER_0_48_406 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_88_597 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_75_225 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_09230_ _04781_ _02177_ _02529_ _04770_ VGND VGND VPWR VPWR _02873_ sky130_fd_sc_hd__a22o_1
X_07491_ _02208_ net41 net42 _02699_ VGND VGND VPWR VPWR _00975_ sky130_fd_sc_hd__a22o_1
XFILLER_0_8_525 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_28_141 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_06442_ _05569_ _05570_ _05476_ _05547_ VGND VGND VPWR VPWR _05572_ sky130_fd_sc_hd__o211ai_4
XFILLER_0_29_653 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_0_29_664 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_90_239 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
X_09161_ _01249_ _01903_ VGND VGND VPWR VPWR _02798_ sky130_fd_sc_hd__nand2_1
XFILLER_0_56_483 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_0_8_569 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
X_06373_ _05500_ _05501_ _05503_ VGND VGND VPWR VPWR _05504_ sky130_fd_sc_hd__nand3_1
XFILLER_0_28_163 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_29_697 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
X_09092_ _02489_ _02550_ _02722_ VGND VGND VPWR VPWR _02723_ sky130_fd_sc_hd__a21oi_4
X_08112_ _01649_ _01650_ _01469_ _01533_ VGND VGND VPWR VPWR _01653_ sky130_fd_sc_hd__o211a_1
XFILLER_0_16_358 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_0_114_533 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_71_475 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
X_08043_ _01416_ _01424_ VGND VGND VPWR VPWR _01577_ sky130_fd_sc_hd__and2_2
XFILLER_0_43_177 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
X_09994_ _03705_ _03706_ VGND VGND VPWR VPWR _03707_ sky130_fd_sc_hd__xor2_2
X_08945_ _02232_ _02385_ _02561_ VGND VGND VPWR VPWR _02562_ sky130_fd_sc_hd__a21oi_4
X_08876_ _02483_ _02484_ _02338_ _02341_ VGND VGND VPWR VPWR _02486_ sky130_fd_sc_hd__a211o_1
X_07827_ _00581_ net55 net17 net18 VGND VGND VPWR VPWR _01341_ sky130_fd_sc_hd__and4_1
X_07758_ _01100_ _01101_ VGND VGND VPWR VPWR _01266_ sky130_fd_sc_hd__or2_2
X_06709_ _00036_ _00040_ VGND VGND VPWR VPWR _00136_ sky130_fd_sc_hd__or2_1
XFILLER_0_109_305 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_94_545 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_79_597 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
X_07689_ _01183_ _01188_ _01189_ VGND VGND VPWR VPWR _01190_ sky130_fd_sc_hd__nor3_1
X_09428_ _01850_ _03086_ _03087_ VGND VGND VPWR VPWR _03088_ sky130_fd_sc_hd__a21bo_1
XFILLER_0_94_589 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_0_81_206 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_35_623 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
X_09359_ _04542_ _01284_ _01449_ _03015_ VGND VGND VPWR VPWR _03013_ sky130_fd_sc_hd__a22o_1
XFILLER_0_47_461 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XFILLER_0_105_511 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_35_667 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_0_117_393 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
X_11321_ _05147_ _05148_ VGND VGND VPWR VPWR _05150_ sky130_fd_sc_hd__and2b_2
XTAP_TAPCELL_ROW_78_1236 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_62_464 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XPHY_EDGE_ROW_97_Left_219 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
X_11252_ _05072_ _05074_ VGND VGND VPWR VPWR _05075_ sky130_fd_sc_hd__xnor2_1
XTAP_TAPCELL_ROW_91_1403 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
X_11183_ _04871_ _04999_ _05000_ VGND VGND VPWR VPWR _05001_ sky130_fd_sc_hd__o21a_2
X_10203_ _03933_ _03934_ VGND VGND VPWR VPWR _03935_ sky130_fd_sc_hd__or2b_1
X_10134_ _03776_ _03778_ VGND VGND VPWR VPWR _03860_ sky130_fd_sc_hd__or2b_1
X_10065_ _03741_ _03742_ _03783_ _03784_ VGND VGND VPWR VPWR _03785_ sky130_fd_sc_hd__nor4_1
XFILLER_0_89_328 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_106_15 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XTAP_TAPCELL_ROW_89_1376 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_97_361 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_0_85_501 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_0_15_57 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XTAP_TAPCELL_ROW_46_835 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
X_10967_ _04763_ _04764_ _04757_ VGND VGND VPWR VPWR _04766_ sky130_fd_sc_hd__a21o_1
XFILLER_0_85_534 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_57_214 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
X_10898_ _04605_ _04608_ _04689_ _04690_ VGND VGND VPWR VPWR _04691_ sky130_fd_sc_hd__a211o_1
XTAP_TAPCELL_ROW_100_1510 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_26_581 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_26_592 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_25_111 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_26_645 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_53_486 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_41_648 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_40_147 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_0_111_569 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XFILLER_0_111_558 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XTAP_TAPCELL_ROW_111_1650 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
X_06991_ _01978_ _00197_ VGND VGND VPWR VPWR _00429_ sky130_fd_sc_hd__and2_1
X_08730_ _02324_ _02326_ VGND VGND VPWR VPWR _02327_ sky130_fd_sc_hd__xor2_2
X_05942_ _01880_ _02372_ _02907_ _02917_ VGND VGND VPWR VPWR _02939_ sky130_fd_sc_hd__a2bb2o_1
XFILLER_0_56_64 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
X_08661_ _01192_ _02052_ VGND VGND VPWR VPWR _02252_ sky130_fd_sc_hd__nand2_2
X_05873_ _00373_ _01050_ _01629_ _01618_ _00319_ VGND VGND VPWR VPWR _02186_ sky130_fd_sc_hd__a32o_1
X_07612_ _01039_ _00830_ VGND VGND VPWR VPWR _01107_ sky130_fd_sc_hd__nand2_1
XFILLER_0_76_501 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
X_08592_ net53 VGND VGND VPWR VPWR _02177_ sky130_fd_sc_hd__clkbuf_4
XFILLER_0_76_545 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_72_85 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
X_07543_ _00888_ _01028_ _01030_ VGND VGND VPWR VPWR _01031_ sky130_fd_sc_hd__o21ai_1
XFILLER_0_48_214 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XTAP_TAPCELL_ROW_62_1037 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
X_07474_ _05304_ _04074_ _00086_ _00189_ VGND VGND VPWR VPWR _00956_ sky130_fd_sc_hd__nand4_1
XFILLER_0_119_658 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
X_09213_ _02849_ _02851_ _02853_ VGND VGND VPWR VPWR _02855_ sky130_fd_sc_hd__a21o_1
X_06425_ _00668_ _00450_ _05319_ _05387_ VGND VGND VPWR VPWR _05555_ sky130_fd_sc_hd__and4_1
XFILLER_0_91_559 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
X_09144_ _02776_ _02777_ _02772_ VGND VGND VPWR VPWR _02779_ sky130_fd_sc_hd__a21o_1
X_06356_ _02000_ _03649_ _02458_ _02721_ VGND VGND VPWR VPWR _05487_ sky130_fd_sc_hd__a22o_1
X_09075_ _00340_ _01987_ _02185_ _00974_ VGND VGND VPWR VPWR _02704_ sky130_fd_sc_hd__a22o_1
XFILLER_0_32_626 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XFILLER_0_32_648 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
X_06287_ _03332_ VGND VGND VPWR VPWR _05419_ sky130_fd_sc_hd__buf_4
XFILLER_0_31_158 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
X_08026_ _05345_ _05425_ _00035_ _05635_ VGND VGND VPWR VPWR _01558_ sky130_fd_sc_hd__nand4_1
X_09977_ _03686_ _03687_ VGND VGND VPWR VPWR _03688_ sky130_fd_sc_hd__and2b_1
XTAP_TAPCELL_ROW_73_1177 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
X_08928_ _02368_ _02369_ VGND VGND VPWR VPWR _02543_ sky130_fd_sc_hd__or2b_1
XFILLER_0_99_615 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
X_08859_ _02455_ _02466_ VGND VGND VPWR VPWR _02467_ sky130_fd_sc_hd__xor2_2
XFILLER_0_86_309 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_10821_ _04599_ _04605_ _04606_ VGND VGND VPWR VPWR _04608_ sky130_fd_sc_hd__nand3_2
XFILLER_0_39_225 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XTAP_TAPCELL_ROW_43_805 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
X_10752_ _04440_ _04442_ VGND VGND VPWR VPWR _04533_ sky130_fd_sc_hd__nand2_1
XFILLER_0_109_113 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_0_67_567 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_0_109_135 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
X_10683_ _04365_ _04372_ VGND VGND VPWR VPWR _04457_ sky130_fd_sc_hd__and2b_1
XFILLER_0_82_559 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_82_548 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XTAP_TAPCELL_ROW_23_551 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_35_431 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_23_615 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_90_581 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_0_23_648 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
X_11304_ _05129_ _05130_ VGND VGND VPWR VPWR _05131_ sky130_fd_sc_hd__xor2_1
XFILLER_0_50_445 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
X_11235_ _05002_ _05003_ _05056_ VGND VGND VPWR VPWR _05057_ sky130_fd_sc_hd__and3_1
X_11166_ _04898_ _04917_ VGND VGND VPWR VPWR _04982_ sky130_fd_sc_hd__nor2_1
X_10117_ _03836_ _03839_ _03840_ VGND VGND VPWR VPWR _03841_ sky130_fd_sc_hd__nand3_1
X_11097_ _04905_ _04906_ VGND VGND VPWR VPWR _04907_ sky130_fd_sc_hd__xnor2_1
X_10048_ _02302_ _02064_ _03763_ _03764_ VGND VGND VPWR VPWR _03766_ sky130_fd_sc_hd__and4_1
XFILLER_0_117_69 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_98_670 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_89_169 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_85_320 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_42_33 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_58_589 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_42_66 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XFILLER_0_45_217 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_45_228 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_115_105 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_0_26_431 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
X_06210_ _05342_ VGND VGND VPWR VPWR _05343_ sky130_fd_sc_hd__clkbuf_4
XFILLER_0_91_9 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
X_07190_ _00608_ _00542_ _00643_ _00644_ VGND VGND VPWR VPWR _00645_ sky130_fd_sc_hd__o211a_1
XFILLER_0_53_294 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
X_06141_ _04965_ _05084_ _05095_ VGND VGND VPWR VPWR _05106_ sky130_fd_sc_hd__nand3_1
X_06072_ _04292_ _04347_ VGND VGND VPWR VPWR _04357_ sky130_fd_sc_hd__xor2_2
XFILLER_0_14_659 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
X_09900_ _03601_ _03602_ _03418_ _03535_ VGND VGND VPWR VPWR _03604_ sky130_fd_sc_hd__o211a_1
XFILLER_0_13_169 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_0_22_681 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_111_355 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_0_111_399 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
X_09831_ _03381_ _03384_ _03528_ VGND VGND VPWR VPWR _03530_ sky130_fd_sc_hd__o21bai_1
XFILLER_0_6_77 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_0_1_597 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
X_09762_ _03449_ _03450_ _03451_ VGND VGND VPWR VPWR _03454_ sky130_fd_sc_hd__a21o_1
X_06974_ _03572_ _00409_ _00288_ _00287_ VGND VGND VPWR VPWR _00410_ sky130_fd_sc_hd__a31o_1
X_08713_ _02103_ _02116_ _02115_ VGND VGND VPWR VPWR _02309_ sky130_fd_sc_hd__a21bo_1
X_05925_ _02710_ _02742_ VGND VGND VPWR VPWR _02753_ sky130_fd_sc_hd__or2_1
X_09693_ _03220_ _03222_ VGND VGND VPWR VPWR _03379_ sky130_fd_sc_hd__nor2_1
X_08644_ _02077_ _02079_ VGND VGND VPWR VPWR _02233_ sky130_fd_sc_hd__or2_2
X_05856_ net62 VGND VGND VPWR VPWR _02000_ sky130_fd_sc_hd__clkbuf_4
XFILLER_0_95_117 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_89_670 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
X_05787_ _01236_ VGND VGND VPWR VPWR _01247_ sky130_fd_sc_hd__clkbuf_4
XTAP_TAPCELL_ROW_1_279 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
X_08575_ _01995_ _01996_ _01997_ VGND VGND VPWR VPWR _02158_ sky130_fd_sc_hd__and3_1
X_07526_ _01010_ _01011_ _00853_ _00856_ VGND VGND VPWR VPWR _01013_ sky130_fd_sc_hd__o211a_1
XFILLER_0_37_707 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_91_301 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_64_504 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_9_653 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_36_217 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XFILLER_0_107_617 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_8_141 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
X_07457_ _00928_ _00935_ _00936_ VGND VGND VPWR VPWR _00937_ sky130_fd_sc_hd__nand3_1
XFILLER_0_91_378 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_9_697 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_8_174 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
X_07388_ _00716_ _00718_ _00860_ _00861_ VGND VGND VPWR VPWR _00862_ sky130_fd_sc_hd__a211o_2
XFILLER_0_17_442 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XTAP_TAPCELL_ROW_20_510 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
X_06408_ _05480_ _05482_ VGND VGND VPWR VPWR _05538_ sky130_fd_sc_hd__or2_1
X_09127_ _04716_ _02041_ _02581_ _02580_ _01354_ VGND VGND VPWR VPWR _02760_ sky130_fd_sc_hd__a32o_1
X_06339_ _05466_ _05469_ VGND VGND VPWR VPWR _05470_ sky130_fd_sc_hd__xor2_2
XFILLER_0_121_119 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
X_09058_ _02663_ _02683_ _02684_ VGND VGND VPWR VPWR _02685_ sky130_fd_sc_hd__nand3_1
XFILLER_0_44_294 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
X_08009_ _03791_ net16 _01537_ _01538_ VGND VGND VPWR VPWR _01539_ sky130_fd_sc_hd__nand4_1
XFILLER_0_102_377 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
X_11020_ _04763_ _04765_ VGND VGND VPWR VPWR _04823_ sky130_fd_sc_hd__nand2_1
XTAP_TAPCELL_ROW_9_379 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_99_456 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XTAP_TAPCELL_ROW_86_1335 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_28_610 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_86_139 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_86_106 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XTAP_TAPCELL_ROW_56_963 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
X_10804_ _03433_ _02236_ VGND VGND VPWR VPWR _04589_ sky130_fd_sc_hd__nand2_1
XFILLER_0_67_320 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_0_95_673 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_27_217 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
X_10735_ _04421_ _04423_ _04512_ _04513_ VGND VGND VPWR VPWR _04514_ sky130_fd_sc_hd__a211o_1
XFILLER_0_103_27 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_12_25 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
X_10666_ _04436_ _04437_ _04397_ VGND VGND VPWR VPWR _04439_ sky130_fd_sc_hd__a21oi_2
XFILLER_0_70_529 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_0_35_261 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
X_10597_ _04268_ _04286_ VGND VGND VPWR VPWR _04364_ sky130_fd_sc_hd__and2b_1
XFILLER_0_106_694 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XTAP_TAPCELL_ROW_97_1475 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_88_29 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_0_50_231 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
Xoutput109 net109 VGND VGND VPWR VPWR product[4] sky130_fd_sc_hd__clkbuf_4
XFILLER_0_50_253 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_11_629 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_10_117 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_23_478 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_10_139 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
X_11218_ _05036_ _05037_ VGND VGND VPWR VPWR _05038_ sky130_fd_sc_hd__nor2_1
X_11149_ _01355_ _04961_ _04962_ VGND VGND VPWR VPWR _04963_ sky130_fd_sc_hd__a21bo_1
Xoutput91 net91 VGND VGND VPWR VPWR product[33] sky130_fd_sc_hd__clkbuf_4
Xoutput80 net80 VGND VGND VPWR VPWR product[23] sky130_fd_sc_hd__clkbuf_4
X_05710_ _00395_ VGND VGND VPWR VPWR _00406_ sky130_fd_sc_hd__clkbuf_4
X_06690_ _00115_ _00116_ _00014_ _00031_ VGND VGND VPWR VPWR _00118_ sky130_fd_sc_hd__a211oi_2
X_08360_ _01918_ _01921_ _01922_ VGND VGND VPWR VPWR _01923_ sky130_fd_sc_hd__nand3_1
XTAP_TAPCELL_ROW_106_1593 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_106_1582 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
X_07311_ _00772_ _00775_ _00776_ VGND VGND VPWR VPWR _00778_ sky130_fd_sc_hd__and3_1
XFILLER_0_18_239 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
X_08291_ _01687_ _01688_ _01703_ _01704_ VGND VGND VPWR VPWR _01848_ sky130_fd_sc_hd__a211o_1
XFILLER_0_73_378 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_0_6_645 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_6_634 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_5_111 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
X_07242_ _00698_ _00699_ _00700_ VGND VGND VPWR VPWR _00703_ sky130_fd_sc_hd__a21o_1
XFILLER_0_116_458 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_104_609 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_07173_ _00483_ _00487_ VGND VGND VPWR VPWR _00627_ sky130_fd_sc_hd__or2_4
XFILLER_0_54_592 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_14_401 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_26_250 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
X_06124_ _03376_ VGND VGND VPWR VPWR _04922_ sky130_fd_sc_hd__buf_4
XFILLER_0_112_642 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XFILLER_0_68_3 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
X_06055_ _04140_ _04150_ _03529_ _03561_ VGND VGND VPWR VPWR _04172_ sky130_fd_sc_hd__a211o_1
X_09814_ _03508_ _03509_ _03358_ _03360_ VGND VGND VPWR VPWR _03511_ sky130_fd_sc_hd__o211a_1
XTAP_TAPCELL_ROW_70_1136 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_6_338 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
X_09745_ _03427_ _03428_ _03432_ _03434_ VGND VGND VPWR VPWR _03435_ sky130_fd_sc_hd__o211a_1
X_06957_ _00389_ _00390_ VGND VGND VPWR VPWR _00391_ sky130_fd_sc_hd__and2_1
X_09676_ _03318_ _03319_ _03358_ _03359_ VGND VGND VPWR VPWR _03360_ sky130_fd_sc_hd__o211ai_4
X_06888_ _00313_ _00314_ _00292_ VGND VGND VPWR VPWR _00316_ sky130_fd_sc_hd__a21oi_2
X_05908_ _00832_ _00854_ _00963_ _01607_ VGND VGND VPWR VPWR _02568_ sky130_fd_sc_hd__and4_1
X_05839_ _01793_ _01804_ VGND VGND VPWR VPWR _01815_ sky130_fd_sc_hd__or2_1
X_08627_ _02212_ _02213_ _02012_ _02031_ VGND VGND VPWR VPWR _02215_ sky130_fd_sc_hd__a211o_2
XTAP_TAPCELL_ROW_53_922 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_77_673 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
X_08558_ _01604_ _02137_ _02138_ VGND VGND VPWR VPWR _02139_ sky130_fd_sc_hd__a21bo_1
XTAP_TAPCELL_ROW_81_1276 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
X_08489_ _03791_ _01187_ _02059_ _02062_ VGND VGND VPWR VPWR _02063_ sky130_fd_sc_hd__a22o_1
X_07509_ _00990_ _00992_ _00993_ VGND VGND VPWR VPWR _00994_ sky130_fd_sc_hd__nand3_1
XFILLER_0_37_537 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_92_665 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
X_10520_ _00762_ _03440_ _04278_ _04279_ VGND VGND VPWR VPWR _04280_ sky130_fd_sc_hd__a22o_1
X_10451_ _04203_ _04204_ VGND VGND VPWR VPWR _04206_ sky130_fd_sc_hd__xor2_1
XFILLER_0_91_186 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_17_250 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
X_10382_ _04039_ _04022_ _04128_ _04130_ VGND VGND VPWR VPWR _04131_ sky130_fd_sc_hd__a211o_2
XFILLER_0_32_253 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_102_152 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_60_595 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XFILLER_0_103_697 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_102_174 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_20_459 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
X_11003_ _00754_ _04800_ _04803_ _04804_ VGND VGND VPWR VPWR _04805_ sky130_fd_sc_hd__o2bb2a_1
XFILLER_0_114_15 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_55_301 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_0_95_492 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_10718_ _04492_ _04494_ VGND VGND VPWR VPWR _04495_ sky130_fd_sc_hd__xor2_1
XTAP_TAPCELL_ROW_99_1504 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_31_649 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_36_581 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
X_10649_ _04271_ _04273_ _04419_ _04420_ VGND VGND VPWR VPWR _04421_ sky130_fd_sc_hd__a211o_2
XFILLER_0_70_348 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_3_615 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_51_584 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XFILLER_0_51_573 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XTAP_TAPCELL_ROW_11_395 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_11_426 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_23_286 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_0_121_494 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_07860_ _01375_ _01376_ VGND VGND VPWR VPWR _01377_ sky130_fd_sc_hd__nor2_1
X_06811_ _00236_ VGND VGND VPWR VPWR _00237_ sky130_fd_sc_hd__clkbuf_4
X_07791_ _01264_ _01265_ _01300_ _01301_ VGND VGND VPWR VPWR _01303_ sky130_fd_sc_hd__or4_2
XTAP_TAPCELL_ROW_108_1611 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
X_09530_ _03197_ _03198_ _03191_ VGND VGND VPWR VPWR _03200_ sky130_fd_sc_hd__a21o_1
X_06742_ _00167_ _00168_ VGND VGND VPWR VPWR _00169_ sky130_fd_sc_hd__and2b_1
XTAP_TAPCELL_ROW_39_749 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
X_09461_ _03121_ _03122_ _03000_ _03002_ VGND VGND VPWR VPWR _03125_ sky130_fd_sc_hd__o211a_1
X_06673_ _00097_ _00098_ _00099_ VGND VGND VPWR VPWR _00101_ sky130_fd_sc_hd__a21o_1
X_09392_ _03002_ _03003_ _03047_ _03049_ VGND VGND VPWR VPWR _03050_ sky130_fd_sc_hd__nand4_2
XFILLER_0_59_673 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
X_08412_ _01449_ VGND VGND VPWR VPWR _01980_ sky130_fd_sc_hd__buf_4
XTAP_TAPCELL_ROW_19_495 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
X_08343_ _01901_ _01904_ VGND VGND VPWR VPWR _01905_ sky130_fd_sc_hd__xor2_2
XFILLER_0_58_194 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
X_08274_ _01647_ _01714_ _01828_ _01829_ VGND VGND VPWR VPWR _01830_ sky130_fd_sc_hd__a211oi_4
XFILLER_0_46_356 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
X_07225_ _00682_ _00683_ VGND VGND VPWR VPWR _00684_ sky130_fd_sc_hd__and2b_1
XTAP_TAPCELL_ROW_119_1751 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_61_337 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_14_220 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_14_253 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
X_07156_ _00522_ _00523_ _00539_ VGND VGND VPWR VPWR _00608_ sky130_fd_sc_hd__o21a_1
XFILLER_0_30_713 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_0_42_562 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
X_06107_ _04726_ VGND VGND VPWR VPWR _04737_ sky130_fd_sc_hd__buf_4
X_07087_ _03856_ VGND VGND VPWR VPWR _00533_ sky130_fd_sc_hd__clkbuf_4
XFILLER_0_2_681 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
X_06038_ _03725_ _03965_ _03976_ VGND VGND VPWR VPWR _03987_ sky130_fd_sc_hd__or3_1
XFILLER_0_100_678 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_100_645 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_0_10_481 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
X_09728_ _03173_ _03391_ _03413_ _03414_ VGND VGND VPWR VPWR _03416_ sky130_fd_sc_hd__o22ai_4
X_07989_ _01515_ _01516_ VGND VGND VPWR VPWR _01517_ sky130_fd_sc_hd__and2_1
XPHY_EDGE_ROW_29_Right_29 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
X_09659_ _02516_ VGND VGND VPWR VPWR _03341_ sky130_fd_sc_hd__buf_4
XTAP_TAPCELL_ROW_83_1305 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_108_701 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_65_621 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_64_153 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_37_378 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XPHY_EDGE_ROW_38_Right_38 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
X_10503_ _04260_ _04261_ VGND VGND VPWR VPWR _04262_ sky130_fd_sc_hd__xor2_1
XFILLER_0_64_197 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
X_10434_ _04153_ _04186_ VGND VGND VPWR VPWR _04187_ sky130_fd_sc_hd__xnor2_2
XFILLER_0_80_679 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
X_10365_ _04109_ _04110_ _04105_ VGND VGND VPWR VPWR _04112_ sky130_fd_sc_hd__a21o_1
XTAP_TAPCELL_ROW_94_1434 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_0_607 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_33_595 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
X_10296_ _04036_ _03923_ _03917_ VGND VGND VPWR VPWR _04037_ sky130_fd_sc_hd__a21o_1
XFILLER_0_109_15 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XPHY_EDGE_ROW_47_Right_47 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_0_88_713 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_0_87_201 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XTAP_TAPCELL_ROW_36_708 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_87_256 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XTAP_TAPCELL_ROW_103_1552 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_16_465 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_28_301 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XPHY_EDGE_ROW_56_Right_56 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XPHY_EDGE_ROW_117_Left_239 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_0_55_164 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_0_16_529 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_0_28_389 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_70_145 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_43_337 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_70_178 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_12_713 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
X_07010_ _00404_ _00405_ _00446_ _00447_ VGND VGND VPWR VPWR _00449_ sky130_fd_sc_hd__o22ai_4
XFILLER_0_11_245 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XTAP_TAPCELL_ROW_114_1692 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_114_1681 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
X_08961_ _00515_ _02236_ _02418_ VGND VGND VPWR VPWR _02579_ sky130_fd_sc_hd__nand3_1
XPHY_EDGE_ROW_65_Right_65 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_0_11_289 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
X_08892_ _02329_ _02331_ _02330_ VGND VGND VPWR VPWR _02504_ sky130_fd_sc_hd__a21bo_1
X_07912_ _02699_ _02208_ net45 VGND VGND VPWR VPWR _01435_ sky130_fd_sc_hd__and3_1
X_07843_ _01352_ _01358_ VGND VGND VPWR VPWR _01359_ sky130_fd_sc_hd__xnor2_2
X_07774_ net51 VGND VGND VPWR VPWR _01284_ sky130_fd_sc_hd__clkbuf_4
X_06725_ _00151_ VGND VGND VPWR VPWR _00152_ sky130_fd_sc_hd__clkbuf_4
X_09513_ _03177_ _03180_ _03034_ _03170_ VGND VGND VPWR VPWR _03182_ sky130_fd_sc_hd__a211oi_1
X_09444_ _00187_ _00894_ _02944_ _00084_ VGND VGND VPWR VPWR _03106_ sky130_fd_sc_hd__a22o_1
XFILLER_0_66_418 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
X_06656_ _05585_ VGND VGND VPWR VPWR _00084_ sky130_fd_sc_hd__buf_4
XPHY_EDGE_ROW_74_Right_74 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XTAP_TAPCELL_ROW_65_1079 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_59_481 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
X_09375_ _01782_ _02251_ _03030_ _02705_ VGND VGND VPWR VPWR _03031_ sky130_fd_sc_hd__nand4_1
X_06587_ _05648_ _00014_ _00015_ VGND VGND VPWR VPWR _00016_ sky130_fd_sc_hd__or3_1
XFILLER_0_62_624 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
X_08326_ _01882_ _01883_ _01697_ _01868_ VGND VGND VPWR VPWR _01886_ sky130_fd_sc_hd__o211ai_2
X_08257_ _01808_ _01809_ _01810_ VGND VGND VPWR VPWR _01811_ sky130_fd_sc_hd__nand3_1
XFILLER_0_15_573 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
X_07208_ _00663_ _00664_ VGND VGND VPWR VPWR _00665_ sky130_fd_sc_hd__nor2_1
X_08188_ _00089_ net6 _01584_ _01583_ _00294_ VGND VGND VPWR VPWR _01735_ sky130_fd_sc_hd__a32o_1
X_07139_ _00451_ _00453_ net142 _00589_ VGND VGND VPWR VPWR _00590_ sky130_fd_sc_hd__a211oi_2
XFILLER_0_15_595 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XPHY_EDGE_ROW_83_Right_83 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
X_10150_ _02976_ _02645_ _00896_ _01042_ _03766_ VGND VGND VPWR VPWR _03877_ sky130_fd_sc_hd__a41o_1
XFILLER_0_30_587 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
X_10081_ _02136_ _03030_ _02705_ _05551_ VGND VGND VPWR VPWR _03802_ sky130_fd_sc_hd__a22o_1
X_10983_ _04780_ _04782_ _04702_ VGND VGND VPWR VPWR _04784_ sky130_fd_sc_hd__o21bai_2
XPHY_EDGE_ROW_92_Right_92 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_0_84_215 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XTAP_TAPCELL_ROW_13_424 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_65_462 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_53_613 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_0_37_175 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_80_443 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_0_25_337 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XTAP_TAPCELL_ROW_41_777 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_53_679 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
X_11397_ _01501_ _04040_ VGND VGND VPWR VPWR _05230_ sky130_fd_sc_hd__nand2_1
X_10417_ _03324_ _02163_ _03006_ _03323_ VGND VGND VPWR VPWR _04168_ sky130_fd_sc_hd__a22o_1
XFILLER_0_96_29 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
X_10348_ _03982_ _03984_ VGND VGND VPWR VPWR _04093_ sky130_fd_sc_hd__or2_2
X_10279_ _04015_ _04016_ _03851_ _03853_ VGND VGND VPWR VPWR _04018_ sky130_fd_sc_hd__o211ai_2
XTAP_TAPCELL_ROW_49_877 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_45_77 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_06510_ _00384_ _00406_ _05541_ _05637_ VGND VGND VPWR VPWR _05639_ sky130_fd_sc_hd__nand4_1
X_07490_ _02721_ _03649_ _00423_ _00197_ VGND VGND VPWR VPWR _00973_ sky130_fd_sc_hd__nand4_2
XFILLER_0_48_418 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XFILLER_0_75_215 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_0_57 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_0_35 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
X_06441_ _05476_ _05547_ _05569_ _05570_ VGND VGND VPWR VPWR _05571_ sky130_fd_sc_hd__a211o_1
XFILLER_0_118_328 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XPHY_EDGE_ROW_100_Right_100 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_0_28_120 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_0_90_218 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
X_09160_ _01898_ _02794_ _02795_ VGND VGND VPWR VPWR _02796_ sky130_fd_sc_hd__a21bo_1
X_06372_ _03310_ _03365_ _05425_ _05502_ VGND VGND VPWR VPWR _05503_ sky130_fd_sc_hd__nand4_2
XFILLER_0_83_281 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
X_09091_ _02547_ _02549_ VGND VGND VPWR VPWR _02722_ sky130_fd_sc_hd__nor2_1
X_08111_ _01469_ _01533_ _01649_ _01650_ VGND VGND VPWR VPWR _01652_ sky130_fd_sc_hd__a211oi_4
XFILLER_0_28_197 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_9_55 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
X_08042_ _01421_ _01423_ VGND VGND VPWR VPWR _01576_ sky130_fd_sc_hd__and2_2
XTAP_TAPCELL_ROW_116_1710 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_52_690 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_3_231 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
X_09993_ _02325_ _00751_ VGND VGND VPWR VPWR _03706_ sky130_fd_sc_hd__nand2_1
XFILLER_0_12_587 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_86_51 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
X_08944_ _02381_ _02384_ VGND VGND VPWR VPWR _02561_ sky130_fd_sc_hd__nor2_1
X_08875_ _02338_ _02341_ _02483_ _02484_ VGND VGND VPWR VPWR _02485_ sky130_fd_sc_hd__o211ai_2
X_07826_ _00493_ net17 _01185_ _00679_ VGND VGND VPWR VPWR _01340_ sky130_fd_sc_hd__a22oi_1
X_07757_ _01262_ _01263_ _01242_ VGND VGND VPWR VPWR _01265_ sky130_fd_sc_hd__a21oi_2
X_06708_ _00069_ _00071_ VGND VGND VPWR VPWR _00135_ sky130_fd_sc_hd__nor2_1
XFILLER_0_66_204 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_07688_ net33 _01187_ _01184_ _01186_ VGND VGND VPWR VPWR _01189_ sky130_fd_sc_hd__o2bb2a_1
XFILLER_0_109_317 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_82_719 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
X_09427_ _00533_ _01674_ _01853_ _00392_ VGND VGND VPWR VPWR _03087_ sky130_fd_sc_hd__a22o_1
X_06639_ _00059_ _00065_ _00066_ VGND VGND VPWR VPWR _00067_ sky130_fd_sc_hd__nand3_1
X_09358_ _01976_ VGND VGND VPWR VPWR _03012_ sky130_fd_sc_hd__buf_4
XFILLER_0_47_473 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_0_74_270 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
X_08309_ _01865_ _01866_ VGND VGND VPWR VPWR _01867_ sky130_fd_sc_hd__nand2_1
XFILLER_0_35_635 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_117_372 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
X_11320_ _05109_ _05146_ _05110_ VGND VGND VPWR VPWR _05148_ sky130_fd_sc_hd__or3_1
XFILLER_0_105_523 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
X_09289_ _02799_ _02807_ _02806_ VGND VGND VPWR VPWR _02937_ sky130_fd_sc_hd__a21o_1
XFILLER_0_35_679 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_0_105_578 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XTAP_TAPCELL_ROW_78_1237 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_50_649 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
X_11251_ _04374_ _05033_ VGND VGND VPWR VPWR _05074_ sky130_fd_sc_hd__nand2_1
XTAP_TAPCELL_ROW_91_1404 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
X_11182_ _04862_ _04936_ _04937_ VGND VGND VPWR VPWR _05000_ sky130_fd_sc_hd__o21ai_1
X_10202_ _03806_ _03809_ _03683_ VGND VGND VPWR VPWR _03934_ sky130_fd_sc_hd__a21o_1
XFILLER_0_30_373 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
X_10133_ _03739_ _03855_ _03857_ VGND VGND VPWR VPWR _03859_ sky130_fd_sc_hd__or3_2
XFILLER_0_100_261 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_30_395 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_100_272 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_10064_ _03781_ _03782_ _03640_ net147 VGND VGND VPWR VPWR _03784_ sky130_fd_sc_hd__a211oi_1
XFILLER_0_106_27 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XTAP_TAPCELL_ROW_89_1377 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_46_836 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
X_10966_ _04757_ _04763_ _04764_ VGND VGND VPWR VPWR _04765_ sky130_fd_sc_hd__nand3_1
XFILLER_0_85_513 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_15_69 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
X_10897_ _04687_ _04688_ _04677_ VGND VGND VPWR VPWR _04690_ sky130_fd_sc_hd__a21oi_1
XFILLER_0_85_546 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XTAP_TAPCELL_ROW_26_582 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_100_1511 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_26_593 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_31_35 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_65_281 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_26_657 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_0_31_57 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_0_108_383 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_25_167 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_80_273 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XFILLER_0_53_498 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
X_11449_ _05274_ _05281_ _05283_ VGND VGND VPWR VPWR _05284_ sky130_fd_sc_hd__mux2_2
XFILLER_0_0_278 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XTAP_TAPCELL_ROW_111_1651 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_56_21 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_0_0_289 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
X_06990_ _00422_ _00426_ VGND VGND VPWR VPWR _00427_ sky130_fd_sc_hd__xnor2_2
X_05941_ _01880_ _02372_ _02907_ _02917_ VGND VGND VPWR VPWR _02928_ sky130_fd_sc_hd__or4bb_1
X_08660_ _02248_ _02249_ VGND VGND VPWR VPWR _02250_ sky130_fd_sc_hd__nor2_2
X_05872_ _02131_ _02142_ _02153_ VGND VGND VPWR VPWR _02175_ sky130_fd_sc_hd__a21oi_1
X_07611_ _01097_ _01104_ VGND VGND VPWR VPWR _01106_ sky130_fd_sc_hd__xor2_2
XFILLER_0_49_705 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_08591_ _01050_ _02174_ VGND VGND VPWR VPWR _02176_ sky130_fd_sc_hd__nand2_1
XFILLER_0_72_75 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_0_72_64 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
X_07542_ _00870_ _00872_ _01025_ _01026_ VGND VGND VPWR VPWR _01030_ sky130_fd_sc_hd__nand4_1
XFILLER_0_119_615 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_76_557 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_72_97 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_64_719 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
X_07473_ _00953_ _00954_ VGND VGND VPWR VPWR _00955_ sky130_fd_sc_hd__xnor2_1
X_09212_ _02849_ _02851_ _02853_ VGND VGND VPWR VPWR _02854_ sky130_fd_sc_hd__nand3_4
XTAP_TAPCELL_ROW_62_1038 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
X_06424_ _00908_ _05551_ _05553_ _02666_ VGND VGND VPWR VPWR _05554_ sky130_fd_sc_hd__a22oi_1
XFILLER_0_17_602 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
X_09143_ _02772_ _02776_ _02777_ VGND VGND VPWR VPWR _02778_ sky130_fd_sc_hd__nand3_2
XFILLER_0_29_484 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
X_06355_ _03223_ VGND VGND VPWR VPWR _05486_ sky130_fd_sc_hd__buf_4
XFILLER_0_98_3 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_44_443 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_114_342 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
X_09074_ _01039_ _02529_ VGND VGND VPWR VPWR _02703_ sky130_fd_sc_hd__and2_1
X_06286_ _05415_ _05417_ VGND VGND VPWR VPWR _05418_ sky130_fd_sc_hd__and2b_1
XFILLER_0_97_50 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
X_08025_ net37 _00035_ _05635_ _05342_ VGND VGND VPWR VPWR _01557_ sky130_fd_sc_hd__a22o_1
XFILLER_0_102_537 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
X_09976_ _03684_ _03685_ VGND VGND VPWR VPWR _03687_ sky130_fd_sc_hd__nand2_1
XTAP_TAPCELL_ROW_73_1178 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
X_08927_ _02526_ _02541_ VGND VGND VPWR VPWR _02542_ sky130_fd_sc_hd__xor2_4
XFILLER_0_99_627 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
X_08858_ _02464_ _02465_ VGND VGND VPWR VPWR _02466_ sky130_fd_sc_hd__and2b_1
X_07809_ _01025_ _01030_ _01174_ VGND VGND VPWR VPWR _01322_ sky130_fd_sc_hd__a21boi_1
XFILLER_0_98_159 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_08789_ _02224_ _02225_ _01665_ _01843_ _02024_ VGND VGND VPWR VPWR _02392_ sky130_fd_sc_hd__a2111oi_2
X_10820_ _04603_ _04604_ _04600_ VGND VGND VPWR VPWR _04606_ sky130_fd_sc_hd__a21o_1
X_10751_ _04529_ _04530_ VGND VGND VPWR VPWR _04532_ sky130_fd_sc_hd__or2_1
XFILLER_0_55_708 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_94_365 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_82_527 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_0_67_579 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
X_10682_ _04356_ _04358_ _04445_ _04446_ VGND VGND VPWR VPWR _04456_ sky130_fd_sc_hd__o211ai_2
XFILLER_0_109_169 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_109_158 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XTAP_TAPCELL_ROW_23_552 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_47_281 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_47_292 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XFILLER_0_118_681 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_90_560 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_62_240 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XTAP_TAPCELL_ROW_51_894 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_35_465 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_105_320 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_90_593 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
X_11303_ _05072_ _05074_ _05071_ VGND VGND VPWR VPWR _05130_ sky130_fd_sc_hd__o21a_1
XFILLER_0_62_295 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
X_11234_ _05053_ _05055_ VGND VGND VPWR VPWR _05056_ sky130_fd_sc_hd__xnor2_1
X_11165_ _04979_ _04980_ VGND VGND VPWR VPWR _04981_ sky130_fd_sc_hd__nand2_1
X_10116_ _00042_ _03341_ _03837_ _03838_ VGND VGND VPWR VPWR _03840_ sky130_fd_sc_hd__nand4_2
X_11096_ _02840_ _01673_ _04831_ _04830_ _01355_ VGND VGND VPWR VPWR _04906_ sky130_fd_sc_hd__a32o_1
XFILLER_0_117_15 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
X_10047_ _02302_ _02947_ _03763_ _03764_ VGND VGND VPWR VPWR _03765_ sky130_fd_sc_hd__a22oi_2
XTAP_TAPCELL_ROW_59_994 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_98_682 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_97_181 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
X_10949_ _04744_ _04745_ VGND VGND VPWR VPWR _04746_ sky130_fd_sc_hd__xnor2_1
XFILLER_0_85_332 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_0_73_505 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_0_46_719 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_5_304 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_5_337 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_0_26_443 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_0_108_180 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_26_487 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
X_06140_ _05052_ _05062_ _05073_ VGND VGND VPWR VPWR _05095_ sky130_fd_sc_hd__a21o_1
X_06071_ _01858_ _02372_ _02896_ _04336_ VGND VGND VPWR VPWR _04347_ sky130_fd_sc_hd__o31a_1
XFILLER_0_1_510 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_22_693 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
X_09830_ _03378_ _03380_ VGND VGND VPWR VPWR _03528_ sky130_fd_sc_hd__nor2_1
XFILLER_0_67_75 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_09761_ _03449_ _03450_ _03451_ VGND VGND VPWR VPWR _03453_ sky130_fd_sc_hd__nand3_1
X_06973_ _00408_ VGND VGND VPWR VPWR _00409_ sky130_fd_sc_hd__clkbuf_8
X_08712_ _02304_ _02305_ _02297_ VGND VGND VPWR VPWR _02308_ sky130_fd_sc_hd__a21o_1
X_05924_ net55 _02721_ _02732_ _00351_ VGND VGND VPWR VPWR _02742_ sky130_fd_sc_hd__a22oi_2
X_09692_ _03231_ _03377_ VGND VGND VPWR VPWR _03378_ sky130_fd_sc_hd__xnor2_4
XFILLER_0_13_3 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
X_08643_ _02081_ _02083_ VGND VGND VPWR VPWR _02232_ sky130_fd_sc_hd__or2_4
X_05855_ _01956_ _01967_ _00810_ _01978_ VGND VGND VPWR VPWR _01989_ sky130_fd_sc_hd__and4b_1
XFILLER_0_107_81 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
X_05786_ _00351_ VGND VGND VPWR VPWR _01236_ sky130_fd_sc_hd__clkbuf_4
X_08574_ _02155_ _02156_ VGND VGND VPWR VPWR _02157_ sky130_fd_sc_hd__and2_2
XTAP_TAPCELL_ROW_1_269 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_88_181 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
X_07525_ _00853_ _00856_ _01010_ _01011_ VGND VGND VPWR VPWR _01012_ sky130_fd_sc_hd__a211oi_4
XFILLER_0_16_90 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_76_365 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_64_516 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_37_719 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_119_478 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_57_590 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_9_665 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_0_8_153 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_29_270 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_07456_ _00933_ _00934_ _00929_ VGND VGND VPWR VPWR _00936_ sky130_fd_sc_hd__a21o_1
XFILLER_0_107_629 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_07387_ _00789_ _00790_ _00858_ _00859_ VGND VGND VPWR VPWR _00861_ sky130_fd_sc_hd__a22oi_4
XTAP_TAPCELL_ROW_20_511 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
X_06407_ _05451_ _05450_ VGND VGND VPWR VPWR _05537_ sky130_fd_sc_hd__or2_1
XFILLER_0_44_240 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
X_09126_ _02757_ _02758_ VGND VGND VPWR VPWR _02759_ sky130_fd_sc_hd__xnor2_1
X_06338_ _01760_ _05468_ VGND VGND VPWR VPWR _05469_ sky130_fd_sc_hd__nand2_1
XFILLER_0_115_673 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
X_09057_ _02681_ _02682_ _02664_ VGND VGND VPWR VPWR _02684_ sky130_fd_sc_hd__a21o_1
XFILLER_0_32_446 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
X_06269_ _05385_ _05386_ _05400_ VGND VGND VPWR VPWR _05401_ sky130_fd_sc_hd__a21oi_2
X_08008_ _05327_ _04726_ _00494_ _00612_ VGND VGND VPWR VPWR _01538_ sky130_fd_sc_hd__nand4_2
XFILLER_0_4_381 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_12_170 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_0_12_192 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XTAP_TAPCELL_ROW_9_369 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
X_09959_ _03528_ _03667_ _03668_ VGND VGND VPWR VPWR _03669_ sky130_fd_sc_hd__a21oi_1
XTAP_TAPCELL_ROW_86_1336 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_28_611 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_56_964 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
X_10803_ _04586_ _04587_ VGND VGND VPWR VPWR _04588_ sky130_fd_sc_hd__xnor2_1
XFILLER_0_95_641 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_95_685 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_28_719 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
X_10734_ _04510_ _04511_ _04499_ VGND VGND VPWR VPWR _04513_ sky130_fd_sc_hd__a21oi_2
XFILLER_0_103_39 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_0_94_184 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_0_82_324 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
X_10665_ _04397_ _04436_ _04437_ VGND VGND VPWR VPWR _04438_ sky130_fd_sc_hd__and3_2
XFILLER_0_106_640 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
X_10596_ _04291_ _04293_ _04334_ _04335_ VGND VGND VPWR VPWR _04363_ sky130_fd_sc_hd__nand4_2
XFILLER_0_112_109 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XTAP_TAPCELL_ROW_97_1476 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_50_265 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_0_121_687 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XFILLER_0_50_298 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_0_31_490 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
Xoutput70 net70 VGND VGND VPWR VPWR product[14] sky130_fd_sc_hd__clkbuf_4
XFILLER_0_120_164 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_11217_ _05021_ _04971_ _05035_ VGND VGND VPWR VPWR _05037_ sky130_fd_sc_hd__a21oi_1
Xoutput81 net81 VGND VGND VPWR VPWR product[24] sky130_fd_sc_hd__clkbuf_4
X_11148_ _04883_ _01355_ _01500_ _04374_ VGND VGND VPWR VPWR _04962_ sky130_fd_sc_hd__a22o_1
Xoutput92 net92 VGND VGND VPWR VPWR product[34] sky130_fd_sc_hd__clkbuf_4
X_11079_ _04814_ _04816_ VGND VGND VPWR VPWR _04887_ sky130_fd_sc_hd__nand2_1
XFILLER_0_37_78 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_58_321 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XTAP_TAPCELL_ROW_106_1583 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_58_365 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_07310_ _04889_ _00143_ _00773_ _00774_ VGND VGND VPWR VPWR _00776_ sky130_fd_sc_hd__a22o_1
XFILLER_0_46_516 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
X_08290_ net141 _01713_ _01830_ _01831_ VGND VGND VPWR VPWR _01846_ sky130_fd_sc_hd__nor4_1
XFILLER_0_116_415 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
X_07241_ _00698_ _00699_ _00700_ VGND VGND VPWR VPWR _00702_ sky130_fd_sc_hd__nand3_1
X_07172_ _00622_ _00625_ VGND VGND VPWR VPWR _00626_ sky130_fd_sc_hd__or2_4
XFILLER_0_6_657 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_42_711 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_0_5_167 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
X_06123_ _03627_ _04900_ VGND VGND VPWR VPWR _04911_ sky130_fd_sc_hd__nand2_1
XFILLER_0_41_221 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_0_41_298 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
X_06054_ _03529_ net160 _04140_ _04150_ VGND VGND VPWR VPWR _04161_ sky130_fd_sc_hd__o211ai_4
X_09813_ _03358_ _03360_ _03508_ _03509_ VGND VGND VPWR VPWR _03510_ sky130_fd_sc_hd__a211oi_4
XTAP_TAPCELL_ROW_70_1137 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_6_339 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_94_73 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
X_09744_ _03433_ _00762_ _03429_ _03431_ VGND VGND VPWR VPWR _03434_ sky130_fd_sc_hd__nand4_1
X_06956_ _04889_ _05557_ _00386_ _00388_ VGND VGND VPWR VPWR _00390_ sky130_fd_sc_hd__a22o_1
X_09675_ _03356_ _03357_ _03320_ _03204_ VGND VGND VPWR VPWR _03359_ sky130_fd_sc_hd__o211ai_2
X_06887_ _00292_ _00313_ _00314_ VGND VGND VPWR VPWR _00315_ sky130_fd_sc_hd__and3_1
X_05907_ _00810_ _01007_ _02065_ _00559_ VGND VGND VPWR VPWR _02557_ sky130_fd_sc_hd__a22oi_1
X_05838_ _01760_ _01782_ _01018_ _01749_ VGND VGND VPWR VPWR _01804_ sky130_fd_sc_hd__a211oi_1
X_08626_ _02012_ net133 _02212_ _02213_ VGND VGND VPWR VPWR _02214_ sky130_fd_sc_hd__o211ai_2
XTAP_TAPCELL_ROW_53_923 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_77_685 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
X_08557_ _02136_ _00558_ _00987_ _05319_ VGND VGND VPWR VPWR _02138_ sky130_fd_sc_hd__a22o_1
X_05769_ _01039_ VGND VGND VPWR VPWR _01050_ sky130_fd_sc_hd__buf_4
XFILLER_0_119_242 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_76_184 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
X_08488_ _05486_ _03736_ _02060_ _02061_ VGND VGND VPWR VPWR _02062_ sky130_fd_sc_hd__nand4_2
X_07508_ _00646_ _00837_ _00991_ _00624_ VGND VGND VPWR VPWR _00993_ sky130_fd_sc_hd__a22o_1
XFILLER_0_37_549 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XFILLER_0_92_677 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XTAP_TAPCELL_ROW_81_1277 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
X_07439_ _01247_ _00751_ _00913_ _00915_ VGND VGND VPWR VPWR _00917_ sky130_fd_sc_hd__a22oi_1
XTAP_TAPCELL_ROW_33_680 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
X_10450_ _02113_ _02051_ VGND VGND VPWR VPWR _04204_ sky130_fd_sc_hd__nand2_1
XFILLER_0_107_459 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_17_262 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_45_582 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_09109_ _02738_ _02739_ _02740_ _02400_ VGND VGND VPWR VPWR _02741_ sky130_fd_sc_hd__a22oi_4
XFILLER_0_115_481 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
X_10381_ _04084_ _04086_ _04126_ _04127_ VGND VGND VPWR VPWR _04130_ sky130_fd_sc_hd__a2bb2oi_2
XFILLER_0_60_552 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_0_32_265 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_0_20_427 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_32_287 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_32_298 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_2_3 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_102_197 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
X_11002_ _00610_ _00614_ _02862_ _02865_ VGND VGND VPWR VPWR _04804_ sky130_fd_sc_hd__and4_1
XFILLER_0_87_449 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_0_114_27 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_82_110 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_23_47 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
X_10717_ _02645_ _03478_ _04405_ _04493_ VGND VGND VPWR VPWR _04494_ sky130_fd_sc_hd__a31o_1
XTAP_TAPCELL_ROW_99_1505 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_55_357 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_10648_ _01606_ _02941_ _04417_ _04418_ VGND VGND VPWR VPWR _04420_ sky130_fd_sc_hd__and4_1
X_10579_ _04250_ _04251_ _04343_ _04344_ VGND VGND VPWR VPWR _04345_ sky130_fd_sc_hd__o211ai_4
XTAP_TAPCELL_ROW_11_396 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_121_440 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_0_11_449 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_11_438 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XPHY_EDGE_ROW_39_Left_161 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
X_06810_ _00235_ VGND VGND VPWR VPWR _00236_ sky130_fd_sc_hd__clkbuf_4
X_07790_ _01298_ _01299_ _01126_ _01129_ VGND VGND VPWR VPWR _01301_ sky130_fd_sc_hd__o211a_1
XTAP_TAPCELL_ROW_108_1612 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_3_57 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
X_06741_ _03343_ _03015_ _04074_ _03332_ VGND VGND VPWR VPWR _00168_ sky130_fd_sc_hd__a22o_1
X_09460_ _03000_ _03002_ _03121_ _03122_ VGND VGND VPWR VPWR _03123_ sky130_fd_sc_hd__a211oi_2
XFILLER_0_59_641 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_06672_ _00097_ _00098_ _00099_ VGND VGND VPWR VPWR _00100_ sky130_fd_sc_hd__nand3_1
X_08411_ _02677_ _01977_ VGND VGND VPWR VPWR _01979_ sky130_fd_sc_hd__nand2_1
XPHY_EDGE_ROW_48_Left_170 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
X_09391_ net152 _03046_ _02886_ _02888_ VGND VGND VPWR VPWR _03049_ sky130_fd_sc_hd__o211ai_2
XFILLER_0_58_151 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XTAP_TAPCELL_ROW_19_496 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_19_505 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_74_622 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_0_73_110 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
X_08342_ _04748_ _01903_ VGND VGND VPWR VPWR _01904_ sky130_fd_sc_hd__nand2_1
XFILLER_0_19_538 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
X_08273_ _01753_ _01754_ _01825_ _01827_ VGND VGND VPWR VPWR _01829_ sky130_fd_sc_hd__a22oi_4
XFILLER_0_74_699 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_61_305 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_6_421 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
X_07224_ _00680_ _00681_ _00676_ VGND VGND VPWR VPWR _00683_ sky130_fd_sc_hd__a21o_1
XFILLER_0_34_519 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XTAP_TAPCELL_ROW_119_1752 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_80_3 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
X_07155_ _00512_ VGND VGND VPWR VPWR _00607_ sky130_fd_sc_hd__inv_2
XFILLER_0_14_265 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XFILLER_0_14_287 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
X_07086_ _00530_ _00531_ VGND VGND VPWR VPWR _00532_ sky130_fd_sc_hd__or2b_1
X_06106_ _02000_ VGND VGND VPWR VPWR _04726_ sky130_fd_sc_hd__buf_4
XFILLER_0_2_693 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
X_06037_ _03932_ _03943_ _03954_ VGND VGND VPWR VPWR _03976_ sky130_fd_sc_hd__a21oi_1
XFILLER_0_1_181 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_10_493 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
X_07988_ _01513_ _01514_ _01369_ _01370_ VGND VGND VPWR VPWR _01516_ sky130_fd_sc_hd__o211ai_1
XPHY_EDGE_ROW_114_Right_114 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
X_09727_ _03173_ _03391_ _03413_ _03414_ VGND VGND VPWR VPWR _03415_ sky130_fd_sc_hd__or4_4
X_06939_ _00248_ _00360_ _00370_ VGND VGND VPWR VPWR _00371_ sky130_fd_sc_hd__a21oi_1
X_09658_ _03150_ _03152_ VGND VGND VPWR VPWR _03340_ sky130_fd_sc_hd__nand2_1
XFILLER_0_96_268 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_96_257 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_84_408 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
X_09589_ _03259_ _03262_ _03263_ VGND VGND VPWR VPWR _03264_ sky130_fd_sc_hd__nand3_4
XFILLER_0_49_140 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
X_08609_ _01984_ _01994_ _01993_ VGND VGND VPWR VPWR _02195_ sky130_fd_sc_hd__a21bo_1
XFILLER_0_49_162 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_0_108_713 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_0_92_441 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_37_335 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
X_10502_ _00042_ _03178_ VGND VGND VPWR VPWR _04261_ sky130_fd_sc_hd__nand2_1
XFILLER_0_52_316 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_52_305 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_0_9_281 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_18_593 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_33_530 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
X_10433_ _04184_ _04185_ VGND VGND VPWR VPWR _04186_ sky130_fd_sc_hd__xnor2_2
XFILLER_0_100_29 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
X_10364_ _04105_ _04109_ _04110_ VGND VGND VPWR VPWR _04111_ sky130_fd_sc_hd__nand3_4
XTAP_TAPCELL_ROW_94_1435 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_103_484 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
X_10295_ _03915_ _03916_ VGND VGND VPWR VPWR _04036_ sky130_fd_sc_hd__xor2_1
XFILLER_0_109_27 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XTAP_TAPCELL_ROW_36_709 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_87_268 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_34_68 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XTAP_TAPCELL_ROW_103_1553 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_8_719 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XTAP_TAPCELL_ROW_16_466 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_55_121 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_7_218 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_0_119_3 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_70_135 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_0_3_402 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_70_157 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_113_259 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_59_32 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_11_213 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XTAP_TAPCELL_ROW_114_1682 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
X_08960_ _02416_ _02417_ VGND VGND VPWR VPWR _02577_ sky130_fd_sc_hd__or2b_1
XFILLER_0_52_7 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XTAP_TAPCELL_ROW_114_1693 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
X_08891_ _02499_ _02500_ _02498_ VGND VGND VPWR VPWR _02503_ sky130_fd_sc_hd__a21o_1
X_07911_ _02764_ _00688_ VGND VGND VPWR VPWR _01434_ sky130_fd_sc_hd__nand2_1
X_07842_ _01356_ _01357_ VGND VGND VPWR VPWR _01358_ sky130_fd_sc_hd__nand2_1
X_09512_ _03034_ _03170_ _03177_ _03180_ VGND VGND VPWR VPWR _03181_ sky130_fd_sc_hd__o211a_1
X_07773_ _00428_ _00991_ VGND VGND VPWR VPWR _01283_ sky130_fd_sc_hd__and2_1
X_06724_ _00150_ VGND VGND VPWR VPWR _00151_ sky130_fd_sc_hd__buf_4
XFILLER_0_91_52 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
X_09443_ _01221_ _00753_ _02967_ _02966_ _01898_ VGND VGND VPWR VPWR _03105_ sky130_fd_sc_hd__a32o_1
X_06655_ _00074_ _00082_ VGND VGND VPWR VPWR _00083_ sky130_fd_sc_hd__xor2_2
XFILLER_0_115_81 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XTAP_TAPCELL_ROW_65_1069 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
X_09374_ _01805_ VGND VGND VPWR VPWR _03030_ sky130_fd_sc_hd__buf_4
XFILLER_0_47_633 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_74_430 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
X_08325_ _01884_ VGND VGND VPWR VPWR _01885_ sky130_fd_sc_hd__inv_2
X_06586_ _00012_ _00013_ _05649_ _05610_ VGND VGND VPWR VPWR _00015_ sky130_fd_sc_hd__a211oi_1
XFILLER_0_117_532 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_0_61_113 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_6_262 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_6_251 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
X_08256_ _01626_ _01628_ _01627_ VGND VGND VPWR VPWR _01810_ sky130_fd_sc_hd__a21bo_1
X_08187_ _00084_ _01414_ _05541_ _05637_ _01560_ VGND VGND VPWR VPWR _01734_ sky130_fd_sc_hd__a41o_1
X_07207_ _05689_ _00269_ _00661_ _00662_ VGND VGND VPWR VPWR _00664_ sky130_fd_sc_hd__a22oi_1
X_07138_ _00517_ _00518_ _00586_ _00587_ VGND VGND VPWR VPWR _00589_ sky130_fd_sc_hd__o22a_1
XFILLER_0_42_371 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_42_382 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_0_30_533 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_100_421 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
X_07069_ _00510_ _00511_ _00498_ VGND VGND VPWR VPWR _00513_ sky130_fd_sc_hd__a21oi_1
X_10080_ _03686_ _03695_ _03687_ VGND VGND VPWR VPWR _03800_ sky130_fd_sc_hd__or3b_1
XFILLER_0_97_511 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_10982_ _04780_ _04782_ _04702_ VGND VGND VPWR VPWR _04783_ sky130_fd_sc_hd__or3b_2
XFILLER_0_52_102 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XTAP_TAPCELL_ROW_13_425 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_37_165 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_0_38_699 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_92_293 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_25_349 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XFILLER_0_37_187 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XTAP_TAPCELL_ROW_41_778 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_108_587 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_52_146 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
X_10416_ _03323_ _03324_ _02163_ VGND VGND VPWR VPWR _04167_ sky130_fd_sc_hd__and3_1
XFILLER_0_61_691 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
X_11396_ _05197_ _05198_ VGND VGND VPWR VPWR _05229_ sky130_fd_sc_hd__or2b_1
XFILLER_0_21_555 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_0_33_393 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_103_270 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
X_10347_ _04090_ _04091_ VGND VGND VPWR VPWR _04092_ sky130_fd_sc_hd__or2_2
XFILLER_0_0_449 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
X_10278_ _03851_ _03853_ _04015_ _04016_ VGND VGND VPWR VPWR _04017_ sky130_fd_sc_hd__a211o_1
XFILLER_0_29_57 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_0_29_79 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_0_88_500 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_88_533 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XTAP_TAPCELL_ROW_49_878 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
Xmax_cap1 _01846_ VGND VGND VPWR VPWR net168 sky130_fd_sc_hd__clkbuf_1
XFILLER_0_88_577 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_0_14 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_61_11 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_0_47 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
X_06440_ _05548_ _05549_ _05568_ VGND VGND VPWR VPWR _05570_ sky130_fd_sc_hd__nor3_2
XFILLER_0_29_622 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_91_709 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_56_441 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_0_0_69 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
X_06371_ net38 VGND VGND VPWR VPWR _05502_ sky130_fd_sc_hd__buf_4
XFILLER_0_83_293 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_0_71_411 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
X_09090_ _02662_ _02719_ VGND VGND VPWR VPWR _02720_ sky130_fd_sc_hd__xnor2_4
X_08110_ _01572_ _01573_ _01647_ _01648_ VGND VGND VPWR VPWR _01650_ sky130_fd_sc_hd__a2bb2oi_2
XFILLER_0_28_176 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_0_28_187 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_08041_ _01428_ _01429_ _01465_ _01466_ VGND VGND VPWR VPWR _01575_ sky130_fd_sc_hd__nor4_1
XTAP_TAPCELL_ROW_116_1711 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_12_533 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
X_09992_ _01898_ _03702_ _03704_ VGND VGND VPWR VPWR _03705_ sky130_fd_sc_hd__a21bo_1
X_08943_ _02405_ _02559_ VGND VGND VPWR VPWR _02560_ sky130_fd_sc_hd__xnor2_2
XFILLER_0_43_3 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
X_08874_ _02481_ _02482_ _02467_ VGND VGND VPWR VPWR _02484_ sky130_fd_sc_hd__a21o_1
XFILLER_0_19_90 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
X_07825_ _00495_ _01207_ _01209_ _01206_ VGND VGND VPWR VPWR _01339_ sky130_fd_sc_hd__o2bb2a_2
X_07756_ _01242_ _01262_ _01263_ VGND VGND VPWR VPWR _01264_ sky130_fd_sc_hd__and3_1
XFILLER_0_79_577 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_67_717 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
X_06707_ _00053_ _00113_ _00114_ VGND VGND VPWR VPWR _00134_ sky130_fd_sc_hd__and3_1
X_09426_ _00533_ _00392_ _01675_ VGND VGND VPWR VPWR _03086_ sky130_fd_sc_hd__and3_1
X_07687_ _01184_ _01186_ net33 _01187_ VGND VGND VPWR VPWR _01188_ sky130_fd_sc_hd__and4bb_1
XFILLER_0_109_329 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_0_66_238 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_0_59_290 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
X_06638_ _00062_ _00063_ _00064_ VGND VGND VPWR VPWR _00066_ sky130_fd_sc_hd__a21o_1
X_09357_ _03009_ _03010_ VGND VGND VPWR VPWR _03011_ sky130_fd_sc_hd__xor2_1
X_06569_ _05692_ _05694_ _05697_ VGND VGND VPWR VPWR _05698_ sky130_fd_sc_hd__nand3_1
XFILLER_0_35_614 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
X_09288_ _02934_ _02935_ VGND VGND VPWR VPWR _02936_ sky130_fd_sc_hd__xor2_4
XFILLER_0_62_411 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
X_08308_ _01684_ _01864_ VGND VGND VPWR VPWR _01866_ sky130_fd_sc_hd__or2_1
XFILLER_0_105_535 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_34_135 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
X_08239_ _01622_ _01786_ _01789_ _01790_ VGND VGND VPWR VPWR _01791_ sky130_fd_sc_hd__o211a_1
XFILLER_0_105_568 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XTAP_TAPCELL_ROW_78_1238 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_91_1405 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
X_11250_ _05070_ _05071_ VGND VGND VPWR VPWR _05072_ sky130_fd_sc_hd__nand2_1
XFILLER_0_15_393 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
X_11181_ _04864_ _04938_ VGND VGND VPWR VPWR _04999_ sky130_fd_sc_hd__or2_1
X_10201_ _03930_ _03931_ VGND VGND VPWR VPWR _03933_ sky130_fd_sc_hd__nand2_1
X_10132_ _03855_ _03857_ _03739_ VGND VGND VPWR VPWR _03858_ sky130_fd_sc_hd__o21ai_2
X_10063_ _03640_ net147 _03781_ _03782_ VGND VGND VPWR VPWR _03783_ sky130_fd_sc_hd__o211a_2
XTAP_TAPCELL_ROW_89_1378 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_97_330 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_0_15_15 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XTAP_TAPCELL_ROW_46_837 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
X_10965_ _04761_ _04762_ _04651_ _04653_ VGND VGND VPWR VPWR _04764_ sky130_fd_sc_hd__o211ai_2
X_10896_ _04677_ _04687_ _04688_ VGND VGND VPWR VPWR _04689_ sky130_fd_sc_hd__and3_1
XFILLER_0_85_558 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XFILLER_0_73_709 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XTAP_TAPCELL_ROW_26_583 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_100_1512 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_93_580 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_65_293 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_108_395 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XFILLER_0_108_362 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XFILLER_0_80_230 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
X_11448_ _05272_ _05253_ _05269_ _05270_ _05282_ VGND VGND VPWR VPWR _05283_ sky130_fd_sc_hd__o311ai_1
XFILLER_0_111_516 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_0_111_505 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_0_40_127 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
X_11379_ _05114_ _05210_ VGND VGND VPWR VPWR _05211_ sky130_fd_sc_hd__nand2_1
XFILLER_0_0_235 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XFILLER_0_0_257 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XTAP_TAPCELL_ROW_111_1652 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
X_05940_ _01858_ _02372_ _02885_ _02896_ VGND VGND VPWR VPWR _02917_ sky130_fd_sc_hd__o22ai_1
X_05871_ _02131_ _02142_ _02153_ VGND VGND VPWR VPWR _02164_ sky130_fd_sc_hd__and3_1
X_08590_ _02173_ VGND VGND VPWR VPWR _02174_ sky130_fd_sc_hd__clkbuf_8
X_07610_ _01098_ _01103_ VGND VGND VPWR VPWR _01104_ sky130_fd_sc_hd__xnor2_2
XFILLER_0_88_330 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
X_07541_ _00888_ _01028_ VGND VGND VPWR VPWR net81 sky130_fd_sc_hd__xor2_4
XFILLER_0_76_569 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
X_07472_ _05589_ _05557_ VGND VGND VPWR VPWR _00954_ sky130_fd_sc_hd__nand2_1
XFILLER_0_48_249 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
X_09211_ _02672_ _02673_ _02674_ VGND VGND VPWR VPWR _02853_ sky130_fd_sc_hd__a21bo_1
XTAP_TAPCELL_ROW_62_1039 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
X_06423_ _05552_ VGND VGND VPWR VPWR _05553_ sky130_fd_sc_hd__buf_4
XFILLER_0_91_539 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
X_09142_ _00076_ _02064_ _02773_ _02774_ VGND VGND VPWR VPWR _02777_ sky130_fd_sc_hd__nand4_2
X_06354_ _03627_ _05419_ _05417_ _05415_ VGND VGND VPWR VPWR _05485_ sky130_fd_sc_hd__a31o_1
XFILLER_0_114_321 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
X_09073_ _02700_ _02701_ VGND VGND VPWR VPWR _02702_ sky130_fd_sc_hd__and2_2
XFILLER_0_21_91 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
X_06285_ _01007_ _03856_ _05416_ _00330_ VGND VGND VPWR VPWR _05417_ sky130_fd_sc_hd__a22o_1
XFILLER_0_44_477 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XFILLER_0_114_365 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_102_505 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
X_08024_ _01390_ _01391_ VGND VGND VPWR VPWR _01556_ sky130_fd_sc_hd__or2_2
XFILLER_0_102_549 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_0_12_363 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_40_694 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
X_09975_ _03684_ _03685_ VGND VGND VPWR VPWR _03686_ sky130_fd_sc_hd__nor2_1
XTAP_TAPCELL_ROW_73_1179 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
X_08926_ _02538_ _02540_ VGND VGND VPWR VPWR _02541_ sky130_fd_sc_hd__xnor2_4
XFILLER_0_99_617 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
X_08857_ _02461_ _02462_ _02463_ VGND VGND VPWR VPWR _02465_ sky130_fd_sc_hd__a21o_1
XFILLER_0_99_639 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
X_07808_ _01028_ _01175_ VGND VGND VPWR VPWR _01321_ sky130_fd_sc_hd__or2_1
X_08788_ _02389_ _02390_ VGND VGND VPWR VPWR _02391_ sky130_fd_sc_hd__xor2_2
XFILLER_0_67_503 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
X_07739_ _05318_ net37 net5 net38 VGND VGND VPWR VPWR _01245_ sky130_fd_sc_hd__and4_1
X_10750_ _04527_ _04528_ _04434_ _04436_ VGND VGND VPWR VPWR _04530_ sky130_fd_sc_hd__o211a_1
X_10681_ _04451_ _04454_ VGND VGND VPWR VPWR net106 sky130_fd_sc_hd__xor2_2
XFILLER_0_82_506 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
X_09409_ _03065_ _03067_ VGND VGND VPWR VPWR _03068_ sky130_fd_sc_hd__xnor2_2
XFILLER_0_94_399 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XTAP_TAPCELL_ROW_23_553 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_47_271 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XFILLER_0_118_693 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XTAP_TAPCELL_ROW_51_895 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_23_628 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_0_35_477 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XFILLER_0_35_499 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_0_105_387 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
X_11302_ _05126_ _05128_ VGND VGND VPWR VPWR _05129_ sky130_fd_sc_hd__nand2_1
XFILLER_0_50_458 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XFILLER_0_16_691 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_11233_ _02840_ _04724_ _04975_ _05054_ VGND VGND VPWR VPWR _05055_ sky130_fd_sc_hd__a31o_1
XFILLER_0_31_661 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_11164_ _04960_ _04978_ VGND VGND VPWR VPWR _04980_ sky130_fd_sc_hd__or2_1
X_10115_ _02646_ _03341_ _03837_ _03838_ VGND VGND VPWR VPWR _03839_ sky130_fd_sc_hd__a22o_1
X_11095_ _04903_ _04904_ VGND VGND VPWR VPWR _04905_ sky130_fd_sc_hd__or2_1
XFILLER_0_117_27 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
X_10046_ _00411_ _01762_ _02943_ _02944_ VGND VGND VPWR VPWR _03764_ sky130_fd_sc_hd__nand4_1
XTAP_TAPCELL_ROW_59_995 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_98_694 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XPHY_EDGE_ROW_11_Left_133 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_0_97_193 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
X_10948_ _02838_ _02041_ _04662_ _04660_ _01354_ VGND VGND VPWR VPWR _04745_ sky130_fd_sc_hd__a32o_1
XFILLER_0_85_366 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_10879_ _04586_ _04587_ VGND VGND VPWR VPWR _04670_ sky130_fd_sc_hd__and2b_1
XFILLER_0_115_129 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_109_671 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_53_241 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XFILLER_0_108_192 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_0_81_572 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XFILLER_0_81_561 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XFILLER_0_14_617 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_26_477 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_0_26_499 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_101_3 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XANTENNA_1 _00344_ VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
X_06070_ _02339_ _02414_ _02863_ _02874_ VGND VGND VPWR VPWR _04336_ sky130_fd_sc_hd__o211ai_1
XPHY_EDGE_ROW_20_Left_142 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_0_1_522 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_41_469 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_0_111_379 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
X_09760_ _03340_ _03349_ _03348_ VGND VGND VPWR VPWR _03451_ sky130_fd_sc_hd__a21bo_1
X_06972_ _05030_ VGND VGND VPWR VPWR _00408_ sky130_fd_sc_hd__buf_4
X_09691_ _03373_ _03375_ VGND VGND VPWR VPWR _03377_ sky130_fd_sc_hd__xor2_4
X_08711_ _02297_ _02304_ _02305_ VGND VGND VPWR VPWR _02307_ sky130_fd_sc_hd__nand3_1
X_05923_ net30 VGND VGND VPWR VPWR _02732_ sky130_fd_sc_hd__buf_4
XFILLER_0_83_53 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
X_08642_ _01356_ _02230_ _02050_ _02049_ VGND VGND VPWR VPWR _02231_ sky130_fd_sc_hd__a31o_1
X_05854_ net23 VGND VGND VPWR VPWR _01978_ sky130_fd_sc_hd__clkbuf_4
X_05785_ _00723_ _01214_ VGND VGND VPWR VPWR _01225_ sky130_fd_sc_hd__nor2_1
X_08573_ _02152_ _02154_ _02132_ VGND VGND VPWR VPWR _02156_ sky130_fd_sc_hd__a21o_1
XFILLER_0_49_503 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
X_07524_ _00968_ _00969_ _01008_ _01009_ VGND VGND VPWR VPWR _01011_ sky130_fd_sc_hd__a2bb2oi_2
XFILLER_0_8_121 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
X_07455_ _00929_ _00933_ _00934_ VGND VGND VPWR VPWR _00935_ sky130_fd_sc_hd__nand3_1
XFILLER_0_64_528 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
X_06406_ _05534_ _05536_ VGND VGND VPWR VPWR net70 sky130_fd_sc_hd__xnor2_4
XFILLER_0_106_129 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_07386_ _00789_ _00790_ _00858_ _00859_ VGND VGND VPWR VPWR _00860_ sky130_fd_sc_hd__and4_2
XFILLER_0_17_433 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XTAP_TAPCELL_ROW_20_512 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
X_06337_ _05467_ VGND VGND VPWR VPWR _05468_ sky130_fd_sc_hd__clkbuf_8
X_09125_ _04900_ _01856_ VGND VGND VPWR VPWR _02758_ sky130_fd_sc_hd__nand2_1
XFILLER_0_60_701 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_115_685 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_114_151 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
X_09056_ _02664_ _02681_ _02682_ VGND VGND VPWR VPWR _02683_ sky130_fd_sc_hd__nand3_2
X_06268_ _05392_ _05399_ VGND VGND VPWR VPWR _05400_ sky130_fd_sc_hd__xor2_1
XFILLER_0_114_173 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
X_08007_ _03288_ _00494_ _00611_ _04878_ VGND VGND VPWR VPWR _01537_ sky130_fd_sc_hd__a22o_1
XFILLER_0_13_661 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_12_160 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
X_06199_ _05330_ _05331_ VGND VGND VPWR VPWR _05332_ sky130_fd_sc_hd__or2_1
XFILLER_0_4_7 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
X_09958_ _03524_ _03526_ VGND VGND VPWR VPWR _03668_ sky130_fd_sc_hd__and2_1
X_08909_ _02519_ _02520_ _02358_ _02359_ VGND VGND VPWR VPWR _02522_ sky130_fd_sc_hd__a211o_1
X_09889_ _03589_ _03590_ _03591_ VGND VGND VPWR VPWR _03592_ sky130_fd_sc_hd__nand3_4
XFILLER_0_99_447 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XTAP_TAPCELL_ROW_86_1337 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_28_612 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_56_965 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
X_10802_ _04484_ _04486_ VGND VGND VPWR VPWR _04587_ sky130_fd_sc_hd__or2_2
X_10733_ _04499_ _04510_ _04511_ VGND VGND VPWR VPWR _04512_ sky130_fd_sc_hd__and3_2
XFILLER_0_55_517 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_95_697 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_94_163 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_82_336 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_55_539 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
X_10664_ _04434_ _04435_ _04328_ _04330_ VGND VGND VPWR VPWR _04437_ sky130_fd_sc_hd__a211o_1
XFILLER_0_82_369 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
X_10595_ _04334_ VGND VGND VPWR VPWR _04362_ sky130_fd_sc_hd__inv_2
XFILLER_0_23_436 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_120_121 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_105_173 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XTAP_TAPCELL_ROW_97_1477 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
X_11216_ _05021_ _04971_ _05035_ VGND VGND VPWR VPWR _05036_ sky130_fd_sc_hd__and3_1
Xoutput93 net93 VGND VGND VPWR VPWR product[35] sky130_fd_sc_hd__clkbuf_4
X_11147_ _04374_ _04883_ _01500_ VGND VGND VPWR VPWR _04961_ sky130_fd_sc_hd__and3_1
Xoutput82 net82 VGND VGND VPWR VPWR product[25] sky130_fd_sc_hd__clkbuf_4
Xoutput71 net71 VGND VGND VPWR VPWR product[15] sky130_fd_sc_hd__buf_2
XFILLER_0_37_57 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_11078_ _04879_ _04885_ VGND VGND VPWR VPWR _04886_ sky130_fd_sc_hd__xnor2_1
X_10029_ _05686_ _00089_ _02036_ _01499_ VGND VGND VPWR VPWR _03745_ sky130_fd_sc_hd__and4_1
XFILLER_0_77_108 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_0_53_45 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XTAP_TAPCELL_ROW_106_1584 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_53_89 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_0_19_709 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
X_07240_ _00564_ _00567_ _00566_ VGND VGND VPWR VPWR _00700_ sky130_fd_sc_hd__a21bo_1
XFILLER_0_54_550 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
X_07171_ _00461_ _00623_ _00620_ _00621_ VGND VGND VPWR VPWR _00625_ sky130_fd_sc_hd__a22oi_1
XFILLER_0_6_669 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_5_113 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_42_701 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_0_112_600 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_06122_ _04889_ VGND VGND VPWR VPWR _04900_ sky130_fd_sc_hd__buf_4
XFILLER_0_41_233 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XFILLER_0_112_611 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_06053_ _04009_ _04020_ _04129_ VGND VGND VPWR VPWR _04150_ sky130_fd_sc_hd__o21ai_2
XFILLER_0_112_699 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_1_363 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
X_09812_ _03505_ _03506_ _03483_ VGND VGND VPWR VPWR _03509_ sky130_fd_sc_hd__o21a_1
XTAP_TAPCELL_ROW_70_1138 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
X_09743_ _02492_ VGND VGND VPWR VPWR _03433_ sky130_fd_sc_hd__clkbuf_4
XFILLER_0_94_96 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_94_85 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
X_06955_ _04889_ _05655_ _00386_ _00388_ VGND VGND VPWR VPWR _00389_ sky130_fd_sc_hd__nand4_1
X_09674_ _03320_ _03204_ _03356_ _03357_ VGND VGND VPWR VPWR _03358_ sky130_fd_sc_hd__a211o_2
X_06886_ _00310_ _00311_ _00312_ VGND VGND VPWR VPWR _00314_ sky130_fd_sc_hd__a21o_1
X_05906_ _02491_ _02502_ _02524_ VGND VGND VPWR VPWR _02546_ sky130_fd_sc_hd__a21o_1
X_05837_ _01018_ _01749_ _01760_ _01782_ VGND VGND VPWR VPWR _01793_ sky130_fd_sc_hd__o211a_2
X_08625_ _02083_ _02084_ _02210_ _02211_ VGND VGND VPWR VPWR _02213_ sky130_fd_sc_hd__a2bb2o_1
X_08556_ _05551_ _02136_ _00558_ VGND VGND VPWR VPWR _02137_ sky130_fd_sc_hd__and3_1
XTAP_TAPCELL_ROW_53_924 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_92_601 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
X_05768_ net28 VGND VGND VPWR VPWR _01039_ sky130_fd_sc_hd__buf_4
X_07507_ _00526_ _00843_ _00837_ _00991_ VGND VGND VPWR VPWR _00992_ sky130_fd_sc_hd__nand4_2
XFILLER_0_92_623 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
X_08487_ _01185_ VGND VGND VPWR VPWR _02061_ sky130_fd_sc_hd__buf_4
XFILLER_0_77_697 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_76_163 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_49_388 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_0_107_427 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_91_122 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XTAP_TAPCELL_ROW_81_1278 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_64_347 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
X_07438_ _00373_ _00753_ _00913_ _00915_ VGND VGND VPWR VPWR _00916_ sky130_fd_sc_hd__and4_1
XTAP_TAPCELL_ROW_33_670 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_107_449 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XFILLER_0_92_689 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_91_166 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
X_07369_ _00838_ _00839_ _00836_ VGND VGND VPWR VPWR _00841_ sky130_fd_sc_hd__a21o_1
X_09108_ _02391_ _02567_ VGND VGND VPWR VPWR _02740_ sky130_fd_sc_hd__and2_1
XFILLER_0_60_531 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_115_493 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_10380_ _04084_ _04086_ _04126_ _04127_ VGND VGND VPWR VPWR _04128_ sky130_fd_sc_hd__and4bb_2
X_09039_ _02515_ _02522_ _02521_ VGND VGND VPWR VPWR _02664_ sky130_fd_sc_hd__a21bo_1
X_11001_ _04801_ VGND VGND VPWR VPWR _04803_ sky130_fd_sc_hd__inv_2
XFILLER_0_68_642 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XFILLER_0_23_15 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_83_612 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
X_10716_ _04403_ _04404_ VGND VGND VPWR VPWR _04493_ sky130_fd_sc_hd__and2b_1
XFILLER_0_99_19 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_83_645 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
X_10647_ _02838_ _03489_ _04417_ _04418_ VGND VGND VPWR VPWR _04419_ sky130_fd_sc_hd__a22oi_2
XFILLER_0_24_701 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_24_712 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XFILLER_0_3_617 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_23_222 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
X_10578_ _04341_ _04342_ _04234_ _04236_ VGND VGND VPWR VPWR _04344_ sky130_fd_sc_hd__a211o_1
XTAP_TAPCELL_ROW_11_397 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_23_244 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XFILLER_0_121_485 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XFILLER_0_48_89 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XTAP_TAPCELL_ROW_108_1613 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_3_69 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
X_06740_ _03376_ _03343_ _03015_ _04542_ VGND VGND VPWR VPWR _00167_ sky130_fd_sc_hd__and4_1
XFILLER_0_64_66 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
X_06671_ _05692_ _05697_ _05694_ VGND VGND VPWR VPWR _00099_ sky130_fd_sc_hd__a21bo_1
X_08410_ _01976_ VGND VGND VPWR VPWR _01977_ sky130_fd_sc_hd__buf_4
X_09390_ _02886_ _02888_ _03045_ _03046_ VGND VGND VPWR VPWR _03047_ sky130_fd_sc_hd__a211o_2
XFILLER_0_58_141 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_0_58_130 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XTAP_TAPCELL_ROW_19_497 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
X_08341_ _00750_ VGND VGND VPWR VPWR _01903_ sky130_fd_sc_hd__clkbuf_4
XFILLER_0_80_98 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_0_74_645 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
X_08272_ _01753_ _01754_ _01825_ _01827_ VGND VGND VPWR VPWR _01828_ sky130_fd_sc_hd__and4_2
XFILLER_0_116_235 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_13_81 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
X_07223_ _00676_ _00680_ _00681_ VGND VGND VPWR VPWR _00682_ sky130_fd_sc_hd__and3_1
XTAP_TAPCELL_ROW_30_640 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_119_1753 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_61_328 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XFILLER_0_6_477 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_42_531 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
X_07154_ _00603_ _00605_ VGND VGND VPWR VPWR _00606_ sky130_fd_sc_hd__xor2_1
XFILLER_0_73_3 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
X_06105_ _04705_ VGND VGND VPWR VPWR _04716_ sky130_fd_sc_hd__buf_4
XFILLER_0_14_299 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
X_07085_ _04063_ net35 _05342_ _03004_ VGND VGND VPWR VPWR _00531_ sky130_fd_sc_hd__a22o_1
XFILLER_0_42_575 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_42_586 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XFILLER_0_112_463 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
X_06036_ _03932_ _03943_ _03954_ VGND VGND VPWR VPWR _03965_ sky130_fd_sc_hd__and3_2
XFILLER_0_1_193 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_07987_ _01369_ _01370_ _01513_ _01514_ VGND VGND VPWR VPWR _01515_ sky130_fd_sc_hd__a211o_1
X_09726_ _03411_ _03412_ _03392_ VGND VGND VPWR VPWR _03414_ sky130_fd_sc_hd__a21oi_2
X_06938_ _00361_ _00369_ VGND VGND VPWR VPWR _00370_ sky130_fd_sc_hd__xnor2_1
XFILLER_0_97_715 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XTAP_TAPCELL_ROW_38_740 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
X_09657_ _03328_ _03338_ VGND VGND VPWR VPWR _03339_ sky130_fd_sc_hd__xnor2_1
XFILLER_0_69_428 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
X_06869_ _01007_ _00330_ _05695_ VGND VGND VPWR VPWR _00295_ sky130_fd_sc_hd__and3_1
X_09588_ _01249_ _02947_ _03260_ _03261_ VGND VGND VPWR VPWR _03263_ sky130_fd_sc_hd__nand4_2
X_08608_ _02191_ _02192_ _02182_ VGND VGND VPWR VPWR _02194_ sky130_fd_sc_hd__a21o_1
XFILLER_0_77_461 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_0_65_601 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
X_08539_ _02115_ _02116_ _02103_ VGND VGND VPWR VPWR _02118_ sky130_fd_sc_hd__a21o_1
XFILLER_0_49_174 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_92_453 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_65_645 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
X_10501_ _02866_ _04257_ _04258_ VGND VGND VPWR VPWR _04260_ sky130_fd_sc_hd__a21bo_1
XFILLER_0_92_475 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_80_615 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_107_279 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
X_10432_ _04057_ _04076_ VGND VGND VPWR VPWR _04185_ sky130_fd_sc_hd__nor2_2
XFILLER_0_103_441 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
X_10363_ _02325_ _02947_ _04106_ _04108_ VGND VGND VPWR VPWR _04110_ sky130_fd_sc_hd__nand4_4
XTAP_TAPCELL_ROW_94_1436 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
X_10294_ _04033_ _04034_ VGND VGND VPWR VPWR _04035_ sky130_fd_sc_hd__nor2_2
XFILLER_0_20_269 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_109_39 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_18_15 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_87_225 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XFILLER_0_34_47 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_34_58 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XTAP_TAPCELL_ROW_103_1554 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_68_472 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XTAP_TAPCELL_ROW_16_456 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_56_667 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_56_645 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XFILLER_0_7_208 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XTAP_TAPCELL_ROW_16_467 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_71_615 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_43_328 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_0_3_436 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_51_383 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_51_361 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_24_586 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XFILLER_0_59_44 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_11_236 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XTAP_TAPCELL_ROW_114_1683 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
X_08890_ _02498_ _02499_ _02500_ VGND VGND VPWR VPWR _02501_ sky130_fd_sc_hd__nand3_1
X_07910_ _01276_ _01279_ _01277_ VGND VGND VPWR VPWR _01432_ sky130_fd_sc_hd__o21ba_1
X_07841_ _01355_ VGND VGND VPWR VPWR _01357_ sky130_fd_sc_hd__clkbuf_8
XPHY_EDGE_ROW_3_Left_125 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
X_07772_ _01276_ _01281_ VGND VGND VPWR VPWR _01282_ sky130_fd_sc_hd__xnor2_2
X_09511_ _03583_ _03178_ _03174_ _03176_ VGND VGND VPWR VPWR _03180_ sky130_fd_sc_hd__nand4_1
X_06723_ net10 VGND VGND VPWR VPWR _00150_ sky130_fd_sc_hd__buf_4
X_09442_ _02945_ _02948_ VGND VGND VPWR VPWR _03104_ sky130_fd_sc_hd__nand2_1
XFILLER_0_66_409 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
X_06654_ _00075_ _00081_ VGND VGND VPWR VPWR _00082_ sky130_fd_sc_hd__xnor2_2
XFILLER_0_59_461 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
X_09373_ _04781_ _02529_ _01987_ _04802_ VGND VGND VPWR VPWR _03029_ sky130_fd_sc_hd__a22o_1
X_06585_ _05649_ _05610_ _00012_ _00013_ VGND VGND VPWR VPWR _00014_ sky130_fd_sc_hd__o211a_1
XFILLER_0_115_93 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_74_442 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_08324_ _01697_ _01868_ _01882_ _01883_ VGND VGND VPWR VPWR _01884_ sky130_fd_sc_hd__a211oi_2
XFILLER_0_19_325 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_24_91 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_46_133 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_47_645 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_117_544 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XFILLER_0_117_522 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XFILLER_0_19_358 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_105_717 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_0_61_125 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_0_6_230 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_15_520 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
X_08255_ _01806_ _01807_ _01803_ VGND VGND VPWR VPWR _01809_ sky130_fd_sc_hd__a21o_1
XFILLER_0_6_274 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
X_08186_ _01556_ _01564_ VGND VGND VPWR VPWR _01733_ sky130_fd_sc_hd__nand2_1
X_07206_ _05030_ _05310_ _00661_ _00662_ VGND VGND VPWR VPWR _00663_ sky130_fd_sc_hd__and4_2
XFILLER_0_120_709 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_104_249 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
X_07137_ _00517_ _00518_ _00586_ _00587_ VGND VGND VPWR VPWR _00588_ sky130_fd_sc_hd__nor4_1
XFILLER_0_100_400 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_30_545 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
X_07068_ _00498_ _00510_ _00511_ VGND VGND VPWR VPWR _00512_ sky130_fd_sc_hd__and3_1
XFILLER_0_30_567 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_30_589 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_100_477 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
X_06019_ _00832_ VGND VGND VPWR VPWR _03780_ sky130_fd_sc_hd__clkbuf_4
X_10981_ _04778_ _04779_ _04738_ VGND VGND VPWR VPWR _04782_ sky130_fd_sc_hd__a21oi_1
X_09709_ _03297_ _03393_ _03394_ VGND VGND VPWR VPWR _03395_ sky130_fd_sc_hd__a21bo_1
XFILLER_0_69_225 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_0_38_601 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_38_645 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XFILLER_0_108_522 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XPHY_EDGE_ROW_67_Left_189 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XTAP_TAPCELL_ROW_13_426 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_41_779 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_52_158 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_40_309 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
X_10415_ _04164_ _04165_ VGND VGND VPWR VPWR _04166_ sky130_fd_sc_hd__xor2_2
XFILLER_0_111_709 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_11395_ _05211_ _05209_ VGND VGND VPWR VPWR _05228_ sky130_fd_sc_hd__nor2_1
X_10346_ _04088_ _04089_ _01759_ net22 VGND VGND VPWR VPWR _04091_ sky130_fd_sc_hd__and4bb_1
X_10277_ _04013_ _04014_ _03995_ VGND VGND VPWR VPWR _04016_ sky130_fd_sc_hd__o21a_1
XPHY_EDGE_ROW_76_Left_198 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_0_45_13 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
Xmax_cap2 _03785_ VGND VGND VPWR VPWR net169 sky130_fd_sc_hd__clkbuf_1
XFILLER_0_88_512 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XTAP_TAPCELL_ROW_49_879 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_0_26 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XFILLER_0_28_111 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XFILLER_0_71_401 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_0_16_306 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
X_06370_ _00843_ _05425_ net38 _02447_ VGND VGND VPWR VPWR _05501_ sky130_fd_sc_hd__a22o_1
XFILLER_0_71_423 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_0_56_497 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_0_4_701 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
X_08040_ _01570_ _01571_ _01534_ _01535_ VGND VGND VPWR VPWR _01573_ sky130_fd_sc_hd__o211a_1
XFILLER_0_9_57 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XTAP_TAPCELL_ROW_116_1712 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_3_222 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XFILLER_0_101_73 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_0_24_383 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
X_09991_ _02320_ _00747_ _00748_ _01603_ VGND VGND VPWR VPWR _03704_ sky130_fd_sc_hd__a22o_1
XFILLER_0_12_589 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XFILLER_0_3_288 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
X_08942_ _02555_ _02558_ VGND VGND VPWR VPWR _02559_ sky130_fd_sc_hd__xnor2_2
X_08873_ _02467_ _02481_ _02482_ VGND VGND VPWR VPWR _02483_ sky130_fd_sc_hd__nand3_1
XFILLER_0_36_3 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
X_07824_ _01184_ _01188_ VGND VGND VPWR VPWR _01338_ sky130_fd_sc_hd__nor2_2
X_07755_ _01243_ _01244_ _01261_ VGND VGND VPWR VPWR _01263_ sky130_fd_sc_hd__nand3_2
X_07686_ net19 VGND VGND VPWR VPWR _01187_ sky130_fd_sc_hd__clkbuf_4
X_06706_ _00113_ VGND VGND VPWR VPWR _00133_ sky130_fd_sc_hd__inv_2
XFILLER_0_79_589 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_09425_ _02936_ _02958_ _02959_ VGND VGND VPWR VPWR _03085_ sky130_fd_sc_hd__or3_4
X_06637_ _00062_ _00063_ _00064_ VGND VGND VPWR VPWR _00065_ sky130_fd_sc_hd__nand3_1
X_09356_ _00798_ _02813_ VGND VGND VPWR VPWR _03010_ sky130_fd_sc_hd__nand2_1
XFILLER_0_19_144 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
X_06568_ _00548_ _05695_ _05696_ _00526_ VGND VGND VPWR VPWR _05697_ sky130_fd_sc_hd__a22o_1
X_09287_ _04716_ _02052_ VGND VGND VPWR VPWR _02935_ sky130_fd_sc_hd__nand2_2
X_06499_ _05622_ _05627_ VGND VGND VPWR VPWR _05628_ sky130_fd_sc_hd__nand2_1
X_08307_ _01684_ _01864_ VGND VGND VPWR VPWR _01865_ sky130_fd_sc_hd__nand2_2
XFILLER_0_47_486 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_7_572 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_0_34_158 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
X_08238_ _03080_ _00983_ _01787_ _01788_ VGND VGND VPWR VPWR _01790_ sky130_fd_sc_hd__a22o_1
XTAP_TAPCELL_ROW_78_1239 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_15_350 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_43_681 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
X_10200_ _05656_ _03172_ _03928_ _03929_ VGND VGND VPWR VPWR _03931_ sky130_fd_sc_hd__nand4_2
X_08169_ _01572_ _01573_ _01647_ _01648_ VGND VGND VPWR VPWR _01714_ sky130_fd_sc_hd__or4bb_2
X_11180_ _04995_ _04996_ VGND VGND VPWR VPWR _04997_ sky130_fd_sc_hd__nor2_2
X_10131_ _03853_ _03854_ _03814_ VGND VGND VPWR VPWR _03857_ sky130_fd_sc_hd__a21oi_1
XFILLER_0_100_241 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_10062_ _03778_ _03779_ _03743_ _03599_ VGND VGND VPWR VPWR _03782_ sky130_fd_sc_hd__a211o_1
XTAP_TAPCELL_ROW_89_1379 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_106_29 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_97_353 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_15_27 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XTAP_TAPCELL_ROW_46_838 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
X_10964_ _04651_ _04653_ _04761_ _04762_ VGND VGND VPWR VPWR _04763_ sky130_fd_sc_hd__a211o_1
XFILLER_0_58_718 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
X_10895_ _04685_ _04686_ _04678_ VGND VGND VPWR VPWR _04688_ sky130_fd_sc_hd__a21o_1
XFILLER_0_57_239 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XTAP_TAPCELL_ROW_100_1513 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_26_584 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_26_604 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_31_15 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_108_352 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XFILLER_0_93_592 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_53_434 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_53_401 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XFILLER_0_38_475 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_80_253 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
Xwire130 _02392_ VGND VGND VPWR VPWR net130 sky130_fd_sc_hd__buf_1
X_11447_ _05279_ VGND VGND VPWR VPWR _05282_ sky130_fd_sc_hd__inv_2
XFILLER_0_21_320 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_40_139 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
X_11378_ _05173_ VGND VGND VPWR VPWR _05210_ sky130_fd_sc_hd__inv_2
XFILLER_0_104_580 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XPHY_EDGE_ROW_84_Left_206 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_0_0_225 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_10329_ _04069_ _04070_ _04065_ _04066_ VGND VGND VPWR VPWR _04072_ sky130_fd_sc_hd__a211o_1
XTAP_TAPCELL_ROW_111_1653 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
X_05870_ _01596_ _01683_ _01585_ VGND VGND VPWR VPWR _02153_ sky130_fd_sc_hd__a21bo_1
X_07540_ _00889_ _01027_ VGND VGND VPWR VPWR _01028_ sky130_fd_sc_hd__xor2_4
XPHY_EDGE_ROW_93_Left_215 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
X_07471_ _00950_ _00951_ VGND VGND VPWR VPWR _00953_ sky130_fd_sc_hd__and2b_1
X_09210_ _04596_ _02850_ _02847_ _02848_ VGND VGND VPWR VPWR _02851_ sky130_fd_sc_hd__a22o_1
X_06422_ net5 VGND VGND VPWR VPWR _05552_ sky130_fd_sc_hd__buf_4
XFILLER_0_91_529 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
X_09141_ _00076_ _02064_ _02773_ _02774_ VGND VGND VPWR VPWR _02776_ sky130_fd_sc_hd__a22o_1
X_06353_ _04900_ _01782_ _04748_ _02251_ _05411_ VGND VGND VPWR VPWR _05484_ sky130_fd_sc_hd__a41o_1
XFILLER_0_71_242 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_0_71_220 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
X_09072_ _02697_ _02698_ _02689_ VGND VGND VPWR VPWR _02701_ sky130_fd_sc_hd__a21o_1
XFILLER_0_16_158 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_0_112_83 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_4_520 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
X_08023_ _01386_ _01394_ VGND VGND VPWR VPWR _01555_ sky130_fd_sc_hd__nand2_1
X_06284_ net64 VGND VGND VPWR VPWR _05416_ sky130_fd_sc_hd__clkbuf_4
XFILLER_0_40_684 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
X_09974_ _03543_ _03545_ _03544_ VGND VGND VPWR VPWR _03685_ sky130_fd_sc_hd__a21bo_1
XTAP_TAPCELL_ROW_73_1169 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
X_08925_ _02362_ _02367_ _02539_ VGND VGND VPWR VPWR _02540_ sky130_fd_sc_hd__a21oi_4
XFILLER_0_99_607 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_08856_ _02461_ _02462_ _02463_ VGND VGND VPWR VPWR _02464_ sky130_fd_sc_hd__and3_1
XFILLER_0_98_139 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
X_07807_ _01176_ _01319_ VGND VGND VPWR VPWR _01320_ sky130_fd_sc_hd__xor2_4
X_05999_ _03539_ _03529_ _03550_ VGND VGND VPWR VPWR _03561_ sky130_fd_sc_hd__nor3_1
X_08787_ _01865_ _02220_ _02218_ VGND VGND VPWR VPWR _02390_ sky130_fd_sc_hd__o21bai_4
X_07738_ _01097_ _01104_ VGND VGND VPWR VPWR _01244_ sky130_fd_sc_hd__nand2_1
XFILLER_0_67_559 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
X_07669_ _00905_ _01167_ _01168_ VGND VGND VPWR VPWR _01169_ sky130_fd_sc_hd__and3_1
X_10680_ _04452_ _04355_ _04453_ VGND VGND VPWR VPWR _04454_ sky130_fd_sc_hd__o21bai_2
XFILLER_0_109_105 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_0_94_356 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_09408_ _02745_ _02906_ _03066_ VGND VGND VPWR VPWR _03067_ sky130_fd_sc_hd__a21oi_2
X_09339_ _02988_ _02989_ _02985_ VGND VGND VPWR VPWR _02991_ sky130_fd_sc_hd__a21o_1
XFILLER_0_75_592 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XTAP_TAPCELL_ROW_23_554 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_35_401 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XPHY_EDGE_ROW_109_Right_109 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XTAP_TAPCELL_ROW_51_896 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_35_456 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XFILLER_0_62_264 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_7_391 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_120_303 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
X_11301_ _04883_ _05033_ _05125_ VGND VGND VPWR VPWR _05128_ sky130_fd_sc_hd__nand3_1
XFILLER_0_50_437 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_0_22_139 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_105_399 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
X_11232_ _04974_ _04972_ VGND VGND VPWR VPWR _05054_ sky130_fd_sc_hd__and2b_1
XFILLER_0_31_673 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
X_11163_ _04960_ _04978_ VGND VGND VPWR VPWR _04979_ sky130_fd_sc_hd__nand2_1
XFILLER_0_101_583 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_101_561 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_10114_ _02640_ _02641_ _02695_ _02161_ VGND VGND VPWR VPWR _03838_ sky130_fd_sc_hd__nand4_2
X_11094_ _03294_ _01673_ _04899_ _04902_ VGND VGND VPWR VPWR _04904_ sky130_fd_sc_hd__and4_1
X_10045_ _01588_ _02060_ _02061_ _00556_ VGND VGND VPWR VPWR _03763_ sky130_fd_sc_hd__a22o_1
XFILLER_0_26_15 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_117_39 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XTAP_TAPCELL_ROW_59_996 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
X_10947_ _04742_ _04743_ VGND VGND VPWR VPWR _04744_ sky130_fd_sc_hd__xnor2_1
XFILLER_0_58_559 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
X_10878_ _04667_ _04668_ VGND VGND VPWR VPWR _04669_ sky130_fd_sc_hd__xnor2_1
XFILLER_0_26_401 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_26_412 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_108_171 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XANTENNA_2 _00346_ VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_0_1_501 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_0_1_534 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_21_183 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
X_06971_ _00292_ _00313_ _00314_ VGND VGND VPWR VPWR _00407_ sky130_fd_sc_hd__nand3_2
X_09690_ _03083_ _03219_ _03374_ VGND VGND VPWR VPWR _03375_ sky130_fd_sc_hd__o21ai_4
X_08710_ _02301_ _02303_ _02298_ VGND VGND VPWR VPWR _02305_ sky130_fd_sc_hd__a21o_1
X_05922_ net29 VGND VGND VPWR VPWR _02721_ sky130_fd_sc_hd__buf_4
X_08641_ _02228_ VGND VGND VPWR VPWR _02230_ sky130_fd_sc_hd__buf_4
X_05853_ _00537_ _01508_ net62 net1 VGND VGND VPWR VPWR _01967_ sky130_fd_sc_hd__a22o_1
XFILLER_0_89_673 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
X_05784_ _00439_ _01192_ _01203_ _00712_ VGND VGND VPWR VPWR _01214_ sky130_fd_sc_hd__a22oi_1
X_08572_ _02132_ _02152_ _02154_ VGND VGND VPWR VPWR _02155_ sky130_fd_sc_hd__nand3_1
XFILLER_0_76_323 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_49_526 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
X_07523_ _00968_ _00969_ _01008_ _01009_ VGND VGND VPWR VPWR _01010_ sky130_fd_sc_hd__and4bb_1
X_07454_ _03736_ _00143_ _00931_ _00932_ VGND VGND VPWR VPWR _00934_ sky130_fd_sc_hd__a22o_1
XFILLER_0_36_209 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_91_337 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_0_91_315 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_57_581 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XFILLER_0_8_133 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_0_17_401 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
X_06405_ _05376_ _05454_ _05535_ VGND VGND VPWR VPWR _05536_ sky130_fd_sc_hd__a21o_2
X_07385_ _00856_ _00857_ _00711_ net157 VGND VGND VPWR VPWR _00859_ sky130_fd_sc_hd__a211o_1
XTAP_TAPCELL_ROW_20_513 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
X_09124_ _01850_ _02755_ _02756_ VGND VGND VPWR VPWR _02757_ sky130_fd_sc_hd__a21bo_1
XFILLER_0_60_713 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
X_06336_ net6 VGND VGND VPWR VPWR _05467_ sky130_fd_sc_hd__clkbuf_8
X_09055_ _02679_ _02680_ _02671_ VGND VGND VPWR VPWR _02682_ sky130_fd_sc_hd__a21o_1
X_06267_ _05397_ _05398_ VGND VGND VPWR VPWR _05399_ sky130_fd_sc_hd__xnor2_1
XFILLER_0_115_697 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
X_08006_ _01406_ _01407_ _01426_ _01427_ VGND VGND VPWR VPWR _01536_ sky130_fd_sc_hd__o211ai_4
XFILLER_0_4_394 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XFILLER_0_102_369 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_13_673 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
X_06198_ _05328_ _05329_ _03605_ _03091_ VGND VGND VPWR VPWR _05331_ sky130_fd_sc_hd__and4bb_1
XFILLER_0_110_380 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
X_09957_ _03524_ _03526_ VGND VGND VPWR VPWR _03667_ sky130_fd_sc_hd__or2_1
X_08908_ _02358_ _02359_ _02519_ _02520_ VGND VGND VPWR VPWR _02521_ sky130_fd_sc_hd__o211ai_2
X_09888_ _03439_ _03448_ _03447_ VGND VGND VPWR VPWR _03591_ sky130_fd_sc_hd__a21bo_1
X_08839_ _02443_ _02444_ VGND VGND VPWR VPWR _02445_ sky130_fd_sc_hd__xnor2_2
XTAP_TAPCELL_ROW_28_613 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_86_1338 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_56_966 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
X_10801_ _04583_ _04584_ VGND VGND VPWR VPWR _04586_ sky130_fd_sc_hd__xnor2_1
XFILLER_0_79_194 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_79_183 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XTAP_TAPCELL_ROW_0_260 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
X_10732_ _04507_ _04508_ _04500_ VGND VGND VPWR VPWR _04511_ sky130_fd_sc_hd__a21o_1
XFILLER_0_95_654 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_67_389 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
X_10663_ _04328_ _04330_ _04434_ _04435_ VGND VGND VPWR VPWR _04436_ sky130_fd_sc_hd__o211ai_4
XFILLER_0_82_359 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_0_82_348 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
X_10594_ _04332_ VGND VGND VPWR VPWR _04361_ sky130_fd_sc_hd__inv_2
XFILLER_0_63_595 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_0_50_223 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XTAP_TAPCELL_ROW_97_1478 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_121_645 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_50_278 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_10_109 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_11215_ _05032_ _05034_ VGND VGND VPWR VPWR _05035_ sky130_fd_sc_hd__xnor2_1
Xoutput83 net83 VGND VGND VPWR VPWR product[26] sky130_fd_sc_hd__clkbuf_4
XFILLER_0_101_391 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_101_380 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
X_11146_ _04893_ _04959_ VGND VGND VPWR VPWR _04960_ sky130_fd_sc_hd__xnor2_1
Xoutput94 net94 VGND VGND VPWR VPWR product[36] sky130_fd_sc_hd__buf_2
XTAP_TAPCELL_ROW_8_360 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
Xoutput72 net72 VGND VGND VPWR VPWR product[16] sky130_fd_sc_hd__buf_2
X_11077_ _04882_ _04884_ VGND VGND VPWR VPWR _04885_ sky130_fd_sc_hd__xnor2_1
X_10028_ _00087_ _01353_ _03238_ _00187_ VGND VGND VPWR VPWR _03744_ sky130_fd_sc_hd__a22oi_1
XFILLER_0_53_68 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_0_53_57 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XTAP_TAPCELL_ROW_106_1585 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_58_389 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_0_39_581 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XFILLER_0_5_125 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
X_07170_ net13 VGND VGND VPWR VPWR _00623_ sky130_fd_sc_hd__buf_4
X_06121_ _04878_ VGND VGND VPWR VPWR _04889_ sky130_fd_sc_hd__buf_4
XFILLER_0_5_169 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_14_415 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_0_26_286 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_111_111 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
X_06052_ _04009_ _04020_ _04129_ VGND VGND VPWR VPWR _04140_ sky130_fd_sc_hd__or3_2
XFILLER_0_112_645 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_10_643 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
X_09811_ _03483_ _03505_ _03506_ VGND VGND VPWR VPWR _03508_ sky130_fd_sc_hd__nor3_2
X_09742_ _01604_ _00488_ _03429_ _03431_ VGND VGND VPWR VPWR _03432_ sky130_fd_sc_hd__a22o_1
XTAP_TAPCELL_ROW_70_1139 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
X_06954_ _03376_ _05318_ _00387_ _03288_ VGND VGND VPWR VPWR _00388_ sky130_fd_sc_hd__a22o_1
X_09673_ _03353_ _03355_ _03339_ VGND VGND VPWR VPWR _03357_ sky130_fd_sc_hd__a21oi_1
X_06885_ _00310_ _00311_ _00312_ VGND VGND VPWR VPWR _00313_ sky130_fd_sc_hd__nand3_4
X_05905_ _02491_ _02502_ _02524_ VGND VGND VPWR VPWR _02535_ sky130_fd_sc_hd__nand3_1
XFILLER_0_96_418 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
X_08624_ _02083_ _02084_ _02210_ _02211_ VGND VGND VPWR VPWR _02212_ sky130_fd_sc_hd__or4bb_1
X_05836_ _01771_ VGND VGND VPWR VPWR _01782_ sky130_fd_sc_hd__buf_4
XFILLER_0_89_470 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_0_77_610 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
X_08555_ _00387_ VGND VGND VPWR VPWR _02136_ sky130_fd_sc_hd__clkbuf_4
X_05767_ _00996_ _01018_ VGND VGND VPWR VPWR _01029_ sky130_fd_sc_hd__nor2_1
XTAP_TAPCELL_ROW_53_925 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_77_654 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
X_07506_ net49 VGND VGND VPWR VPWR _00991_ sky130_fd_sc_hd__clkbuf_4
XFILLER_0_119_222 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
X_08486_ net17 VGND VGND VPWR VPWR _02060_ sky130_fd_sc_hd__clkbuf_4
XFILLER_0_64_304 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_0_37_518 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XTAP_TAPCELL_ROW_81_1279 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_76_197 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
X_07437_ _00504_ _00747_ _00914_ _00461_ VGND VGND VPWR VPWR _00915_ sky130_fd_sc_hd__a22o_1
XFILLER_0_64_359 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XTAP_TAPCELL_ROW_33_671 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_91_178 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_17_242 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
X_07368_ _00836_ _00838_ _00839_ VGND VGND VPWR VPWR _00840_ sky130_fd_sc_hd__nand3_1
XFILLER_0_33_702 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
X_09107_ _02402_ _02564_ _02389_ _02390_ VGND VGND VPWR VPWR _02739_ sky130_fd_sc_hd__a2bb2o_1
X_06319_ _05367_ _05368_ VGND VGND VPWR VPWR _05451_ sky130_fd_sc_hd__nand2_1
XFILLER_0_102_100 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
X_07299_ _00515_ _00762_ _00763_ _00760_ VGND VGND VPWR VPWR _00764_ sky130_fd_sc_hd__a22oi_1
XFILLER_0_103_645 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_60_587 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
X_09038_ _02505_ _02507_ VGND VGND VPWR VPWR _02663_ sky130_fd_sc_hd__nand2_1
X_11000_ _00614_ _02862_ _02865_ _01898_ VGND VGND VPWR VPWR _04801_ sky130_fd_sc_hd__a22o_1
XTAP_TAPCELL_ROW_5_330 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_114_29 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_23_27 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_68_698 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
X_10715_ _04490_ _04491_ VGND VGND VPWR VPWR _04492_ sky130_fd_sc_hd__xnor2_1
XFILLER_0_83_657 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
X_10646_ _02667_ _02163_ _02943_ _02944_ VGND VGND VPWR VPWR _04418_ sky130_fd_sc_hd__nand4_1
XFILLER_0_70_307 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_63_381 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
X_10577_ _04234_ _04236_ _04341_ _04342_ VGND VGND VPWR VPWR _04343_ sky130_fd_sc_hd__o211ai_4
XTAP_TAPCELL_ROW_11_398 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_3_629 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_2_139 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_23_278 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XFILLER_0_48_57 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_0_48_79 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
X_11129_ _04920_ _04918_ VGND VGND VPWR VPWR _04941_ sky130_fd_sc_hd__and2b_1
XFILLER_0_3_15 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XTAP_TAPCELL_ROW_108_1614 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
X_06670_ _00095_ _00096_ _00093_ VGND VGND VPWR VPWR _00098_ sky130_fd_sc_hd__a21o_1
XFILLER_0_59_610 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_0_86_440 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XTAP_TAPCELL_ROW_19_498 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_80_44 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
X_08340_ _01898_ _01899_ _01900_ VGND VGND VPWR VPWR _01901_ sky130_fd_sc_hd__a21bo_1
XFILLER_0_80_88 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_0_58_197 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
X_08271_ _01823_ _01824_ _01643_ net153 VGND VGND VPWR VPWR _01827_ sky130_fd_sc_hd__a211o_1
XFILLER_0_73_167 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_27_540 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
X_07222_ _03080_ _00086_ _00677_ _00678_ VGND VGND VPWR VPWR _00681_ sky130_fd_sc_hd__a22o_1
XFILLER_0_116_247 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_0_104_409 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
X_07153_ _01356_ _00496_ _00492_ _00604_ VGND VGND VPWR VPWR _00605_ sky130_fd_sc_hd__a31oi_4
XFILLER_0_27_584 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_27_595 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XTAP_TAPCELL_ROW_30_641 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_119_1754 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_6_489 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_42_554 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
X_06104_ _00810_ VGND VGND VPWR VPWR _04705_ sky130_fd_sc_hd__buf_4
XFILLER_0_120_83 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
X_07084_ _03004_ net2 net35 net36 VGND VGND VPWR VPWR _00530_ sky130_fd_sc_hd__and4_1
XFILLER_0_1_161 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
X_06035_ _03277_ _03441_ _03430_ VGND VGND VPWR VPWR _03954_ sky130_fd_sc_hd__a21bo_1
XFILLER_0_10_440 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_0_10_473 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
X_07986_ _01511_ _01512_ _00690_ net19 VGND VGND VPWR VPWR _01514_ sky130_fd_sc_hd__and4bb_1
X_09725_ _03392_ _03411_ _03412_ VGND VGND VPWR VPWR _03413_ sky130_fd_sc_hd__and3_2
X_06937_ _00367_ _00368_ VGND VGND VPWR VPWR _00369_ sky130_fd_sc_hd__and2_1
X_09656_ _03336_ _03337_ VGND VGND VPWR VPWR _03338_ sky130_fd_sc_hd__or2b_1
XFILLER_0_69_418 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
X_06868_ _05696_ VGND VGND VPWR VPWR _00294_ sky130_fd_sc_hd__clkbuf_4
XTAP_TAPCELL_ROW_38_741 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
X_08607_ _02182_ _02191_ _02192_ VGND VGND VPWR VPWR _02193_ sky130_fd_sc_hd__nand3_1
X_09587_ _01249_ _02941_ _03260_ _03261_ VGND VGND VPWR VPWR _03262_ sky130_fd_sc_hd__a22o_1
X_05819_ _01541_ _01563_ _01574_ VGND VGND VPWR VPWR _01596_ sky130_fd_sc_hd__a21o_1
X_06799_ _00124_ _00122_ _00121_ VGND VGND VPWR VPWR _00226_ sky130_fd_sc_hd__a21oi_1
XFILLER_0_64_101 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_08538_ _02103_ _02115_ _02116_ VGND VGND VPWR VPWR _02117_ sky130_fd_sc_hd__nand3_1
X_08469_ net22 VGND VGND VPWR VPWR _02041_ sky130_fd_sc_hd__clkbuf_4
XFILLER_0_107_225 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
X_10500_ _05637_ _02862_ _02865_ _05541_ VGND VGND VPWR VPWR _04258_ sky130_fd_sc_hd__a22o_1
XFILLER_0_92_498 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_45_381 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
X_10431_ _04166_ _04182_ VGND VGND VPWR VPWR _04184_ sky130_fd_sc_hd__xor2_2
X_10362_ _02105_ _02941_ _04106_ _04108_ VGND VGND VPWR VPWR _04109_ sky130_fd_sc_hd__a22o_1
XTAP_TAPCELL_ROW_94_1437 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_60_373 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
X_10293_ _03908_ _03913_ _04030_ _04032_ VGND VGND VPWR VPWR _04034_ sky130_fd_sc_hd__a211oi_2
XFILLER_0_18_27 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XPHY_EDGE_ROW_16_Right_16 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_0_34_15 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XTAP_TAPCELL_ROW_103_1544 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_68_451 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_0_55_101 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XTAP_TAPCELL_ROW_16_457 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_103_1555 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_95_281 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_0_56_657 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XTAP_TAPCELL_ROW_16_468 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
X_10629_ _00987_ _01610_ _03237_ _01675_ VGND VGND VPWR VPWR _04399_ sky130_fd_sc_hd__and4_1
XPHY_EDGE_ROW_25_Right_25 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_0_113_239 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_0_51_373 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_0_121_261 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XTAP_TAPCELL_ROW_114_1684 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
X_07840_ _01354_ VGND VGND VPWR VPWR _01355_ sky130_fd_sc_hd__clkbuf_4
X_07771_ _01277_ _01279_ VGND VGND VPWR VPWR _01281_ sky130_fd_sc_hd__nor2_1
X_09510_ _03172_ VGND VGND VPWR VPWR _03178_ sky130_fd_sc_hd__buf_4
XTAP_TAPCELL_ROW_69_1130 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
X_06722_ _00147_ _00148_ VGND VGND VPWR VPWR _00149_ sky130_fd_sc_hd__xor2_2
XPHY_EDGE_ROW_34_Right_34 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_0_91_21 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_78_204 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_78_237 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
X_09441_ _02970_ _02979_ _02978_ VGND VGND VPWR VPWR _03103_ sky130_fd_sc_hd__a21o_1
XTAP_TAPCELL_ROW_35_700 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
X_06653_ _00077_ _00080_ VGND VGND VPWR VPWR _00081_ sky130_fd_sc_hd__xnor2_2
XFILLER_0_91_98 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
X_09372_ _02875_ _02877_ VGND VGND VPWR VPWR _03028_ sky130_fd_sc_hd__nand2_1
X_06584_ _05671_ _05672_ _00010_ _00011_ VGND VGND VPWR VPWR _00013_ sky130_fd_sc_hd__a2bb2o_1
XFILLER_0_86_281 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_74_421 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_0_59_495 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_08323_ _01879_ _01881_ _01870_ VGND VGND VPWR VPWR _01883_ sky130_fd_sc_hd__a21boi_2
XFILLER_0_47_657 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_0_6_253 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
X_08254_ _01803_ _01806_ _01807_ VGND VGND VPWR VPWR _01808_ sky130_fd_sc_hd__nand3_1
XPHY_EDGE_ROW_43_Right_43 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XPHY_EDGE_ROW_104_Left_226 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
X_08185_ _01721_ _01731_ VGND VGND VPWR VPWR _01732_ sky130_fd_sc_hd__xor2_2
XFILLER_0_6_286 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_15_532 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
X_07205_ _04063_ _05342_ net37 _03004_ VGND VGND VPWR VPWR _00662_ sky130_fd_sc_hd__a22o_1
X_07136_ _00584_ _00585_ _00446_ _00519_ VGND VGND VPWR VPWR _00587_ sky130_fd_sc_hd__a211oi_1
XFILLER_0_30_513 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
X_07067_ _00367_ _00499_ _00509_ VGND VGND VPWR VPWR _00511_ sky130_fd_sc_hd__nand3_1
XFILLER_0_100_412 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_2_481 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_30_579 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_06018_ _03736_ _03747_ _03758_ VGND VGND VPWR VPWR _03769_ sky130_fd_sc_hd__a21bo_1
XFILLER_0_10_270 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XPHY_EDGE_ROW_113_Left_235 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XPHY_EDGE_ROW_52_Right_52 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
X_09708_ _02136_ _02173_ _01980_ _05551_ VGND VGND VPWR VPWR _03394_ sky130_fd_sc_hd__a22o_1
X_07969_ _01361_ _01362_ _01473_ _01474_ VGND VGND VPWR VPWR _01495_ sky130_fd_sc_hd__nor4_1
X_10980_ _04738_ _04778_ _04779_ VGND VGND VPWR VPWR _04780_ sky130_fd_sc_hd__and3_1
XFILLER_0_69_204 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
X_09639_ _03145_ _03159_ _03160_ VGND VGND VPWR VPWR _03319_ sky130_fd_sc_hd__and3_1
XFILLER_0_69_248 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_84_207 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XFILLER_0_38_613 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_92_251 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_65_443 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XPHY_EDGE_ROW_61_Right_61 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_0_53_605 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XTAP_TAPCELL_ROW_13_427 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_92_273 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_80_413 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_53_627 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XTAP_TAPCELL_ROW_41_769 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
X_11463_ _05293_ VGND VGND VPWR VPWR net109 sky130_fd_sc_hd__clkbuf_1
XFILLER_0_108_589 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_18_381 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_0_33_340 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
X_10414_ _04051_ _04054_ VGND VGND VPWR VPWR _04165_ sky130_fd_sc_hd__nand2_2
XFILLER_0_61_671 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
X_11394_ _05190_ _05224_ _05226_ _05220_ VGND VGND VPWR VPWR _05227_ sky130_fd_sc_hd__o211a_1
XFILLER_0_60_192 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_0_60_181 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
X_10345_ _01759_ _01680_ _04088_ _04089_ VGND VGND VPWR VPWR _04090_ sky130_fd_sc_hd__o2bb2a_1
XFILLER_0_21_568 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
X_10276_ _03995_ _04013_ _04014_ VGND VGND VPWR VPWR _04015_ sky130_fd_sc_hd__nor3_1
XPHY_EDGE_ROW_70_Right_70 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_0_45_25 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XTAP_TAPCELL_ROW_49_869 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
Xmax_cap3 net171 VGND VGND VPWR VPWR net170 sky130_fd_sc_hd__clkbuf_1
XFILLER_0_76_719 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_29_602 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_0_118_309 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XTAP_TAPCELL_ROW_64_1060 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_61_57 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_56_421 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_0_9_69 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_4_713 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_0_3_201 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XTAP_TAPCELL_ROW_116_1713 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_114_548 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_12_502 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_0_3_245 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
X_09990_ _01603_ _02320_ _00748_ VGND VGND VPWR VPWR _03702_ sky130_fd_sc_hd__and3_1
XFILLER_0_10_83 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
X_08941_ _02276_ _02380_ _02556_ VGND VGND VPWR VPWR _02558_ sky130_fd_sc_hd__o21a_2
X_08872_ _02477_ _02478_ _02479_ VGND VGND VPWR VPWR _02482_ sky130_fd_sc_hd__a21o_1
X_07823_ _01210_ _01218_ _01336_ VGND VGND VPWR VPWR _01337_ sky130_fd_sc_hd__a21oi_4
X_07754_ _01243_ _01244_ _01261_ VGND VGND VPWR VPWR _01262_ sky130_fd_sc_hd__a21o_2
X_07685_ _00450_ _00893_ _01185_ _00351_ VGND VGND VPWR VPWR _01186_ sky130_fd_sc_hd__a22oi_1
X_06705_ _05643_ _00052_ VGND VGND VPWR VPWR _00132_ sky130_fd_sc_hd__nor2_1
X_09424_ _02958_ VGND VGND VPWR VPWR _03084_ sky130_fd_sc_hd__inv_2
X_06636_ _05660_ _05662_ _05661_ VGND VGND VPWR VPWR _00064_ sky130_fd_sc_hd__a21bo_1
XFILLER_0_59_281 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_74_240 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_09355_ _03006_ _03007_ _03008_ VGND VGND VPWR VPWR _03009_ sky130_fd_sc_hd__a21bo_1
XFILLER_0_19_156 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
X_06567_ net40 VGND VGND VPWR VPWR _05696_ sky130_fd_sc_hd__clkbuf_4
X_09286_ _02932_ _02933_ VGND VGND VPWR VPWR _02934_ sky130_fd_sc_hd__nor2_2
X_08306_ _01862_ _01863_ VGND VGND VPWR VPWR _01864_ sky130_fd_sc_hd__and2_2
X_06498_ _05533_ _05536_ _05624_ _05532_ VGND VGND VPWR VPWR _05627_ sky130_fd_sc_hd__a211o_1
XFILLER_0_34_104 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_0_47_498 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_0_62_468 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_62_446 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_0_28_690 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_08237_ _02764_ _00983_ _01787_ _01788_ VGND VGND VPWR VPWR _01789_ sky130_fd_sc_hd__nand4_2
XFILLER_0_105_548 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_120_507 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
X_08168_ _01710_ _01711_ _01669_ VGND VGND VPWR VPWR _01713_ sky130_fd_sc_hd__o21a_1
X_07119_ _00564_ _00566_ _00567_ VGND VGND VPWR VPWR _00568_ sky130_fd_sc_hd__nand3_1
X_08099_ _01635_ _01636_ _01637_ VGND VGND VPWR VPWR _01638_ sky130_fd_sc_hd__nand3_4
XFILLER_0_30_365 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_10130_ _03814_ _03853_ _03854_ VGND VGND VPWR VPWR _03855_ sky130_fd_sc_hd__and3_2
X_10061_ _03743_ _03599_ _03778_ _03779_ VGND VGND VPWR VPWR _03781_ sky130_fd_sc_hd__o211ai_1
XFILLER_0_100_253 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XTAP_TAPCELL_ROW_89_1369 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
X_10963_ _03341_ _02064_ _04758_ _04760_ VGND VGND VPWR VPWR _04762_ sky130_fd_sc_hd__and4_1
XFILLER_0_15_39 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XTAP_TAPCELL_ROW_46_839 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_85_505 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_10894_ _04678_ _04685_ _04686_ VGND VGND VPWR VPWR _04687_ sky130_fd_sc_hd__nand3_1
XFILLER_0_38_421 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XTAP_TAPCELL_ROW_100_1514 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_26_585 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_38_443 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_0_26_616 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_31_27 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_53_457 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XFILLER_0_53_446 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XFILLER_0_41_608 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
X_11446_ _05275_ _05278_ _05274_ VGND VGND VPWR VPWR _05281_ sky130_fd_sc_hd__a21bo_1
XFILLER_0_33_181 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
X_11377_ _05207_ _05208_ VGND VGND VPWR VPWR _05209_ sky130_fd_sc_hd__xnor2_2
XFILLER_0_21_332 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_0_21_365 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
X_10328_ _04065_ _04066_ _04069_ _04070_ VGND VGND VPWR VPWR _04071_ sky130_fd_sc_hd__o211a_1
XTAP_TAPCELL_ROW_111_1654 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
X_10259_ _03876_ _03886_ _03887_ VGND VGND VPWR VPWR _03996_ sky130_fd_sc_hd__nand3_1
XFILLER_0_72_56 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_119_607 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_07470_ _05343_ _05550_ _05552_ _05341_ VGND VGND VPWR VPWR _00951_ sky130_fd_sc_hd__a22o_1
X_06421_ _05550_ VGND VGND VPWR VPWR _05551_ sky130_fd_sc_hd__buf_4
XFILLER_0_8_326 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_118_139 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
X_09140_ _05589_ _05689_ _00894_ _02061_ VGND VGND VPWR VPWR _02774_ sky130_fd_sc_hd__nand4_2
XFILLER_0_8_359 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_0_16_104 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
X_06352_ _05480_ _05481_ _05459_ VGND VGND VPWR VPWR _05483_ sky130_fd_sc_hd__o21a_1
XFILLER_0_44_402 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
X_09071_ _02689_ _02697_ _02698_ VGND VGND VPWR VPWR _02700_ sky130_fd_sc_hd__nand3_1
X_06283_ _01007_ _03201_ net34 net64 VGND VGND VPWR VPWR _05415_ sky130_fd_sc_hd__and4_1
XFILLER_0_44_435 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_114_334 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
X_08022_ _01387_ _01393_ VGND VGND VPWR VPWR _01554_ sky130_fd_sc_hd__nand2_1
XFILLER_0_32_608 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_0_12_321 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
X_09973_ _03682_ _03683_ VGND VGND VPWR VPWR _03684_ sky130_fd_sc_hd__nor2_1
XFILLER_0_97_86 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_08924_ _02365_ _02366_ VGND VGND VPWR VPWR _02539_ sky130_fd_sc_hd__and2b_1
X_08855_ _02287_ _02289_ _02288_ VGND VGND VPWR VPWR _02463_ sky130_fd_sc_hd__a21bo_1
XFILLER_0_98_107 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_79_310 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_08786_ _02231_ _02388_ VGND VGND VPWR VPWR _02389_ sky130_fd_sc_hd__xor2_2
X_07806_ _01177_ _01318_ VGND VGND VPWR VPWR _01319_ sky130_fd_sc_hd__xnor2_4
XPHY_EDGE_ROW_2_Right_2 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
X_07737_ _01098_ _01101_ _01102_ VGND VGND VPWR VPWR _01243_ sky130_fd_sc_hd__or3_2
X_05998_ net165 _03518_ _03059_ _02819_ VGND VGND VPWR VPWR _03550_ sky130_fd_sc_hd__o211a_1
XFILLER_0_1_81 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
X_07668_ _01165_ _01166_ _01016_ _01033_ VGND VGND VPWR VPWR _01168_ sky130_fd_sc_hd__o211ai_2
XFILLER_0_39_229 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
X_09407_ _02903_ _02905_ VGND VGND VPWR VPWR _03066_ sky130_fd_sc_hd__nor2_1
X_06619_ _05653_ _00044_ _00040_ _00043_ VGND VGND VPWR VPWR _00047_ sky130_fd_sc_hd__a211oi_2
X_07599_ _01089_ _01090_ _00966_ _00968_ VGND VGND VPWR VPWR _01092_ sky130_fd_sc_hd__a211oi_1
X_09338_ _02985_ _02988_ _02989_ VGND VGND VPWR VPWR _02990_ sky130_fd_sc_hd__nand3_1
XTAP_TAPCELL_ROW_23_544 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_23_555 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_117_150 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XTAP_TAPCELL_ROW_51_897 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_117_194 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
X_11300_ _04883_ _05033_ _05125_ VGND VGND VPWR VPWR _05126_ sky130_fd_sc_hd__a21o_1
X_09269_ _02913_ _02914_ VGND VGND VPWR VPWR _02915_ sky130_fd_sc_hd__or2_2
XFILLER_0_50_416 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_43_490 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
X_11231_ _05050_ _05051_ VGND VGND VPWR VPWR _05053_ sky130_fd_sc_hd__nor2_1
XFILLER_0_120_359 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
X_11162_ _04975_ _04977_ VGND VGND VPWR VPWR _04978_ sky130_fd_sc_hd__xor2_1
X_10113_ _02641_ _02345_ _01980_ _02640_ VGND VGND VPWR VPWR _03837_ sky130_fd_sc_hd__a22o_1
XFILLER_0_101_595 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
X_11093_ _03294_ _01673_ _04899_ _04902_ VGND VGND VPWR VPWR _04903_ sky130_fd_sc_hd__a22oi_1
X_10044_ _03628_ _03630_ VGND VGND VPWR VPWR _03762_ sky130_fd_sc_hd__nand2_1
XFILLER_0_26_27 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XTAP_TAPCELL_ROW_59_997 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
X_10946_ _02813_ _01856_ VGND VGND VPWR VPWR _04743_ sky130_fd_sc_hd__nand2_1
XFILLER_0_85_313 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_58_549 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_0_42_15 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
X_10877_ _03574_ _03247_ VGND VGND VPWR VPWR _04668_ sky130_fd_sc_hd__nand2_1
XFILLER_0_66_582 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XTAP_TAPCELL_ROW_61_1030 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_38_251 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_109_673 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_53_210 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_26_435 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_38_284 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_0_41_405 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XANTENNA_3 _00408_ VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_0_13_129 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_41_427 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_0_111_304 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
X_11429_ _05241_ _05263_ VGND VGND VPWR VPWR _05264_ sky130_fd_sc_hd__xor2_1
XFILLER_0_6_15 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_34_490 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_111_337 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_0_67_23 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_0_1_546 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_21_195 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
X_06970_ _00402_ _00403_ _00381_ _00382_ VGND VGND VPWR VPWR _00405_ sky130_fd_sc_hd__a211oi_2
X_05921_ net55 net44 _02699_ _02208_ VGND VGND VPWR VPWR _02710_ sky130_fd_sc_hd__and4_1
X_08640_ _02227_ VGND VGND VPWR VPWR _02228_ sky130_fd_sc_hd__buf_4
X_05852_ net1 net12 net61 net62 VGND VGND VPWR VPWR _01956_ sky130_fd_sc_hd__and4_1
XFILLER_0_89_685 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_83_88 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
X_05783_ _00701_ VGND VGND VPWR VPWR _01203_ sky130_fd_sc_hd__inv_2
X_08571_ _02150_ _02151_ _02133_ VGND VGND VPWR VPWR _02154_ sky130_fd_sc_hd__a21o_1
XFILLER_0_49_505 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_88_195 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
X_07522_ net173 _01006_ _00849_ _00970_ VGND VGND VPWR VPWR _01009_ sky130_fd_sc_hd__o211ai_4
XFILLER_0_119_415 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
X_07453_ _04737_ _00041_ _00931_ _00932_ VGND VGND VPWR VPWR _00933_ sky130_fd_sc_hd__nand4_2
XFILLER_0_17_413 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
X_06404_ _05453_ _05377_ VGND VGND VPWR VPWR _05535_ sky130_fd_sc_hd__and2b_1
X_09123_ _05676_ _01674_ _01675_ _05659_ VGND VGND VPWR VPWR _02756_ sky130_fd_sc_hd__a22o_1
X_07384_ _00711_ net158 _00856_ _00857_ VGND VGND VPWR VPWR _00858_ sky130_fd_sc_hd__o211ai_4
XTAP_TAPCELL_ROW_20_514 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_44_210 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_96_3 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
X_06335_ _05462_ _05465_ VGND VGND VPWR VPWR _05466_ sky130_fd_sc_hd__nor2_1
X_09054_ _02671_ _02679_ _02680_ VGND VGND VPWR VPWR _02681_ sky130_fd_sc_hd__nand3_1
X_06266_ _05306_ _05312_ VGND VGND VPWR VPWR _05398_ sky130_fd_sc_hd__nor2_1
XFILLER_0_32_427 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
X_08005_ _01385_ _01396_ _01397_ VGND VGND VPWR VPWR _01535_ sky130_fd_sc_hd__or3_2
XFILLER_0_13_685 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_40_471 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
X_06197_ _03255_ _03091_ _05328_ _05329_ VGND VGND VPWR VPWR _05330_ sky130_fd_sc_hd__o2bb2a_1
XFILLER_0_110_392 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
X_09956_ _03069_ _03073_ _03664_ VGND VGND VPWR VPWR _03666_ sky130_fd_sc_hd__a21o_1
X_09887_ _03587_ _03588_ _03580_ VGND VGND VPWR VPWR _03590_ sky130_fd_sc_hd__a21o_1
X_08907_ _05410_ _01976_ _02517_ _02518_ VGND VGND VPWR VPWR _02520_ sky130_fd_sc_hd__a22o_1
X_08838_ _02266_ _02268_ VGND VGND VPWR VPWR _02444_ sky130_fd_sc_hd__nor2_1
XTAP_TAPCELL_ROW_28_614 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_86_1339 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_56_956 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
X_08769_ _02368_ _02369_ VGND VGND VPWR VPWR _02370_ sky130_fd_sc_hd__xor2_4
XFILLER_0_95_633 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_95_622 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
X_10800_ _03574_ _02041_ VGND VGND VPWR VPWR _04584_ sky130_fd_sc_hd__nand2_1
XTAP_TAPCELL_ROW_56_967 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_0_250 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_0_261 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
X_10731_ _04500_ _04507_ _04508_ VGND VGND VPWR VPWR _04510_ sky130_fd_sc_hd__nand3_2
XFILLER_0_95_666 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
X_10662_ _04431_ _04432_ _04288_ VGND VGND VPWR VPWR _04435_ sky130_fd_sc_hd__o21ai_2
XFILLER_0_12_29 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
X_10593_ _04252_ _04230_ _04339_ _04340_ VGND VGND VPWR VPWR _04360_ sky130_fd_sc_hd__o211a_1
XFILLER_0_51_714 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_0_23_416 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_105_153 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XTAP_TAPCELL_ROW_97_1479 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_23_449 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_0_121_657 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
X_11214_ _03396_ _05033_ VGND VGND VPWR VPWR _05034_ sky130_fd_sc_hd__nand2_1
XFILLER_0_121_679 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_120_156 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
Xoutput73 net73 VGND VGND VPWR VPWR product[17] sky130_fd_sc_hd__clkbuf_4
X_11145_ _04957_ _04958_ VGND VGND VPWR VPWR _04959_ sky130_fd_sc_hd__or2_1
XTAP_TAPCELL_ROW_8_361 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
Xoutput84 net84 VGND VGND VPWR VPWR product[27] sky130_fd_sc_hd__clkbuf_4
Xoutput95 net95 VGND VGND VPWR VPWR product[37] sky130_fd_sc_hd__buf_2
X_11076_ _04505_ _04883_ VGND VGND VPWR VPWR _04884_ sky130_fd_sc_hd__nand2_1
X_10027_ _03562_ _03413_ _03595_ _03596_ VGND VGND VPWR VPWR _03743_ sky130_fd_sc_hd__o211a_1
XFILLER_0_86_600 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_0_85_110 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
X_10929_ _03675_ VGND VGND VPWR VPWR _04724_ sky130_fd_sc_hd__clkbuf_4
XTAP_TAPCELL_ROW_106_1586 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_58_346 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_86_699 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_39_593 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_0_109_481 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_5_137 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_82_9 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_81_360 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_0_54_585 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_0_41_213 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_06120_ _01508_ VGND VGND VPWR VPWR _04878_ sky130_fd_sc_hd__buf_4
XFILLER_0_112_624 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_0_75_8 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
X_06051_ _04052_ _04118_ VGND VGND VPWR VPWR _04129_ sky130_fd_sc_hd__xnor2_1
XFILLER_0_112_657 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_1_321 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XPHY_EDGE_ROW_99_Right_99 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
X_09810_ _03503_ _03504_ _03269_ _03484_ VGND VGND VPWR VPWR _03506_ sky130_fd_sc_hd__a211oi_2
X_09741_ _00348_ _00350_ _02141_ _02837_ VGND VGND VPWR VPWR _03431_ sky130_fd_sc_hd__nand4_1
X_06953_ net5 VGND VGND VPWR VPWR _00387_ sky130_fd_sc_hd__clkbuf_4
XFILLER_0_10_699 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
X_05904_ _02513_ _00439_ _01967_ _01956_ VGND VGND VPWR VPWR _02524_ sky130_fd_sc_hd__a31o_1
XFILLER_0_118_83 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
X_09672_ _03339_ _03353_ _03355_ VGND VGND VPWR VPWR _03356_ sky130_fd_sc_hd__and3_2
X_06884_ _00193_ _00203_ _00202_ VGND VGND VPWR VPWR _00312_ sky130_fd_sc_hd__a21bo_1
X_08623_ _02207_ _02209_ _02007_ _02085_ VGND VGND VPWR VPWR _02211_ sky130_fd_sc_hd__a211o_1
X_05835_ net29 VGND VGND VPWR VPWR _01771_ sky130_fd_sc_hd__buf_4
XFILLER_0_89_493 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_76_110 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
X_08554_ _05656_ _02134_ VGND VGND VPWR VPWR _02135_ sky130_fd_sc_hd__nand2_1
X_05766_ _00679_ _01007_ _00330_ _00351_ VGND VGND VPWR VPWR _01018_ sky130_fd_sc_hd__and4_1
XFILLER_0_11_3 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_77_666 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XTAP_TAPCELL_ROW_53_926 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
X_07505_ _00428_ _00695_ VGND VGND VPWR VPWR _00990_ sky130_fd_sc_hd__and2_1
XFILLER_0_76_176 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_08485_ _05659_ _00893_ _01040_ _05486_ VGND VGND VPWR VPWR _02059_ sky130_fd_sc_hd__a22o_1
XFILLER_0_91_113 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XTAP_TAPCELL_ROW_81_1269 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
X_07436_ _00611_ VGND VGND VPWR VPWR _00914_ sky130_fd_sc_hd__buf_4
XTAP_TAPCELL_ROW_33_672 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_33_714 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
X_07367_ _00537_ net47 _00837_ _00624_ VGND VGND VPWR VPWR _00839_ sky130_fd_sc_hd__a22o_1
XFILLER_0_72_360 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
X_09106_ _02402_ _02564_ VGND VGND VPWR VPWR _02738_ sky130_fd_sc_hd__nand2_1
XFILLER_0_60_533 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_17_298 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
X_06318_ _05448_ _05449_ VGND VGND VPWR VPWR _05450_ sky130_fd_sc_hd__nand2_2
XFILLER_0_115_473 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
X_09037_ _02660_ _02661_ VGND VGND VPWR VPWR _02662_ sky130_fd_sc_hd__nor2_2
XFILLER_0_5_671 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
X_07298_ _00759_ VGND VGND VPWR VPWR _00763_ sky130_fd_sc_hd__inv_2
XFILLER_0_103_657 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_32_279 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_06249_ _05300_ _05323_ _05380_ VGND VGND VPWR VPWR _05381_ sky130_fd_sc_hd__a21oi_1
XFILLER_0_13_493 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XTAP_TAPCELL_ROW_5_320 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
X_09939_ _03644_ _03645_ _03606_ VGND VGND VPWR VPWR _03647_ sky130_fd_sc_hd__a21oi_1
XFILLER_0_99_268 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_99_257 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_0_68_666 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_23_39 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_10714_ _02325_ _01849_ VGND VGND VPWR VPWR _04491_ sky130_fd_sc_hd__nand2_1
X_10645_ _02843_ _02060_ _02061_ _02812_ VGND VGND VPWR VPWR _04417_ sky130_fd_sc_hd__a22o_1
XFILLER_0_83_669 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_0_82_146 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_0_23_202 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
X_10576_ _04339_ _04340_ _04252_ _04230_ VGND VGND VPWR VPWR _04342_ sky130_fd_sc_hd__a211o_1
XFILLER_0_106_484 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_0_51_555 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XTAP_TAPCELL_ROW_11_399 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_121_421 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_23_268 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
X_11128_ _04925_ _04926_ VGND VGND VPWR VPWR _04940_ sky130_fd_sc_hd__and2b_1
XFILLER_0_3_27 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
X_11059_ _04720_ _04865_ VGND VGND VPWR VPWR _04866_ sky130_fd_sc_hd__nor2_1
XTAP_TAPCELL_ROW_108_1615 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_78_419 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_80_23 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XTAP_TAPCELL_ROW_19_499 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_86_463 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_0_80_56 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_73_102 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_59_677 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_104_41 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XFILLER_0_73_113 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
X_08270_ _01643_ net154 _01823_ _01824_ VGND VGND VPWR VPWR _01825_ sky130_fd_sc_hd__o211ai_4
XFILLER_0_104_85 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XTAP_TAPCELL_ROW_30_631 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
X_07221_ _02764_ _00086_ _00677_ _00678_ VGND VGND VPWR VPWR _00680_ sky130_fd_sc_hd__nand4_1
XTAP_TAPCELL_ROW_119_1744 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_82_691 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_07152_ _00490_ _00491_ VGND VGND VPWR VPWR _00604_ sky130_fd_sc_hd__and2b_1
XTAP_TAPCELL_ROW_30_642 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_119_1755 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_14_246 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_0_42_533 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
X_06103_ _03660_ _03681_ VGND VGND VPWR VPWR _04694_ sky130_fd_sc_hd__nor2_1
XFILLER_0_112_432 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_112_421 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
X_07083_ _00527_ _00528_ VGND VGND VPWR VPWR _00529_ sky130_fd_sc_hd__nand2_1
XFILLER_0_42_599 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
X_06034_ _03911_ _03922_ _03812_ VGND VGND VPWR VPWR _03943_ sky130_fd_sc_hd__a21o_1
XFILLER_0_112_498 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
X_07985_ _00690_ net19 _01511_ _01512_ VGND VGND VPWR VPWR _01513_ sky130_fd_sc_hd__o2bb2a_1
X_09724_ _03409_ _03410_ _03286_ VGND VGND VPWR VPWR _03412_ sky130_fd_sc_hd__a21o_1
X_06936_ _00365_ _00366_ _00264_ _00266_ VGND VGND VPWR VPWR _00368_ sky130_fd_sc_hd__o211ai_1
X_09655_ _03334_ _03335_ _03329_ _03330_ VGND VGND VPWR VPWR _03337_ sky130_fd_sc_hd__a211o_1
XTAP_TAPCELL_ROW_38_731 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
X_06867_ _02677_ _00087_ VGND VGND VPWR VPWR _00293_ sky130_fd_sc_hd__nand2_1
X_05818_ _01541_ _01563_ _01574_ VGND VGND VPWR VPWR _01585_ sky130_fd_sc_hd__nand3_1
XTAP_TAPCELL_ROW_38_742 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
X_08606_ _02188_ _02189_ _02190_ VGND VGND VPWR VPWR _02192_ sky130_fd_sc_hd__a21o_1
XFILLER_0_96_238 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_77_441 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
X_09586_ _01414_ _01580_ _02943_ _02944_ VGND VGND VPWR VPWR _03261_ sky130_fd_sc_hd__nand4_2
X_06798_ _00223_ _00224_ VGND VGND VPWR VPWR _00225_ sky130_fd_sc_hd__and2b_1
X_08537_ _02112_ _02114_ _02106_ VGND VGND VPWR VPWR _02116_ sky130_fd_sc_hd__a21o_1
X_05749_ net60 VGND VGND VPWR VPWR _00832_ sky130_fd_sc_hd__clkbuf_4
XFILLER_0_37_305 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
X_08468_ _02038_ _02039_ VGND VGND VPWR VPWR _02040_ sky130_fd_sc_hd__xnor2_1
XFILLER_0_92_477 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
X_07419_ _00894_ VGND VGND VPWR VPWR _00895_ sky130_fd_sc_hd__buf_4
XFILLER_0_18_530 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XFILLER_0_107_237 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
X_10430_ _04171_ _04181_ VGND VGND VPWR VPWR _04182_ sky130_fd_sc_hd__xnor2_2
X_08399_ _01795_ _01817_ _01818_ VGND VGND VPWR VPWR _01965_ sky130_fd_sc_hd__nand3_2
XFILLER_0_45_393 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XFILLER_0_115_270 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_10361_ _02492_ _02141_ _02943_ _02944_ VGND VGND VPWR VPWR _04108_ sky130_fd_sc_hd__nand4_4
XTAP_TAPCELL_ROW_94_1438 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_20_205 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_21_717 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
X_10292_ _04030_ _04032_ _03908_ _03913_ VGND VGND VPWR VPWR _04033_ sky130_fd_sc_hd__o211a_1
XFILLER_0_20_238 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_87_216 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_87_205 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XFILLER_0_34_27 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XTAP_TAPCELL_ROW_103_1545 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_56_614 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_55_113 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XTAP_TAPCELL_ROW_16_458 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_28_338 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_114_719 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_70_105 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_50_59 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_113_229 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
X_10628_ _02141_ _01353_ _01500_ _02492_ VGND VGND VPWR VPWR _04398_ sky130_fd_sc_hd__a22oi_1
XFILLER_0_70_149 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_51_330 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_0_24_533 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
X_10559_ _04311_ _04321_ _04322_ VGND VGND VPWR VPWR _04323_ sky130_fd_sc_hd__and3_1
XFILLER_0_11_205 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_3_449 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_0_59_68 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_0_51_396 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XTAP_TAPCELL_ROW_114_1685 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_45_9 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
X_07770_ _02065_ _00695_ _01278_ _00308_ VGND VGND VPWR VPWR _01279_ sky130_fd_sc_hd__a22oi_2
XFILLER_0_79_717 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XTAP_TAPCELL_ROW_69_1120 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
X_06721_ _00049_ _00047_ _00045_ VGND VGND VPWR VPWR _00148_ sky130_fd_sc_hd__o21ai_2
X_09440_ _02778_ _02780_ _02954_ _02955_ VGND VGND VPWR VPWR _03101_ sky130_fd_sc_hd__a211oi_2
XFILLER_0_78_249 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XTAP_TAPCELL_ROW_35_701 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
X_06652_ _00078_ _00079_ VGND VGND VPWR VPWR _00080_ sky130_fd_sc_hd__and2b_1
XFILLER_0_115_51 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
X_09371_ _02866_ VGND VGND VPWR VPWR _03027_ sky130_fd_sc_hd__clkbuf_8
X_06583_ _05671_ _05672_ _00010_ _00011_ VGND VGND VPWR VPWR _00012_ sky130_fd_sc_hd__or4bb_2
X_08322_ _01870_ _01879_ _01881_ VGND VGND VPWR VPWR _01882_ sky130_fd_sc_hd__and3b_2
X_08253_ _00799_ _03365_ net53 _01805_ VGND VGND VPWR VPWR _01807_ sky130_fd_sc_hd__nand4_2
XFILLER_0_47_669 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_0_117_557 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_0_55_680 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XFILLER_0_6_243 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_07204_ _04520_ _04542_ _05345_ _05425_ VGND VGND VPWR VPWR _00661_ sky130_fd_sc_hd__nand4_1
XFILLER_0_104_207 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
X_08184_ _01729_ _01730_ VGND VGND VPWR VPWR _01731_ sky130_fd_sc_hd__and2b_1
XFILLER_0_27_393 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
X_07135_ _00446_ _00519_ _00584_ _00585_ VGND VGND VPWR VPWR _00586_ sky130_fd_sc_hd__o211a_1
XFILLER_0_15_577 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
X_07066_ _00367_ _00499_ _00509_ VGND VGND VPWR VPWR _00510_ sky130_fd_sc_hd__a21o_1
X_06017_ _02065_ _03223_ _02000_ _01007_ VGND VGND VPWR VPWR _03758_ sky130_fd_sc_hd__a22o_1
XFILLER_0_10_282 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
X_07968_ _01493_ _01362_ VGND VGND VPWR VPWR _01494_ sky130_fd_sc_hd__nor2_1
X_09707_ _05551_ _02136_ _02345_ VGND VGND VPWR VPWR _03393_ sky130_fd_sc_hd__and3_1
X_06919_ net11 VGND VGND VPWR VPWR _00349_ sky130_fd_sc_hd__buf_4
XFILLER_0_97_503 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_69_216 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_07899_ _05310_ _00294_ _01417_ _01418_ VGND VGND VPWR VPWR _01420_ sky130_fd_sc_hd__o2bb2a_1
XFILLER_0_97_558 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XFILLER_0_85_709 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
X_09638_ _03159_ VGND VGND VPWR VPWR _03318_ sky130_fd_sc_hd__inv_2
X_09569_ _03239_ _03240_ _05497_ net22 VGND VGND VPWR VPWR _03242_ sky130_fd_sc_hd__and4bb_1
XFILLER_0_77_293 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_65_411 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_37_113 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_0_37_124 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_38_625 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XTAP_TAPCELL_ROW_13_428 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_92_285 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_18_360 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
X_11462_ _01444_ _05292_ VGND VGND VPWR VPWR _05293_ sky130_fd_sc_hd__and2_1
XFILLER_0_20_29 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
X_11393_ _05186_ _05219_ VGND VGND VPWR VPWR _05226_ sky130_fd_sc_hd__nand2_1
X_10413_ _04162_ _04163_ VGND VGND VPWR VPWR _04164_ sky130_fd_sc_hd__xnor2_2
XFILLER_0_33_352 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
X_10344_ _00294_ _00686_ _02036_ _01852_ VGND VGND VPWR VPWR _04089_ sky130_fd_sc_hd__and4_1
X_10275_ _04011_ _04012_ _03996_ _03891_ VGND VGND VPWR VPWR _04014_ sky130_fd_sc_hd__o211a_1
XFILLER_0_45_37 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
Xmax_cap4 _00588_ VGND VGND VPWR VPWR net171 sky130_fd_sc_hd__clkbuf_1
XFILLER_0_0_39 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_29_647 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XTAP_TAPCELL_ROW_64_1061 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_61_69 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_9_15 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_117_3 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_71_436 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XTAP_TAPCELL_ROW_116_1714 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_24_363 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_101_53 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_0_86_22 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_0_12_569 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_12_558 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_0_3_279 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
X_08940_ _02378_ _02379_ VGND VGND VPWR VPWR _02556_ sky130_fd_sc_hd__or2_1
X_08871_ _02477_ _02478_ _02479_ VGND VGND VPWR VPWR _02481_ sky130_fd_sc_hd__nand3_1
X_07822_ _01216_ _01217_ VGND VGND VPWR VPWR _01336_ sky130_fd_sc_hd__and2_1
XFILLER_0_79_503 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
X_07753_ _01252_ _01260_ VGND VGND VPWR VPWR _01261_ sky130_fd_sc_hd__xnor2_1
XFILLER_0_79_536 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_67_709 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_07684_ net18 VGND VGND VPWR VPWR _01185_ sky130_fd_sc_hd__clkbuf_4
X_06704_ _00032_ _00051_ VGND VGND VPWR VPWR _00131_ sky130_fd_sc_hd__and2_1
XFILLER_0_79_569 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
X_09423_ _03082_ VGND VGND VPWR VPWR _03083_ sky130_fd_sc_hd__inv_2
X_06635_ _04900_ _04596_ _00060_ _00061_ VGND VGND VPWR VPWR _00063_ sky130_fd_sc_hd__a22o_1
X_09354_ _05387_ _01278_ _01798_ _05463_ VGND VGND VPWR VPWR _03008_ sky130_fd_sc_hd__a22o_1
XFILLER_0_19_113 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_08305_ _01181_ _01849_ _01861_ VGND VGND VPWR VPWR _01863_ sky130_fd_sc_hd__nand3_1
XFILLER_0_19_135 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
X_06566_ net39 VGND VGND VPWR VPWR _05695_ sky130_fd_sc_hd__clkbuf_4
XFILLER_0_35_606 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_90_701 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
X_09285_ _02920_ _02921_ _02931_ VGND VGND VPWR VPWR _02933_ sky130_fd_sc_hd__a21oi_1
X_06497_ _05625_ _05626_ VGND VGND VPWR VPWR net71 sky130_fd_sc_hd__xnor2_1
XFILLER_0_35_617 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_0_105_505 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_0_15_330 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
X_08236_ _02197_ _02732_ _00695_ _00837_ VGND VGND VPWR VPWR _01788_ sky130_fd_sc_hd__nand4_2
X_08167_ _01669_ _01710_ _01711_ VGND VGND VPWR VPWR _01712_ sky130_fd_sc_hd__nor3_1
X_07118_ _00646_ _00430_ _00565_ _00624_ VGND VGND VPWR VPWR _00567_ sky130_fd_sc_hd__a22o_1
XFILLER_0_113_593 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
X_08098_ _01447_ _01457_ _01456_ VGND VGND VPWR VPWR _01637_ sky130_fd_sc_hd__a21bo_1
X_07049_ _00353_ _00357_ _00347_ VGND VGND VPWR VPWR _00491_ sky130_fd_sc_hd__o21ai_2
X_10060_ _03776_ _03777_ _03759_ VGND VGND VPWR VPWR _03779_ sky130_fd_sc_hd__o21ai_1
X_10962_ _03341_ _02941_ _04758_ _04760_ VGND VGND VPWR VPWR _04761_ sky130_fd_sc_hd__a22oi_2
X_10893_ _04682_ _04684_ _04679_ VGND VGND VPWR VPWR _04686_ sky130_fd_sc_hd__a21o_1
XTAP_TAPCELL_ROW_100_1515 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_26_586 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_93_572 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_53_414 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_25_105 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_0_26_628 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_38_477 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_0_38_488 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_80_244 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_25_127 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
X_11445_ _05279_ _05280_ VGND VGND VPWR VPWR net123 sky130_fd_sc_hd__xnor2_4
Xwire154 _01755_ VGND VGND VPWR VPWR net154 sky130_fd_sc_hd__buf_1
XFILLER_0_18_190 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_0_1_717 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
X_11376_ _04732_ _03675_ VGND VGND VPWR VPWR _05208_ sky130_fd_sc_hd__nand2_1
X_10327_ _00762_ _02850_ _04067_ _04068_ VGND VGND VPWR VPWR _04070_ sky130_fd_sc_hd__nand4_1
XTAP_TAPCELL_ROW_111_1655 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_111_1644 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
X_10258_ _03993_ _03994_ VGND VGND VPWR VPWR _03995_ sky130_fd_sc_hd__xor2_1
X_10189_ _03661_ _03796_ _03797_ VGND VGND VPWR VPWR _03920_ sky130_fd_sc_hd__o21ai_2
XFILLER_0_72_46 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
X_06420_ net4 VGND VGND VPWR VPWR _05550_ sky130_fd_sc_hd__clkbuf_4
XFILLER_0_91_509 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_29_455 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_72_701 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_17_617 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
X_06351_ _05459_ _05480_ _05481_ VGND VGND VPWR VPWR _05482_ sky130_fd_sc_hd__nor3_1
XFILLER_0_112_41 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
X_09070_ _02694_ _02696_ _02690_ VGND VGND VPWR VPWR _02698_ sky130_fd_sc_hd__a21o_1
X_06282_ _05405_ _05413_ VGND VGND VPWR VPWR _05414_ sky130_fd_sc_hd__xnor2_2
XFILLER_0_112_85 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_71_255 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_0_4_533 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
X_08021_ _01550_ _01551_ VGND VGND VPWR VPWR _01553_ sky130_fd_sc_hd__or2_2
XTAP_TAPCELL_ROW_77_1230 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_4_577 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_0_40_631 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XFILLER_0_40_653 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
X_09972_ _04085_ _04596_ _02862_ _02866_ VGND VGND VPWR VPWR _03683_ sky130_fd_sc_hd__and4_1
X_08923_ _02536_ _02537_ VGND VGND VPWR VPWR _02538_ sky130_fd_sc_hd__or2_2
XFILLER_0_12_399 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
X_08854_ _02457_ _02460_ _02456_ VGND VGND VPWR VPWR _02462_ sky130_fd_sc_hd__a21o_1
XFILLER_0_98_119 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
X_08785_ _02386_ _02387_ VGND VGND VPWR VPWR _02388_ sky130_fd_sc_hd__xor2_2
X_05997_ _02993_ _03037_ VGND VGND VPWR VPWR _03539_ sky130_fd_sc_hd__xnor2_1
X_07805_ _01316_ _01317_ VGND VGND VPWR VPWR _01318_ sky130_fd_sc_hd__or2b_2
XFILLER_0_79_333 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
X_07736_ _01146_ _01148_ VGND VGND VPWR VPWR _01242_ sky130_fd_sc_hd__nand2_2
XFILLER_0_67_517 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XPHY_EDGE_ROW_9_Left_131 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_0_94_325 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
X_07667_ _01016_ _01033_ _01165_ _01166_ VGND VGND VPWR VPWR _01167_ sky130_fd_sc_hd__a211o_1
X_09406_ _02912_ _03064_ VGND VGND VPWR VPWR _03065_ sky130_fd_sc_hd__xnor2_2
X_06618_ _00045_ VGND VGND VPWR VPWR _00046_ sky130_fd_sc_hd__inv_2
XFILLER_0_1_93 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
X_07598_ _00966_ _00968_ _01089_ _01090_ VGND VGND VPWR VPWR _01091_ sky130_fd_sc_hd__o211a_1
XFILLER_0_118_641 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
X_09337_ _02646_ _01604_ _02986_ _02987_ VGND VGND VPWR VPWR _02989_ sky130_fd_sc_hd__nand4_1
XTAP_TAPCELL_ROW_23_545 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
X_06549_ _01771_ _02219_ _03856_ _05416_ VGND VGND VPWR VPWR _05678_ sky130_fd_sc_hd__nand4_2
X_09268_ _02750_ _02791_ VGND VGND VPWR VPWR _02914_ sky130_fd_sc_hd__and2b_1
XTAP_TAPCELL_ROW_51_898 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_7_393 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_0_23_609 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
X_08219_ _05307_ _05305_ _00688_ _00830_ VGND VGND VPWR VPWR _01769_ sky130_fd_sc_hd__nand4_1
XFILLER_0_90_597 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
X_09199_ _05468_ _02838_ VGND VGND VPWR VPWR _02839_ sky130_fd_sc_hd__nand2_2
XFILLER_0_62_299 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
X_11230_ _04986_ _05049_ VGND VGND VPWR VPWR _05051_ sky130_fd_sc_hd__and2_1
X_11161_ _02840_ _02227_ VGND VGND VPWR VPWR _04977_ sky130_fd_sc_hd__nand2_1
XFILLER_0_30_174 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_0_31_686 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
X_10112_ _03689_ _03694_ _03691_ VGND VGND VPWR VPWR _03836_ sky130_fd_sc_hd__a21bo_1
X_11092_ _04901_ VGND VGND VPWR VPWR _04902_ sky130_fd_sc_hd__inv_2
X_10043_ _03567_ _03577_ _03576_ VGND VGND VPWR VPWR _03761_ sky130_fd_sc_hd__a21o_1
XTAP_TAPCELL_ROW_59_998 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
X_10945_ _01850_ _04740_ _04741_ VGND VGND VPWR VPWR _04742_ sky130_fd_sc_hd__a21bo_1
X_10876_ _04665_ _04666_ VGND VGND VPWR VPWR _04667_ sky130_fd_sc_hd__xnor2_1
XFILLER_0_38_230 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_0_42_27 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_109_641 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XTAP_TAPCELL_ROW_61_1020 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_53_222 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XFILLER_0_5_319 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_109_685 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_81_586 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_111_316 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
X_11428_ _05261_ _05262_ VGND VGND VPWR VPWR _05263_ sky130_fd_sc_hd__or2_2
XFILLER_0_22_642 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XANTENNA_4 _00624_ VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
X_11359_ _05099_ _05147_ _05148_ VGND VGND VPWR VPWR _05190_ sky130_fd_sc_hd__o21ai_1
XFILLER_0_6_27 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_1_558 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XFILLER_0_67_57 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XTAP_TAPCELL_ROW_72_1160 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
X_05920_ net29 VGND VGND VPWR VPWR _02699_ sky130_fd_sc_hd__clkbuf_4
XFILLER_0_83_23 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
X_05851_ _01935_ VGND VGND VPWR VPWR net125 sky130_fd_sc_hd__buf_1
XFILLER_0_83_45 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_08570_ _02133_ _02150_ _02151_ VGND VGND VPWR VPWR _02152_ sky130_fd_sc_hd__nand3_2
X_05782_ _00384_ VGND VGND VPWR VPWR _01192_ sky130_fd_sc_hd__clkbuf_4
X_07521_ _00849_ _00970_ net173 _01006_ VGND VGND VPWR VPWR _01008_ sky130_fd_sc_hd__a211o_2
XFILLER_0_89_697 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_49_517 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
X_07452_ _04976_ _05539_ _00139_ _03332_ VGND VGND VPWR VPWR _00932_ sky130_fd_sc_hd__a22o_1
XFILLER_0_57_561 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
X_07383_ _00815_ _00816_ _00853_ _00855_ VGND VGND VPWR VPWR _00857_ sky130_fd_sc_hd__a2bb2o_2
X_06403_ _05532_ _05533_ VGND VGND VPWR VPWR _05534_ sky130_fd_sc_hd__or2b_2
X_09122_ _05659_ _05676_ _01499_ VGND VGND VPWR VPWR _02755_ sky130_fd_sc_hd__and3_1
X_06334_ _00461_ _01236_ _05464_ _05388_ VGND VGND VPWR VPWR _05465_ sky130_fd_sc_hd__and4_1
XFILLER_0_17_425 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XTAP_TAPCELL_ROW_20_515 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_44_222 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_115_611 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_0_114_121 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_89_3 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
X_09053_ _02675_ _02676_ _02678_ VGND VGND VPWR VPWR _02680_ sky130_fd_sc_hd__a21o_1
X_06265_ _05395_ _05396_ VGND VGND VPWR VPWR _05397_ sky130_fd_sc_hd__xor2_1
XFILLER_0_102_327 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_102_305 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
X_08004_ _01396_ VGND VGND VPWR VPWR _01534_ sky130_fd_sc_hd__inv_2
X_06196_ _02513_ _04878_ _04802_ _03124_ VGND VGND VPWR VPWR _05329_ sky130_fd_sc_hd__and4_1
XFILLER_0_102_349 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_12_141 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XFILLER_0_13_697 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
X_09955_ _03074_ _03664_ VGND VGND VPWR VPWR _03665_ sky130_fd_sc_hd__nor2_1
X_09886_ _03580_ _03587_ _03588_ VGND VGND VPWR VPWR _03589_ sky130_fd_sc_hd__nand3_2
X_08906_ _03091_ _02516_ _02517_ _02518_ VGND VGND VPWR VPWR _02519_ sky130_fd_sc_hd__nand4_2
X_08837_ _02441_ _02442_ VGND VGND VPWR VPWR _02443_ sky130_fd_sc_hd__or2b_2
XTAP_TAPCELL_ROW_28_615 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_56_957 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
X_08768_ _02182_ _02192_ _02191_ VGND VGND VPWR VPWR _02369_ sky130_fd_sc_hd__a21bo_1
XFILLER_0_94_111 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
X_08699_ _02290_ _02291_ _02285_ _02286_ VGND VGND VPWR VPWR _02293_ sky130_fd_sc_hd__a211o_1
XTAP_TAPCELL_ROW_56_968 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_0_251 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_0_262 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
X_07719_ _00533_ _05008_ _00138_ _00038_ VGND VGND VPWR VPWR _01223_ sky130_fd_sc_hd__nand4_2
X_10730_ _04504_ _04506_ _04501_ VGND VGND VPWR VPWR _04508_ sky130_fd_sc_hd__a21o_1
XFILLER_0_67_358 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
X_10661_ _04288_ _04431_ _04432_ VGND VGND VPWR VPWR _04434_ sky130_fd_sc_hd__or3_2
XFILLER_0_82_306 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XFILLER_0_36_701 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_48_583 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
X_10592_ _04339_ VGND VGND VPWR VPWR _04359_ sky130_fd_sc_hd__inv_2
XFILLER_0_121_625 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XTAP_TAPCELL_ROW_97_1469 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_121_669 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_0_120_135 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
X_11213_ _03478_ VGND VGND VPWR VPWR _05033_ sky130_fd_sc_hd__buf_2
XFILLER_0_50_269 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
X_11144_ _04944_ _04890_ _04956_ VGND VGND VPWR VPWR _04958_ sky130_fd_sc_hd__and3_1
XTAP_TAPCELL_ROW_8_362 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
Xoutput85 net85 VGND VGND VPWR VPWR product[28] sky130_fd_sc_hd__clkbuf_4
Xoutput74 net74 VGND VGND VPWR VPWR product[18] sky130_fd_sc_hd__clkbuf_4
XFILLER_0_101_393 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_11075_ _04275_ VGND VGND VPWR VPWR _04883_ sky130_fd_sc_hd__buf_2
Xoutput96 net96 VGND VGND VPWR VPWR product[38] sky130_fd_sc_hd__clkbuf_4
XFILLER_0_37_38 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
X_10026_ _03739_ _03740_ _03680_ _03601_ VGND VGND VPWR VPWR _03742_ sky130_fd_sc_hd__a211oi_1
X_10928_ _04669_ _04671_ VGND VGND VPWR VPWR _04723_ sky130_fd_sc_hd__and2_1
XTAP_TAPCELL_ROW_106_1587 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_86_645 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_85_133 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_58_358 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_0_73_317 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_39_561 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_0_116_419 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
X_10859_ _04646_ _04647_ VGND VGND VPWR VPWR _04648_ sky130_fd_sc_hd__nor2_1
XFILLER_0_54_520 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_0_109_493 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_0_5_105 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_0_5_149 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_42_715 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
X_06050_ _04096_ _04107_ VGND VGND VPWR VPWR _04118_ sky130_fd_sc_hd__nor2_1
XFILLER_0_1_333 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_0_112_669 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_111_146 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_10_645 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
X_09740_ _02459_ _02320_ _01605_ _00151_ VGND VGND VPWR VPWR _03429_ sky130_fd_sc_hd__a22o_1
X_06952_ _03288_ _03376_ _05550_ _05552_ VGND VGND VPWR VPWR _00386_ sky130_fd_sc_hd__nand4_2
.ends
