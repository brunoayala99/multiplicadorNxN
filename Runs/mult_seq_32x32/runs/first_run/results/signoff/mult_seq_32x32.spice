* NGSPICE file created from mult_seq_32x32.ext - technology: sky130A

* Black-box entry subcircuit for sky130_fd_sc_hd__o311a_1 abstract view
.subckt sky130_fd_sc_hd__o311a_1 A1 A2 A3 B1 C1 VGND VNB VPB VPWR X
.ends

* Black-box entry subcircuit for sky130_fd_sc_hd__fill_1 abstract view
.subckt sky130_fd_sc_hd__fill_1 VGND VNB VPB VPWR
.ends

* Black-box entry subcircuit for sky130_ef_sc_hd__decap_12 abstract view
.subckt sky130_ef_sc_hd__decap_12 VGND VPWR VPB VNB
.ends

* Black-box entry subcircuit for sky130_fd_sc_hd__decap_4 abstract view
.subckt sky130_fd_sc_hd__decap_4 VGND VNB VPB VPWR
.ends

* Black-box entry subcircuit for sky130_fd_sc_hd__dfxtp_2 abstract view
.subckt sky130_fd_sc_hd__dfxtp_2 CLK D VGND VNB VPB VPWR Q
.ends

* Black-box entry subcircuit for sky130_fd_sc_hd__decap_3 abstract view
.subckt sky130_fd_sc_hd__decap_3 VGND VNB VPB VPWR
.ends

* Black-box entry subcircuit for sky130_fd_sc_hd__a21o_1 abstract view
.subckt sky130_fd_sc_hd__a21o_1 A1 A2 B1 VGND VNB VPB VPWR X
.ends

* Black-box entry subcircuit for sky130_fd_sc_hd__nor2_1 abstract view
.subckt sky130_fd_sc_hd__nor2_1 A B VGND VNB VPB VPWR Y
.ends

* Black-box entry subcircuit for sky130_fd_sc_hd__dfxtp_1 abstract view
.subckt sky130_fd_sc_hd__dfxtp_1 CLK D VGND VNB VPB VPWR Q
.ends

* Black-box entry subcircuit for sky130_fd_sc_hd__o31a_1 abstract view
.subckt sky130_fd_sc_hd__o31a_1 A1 A2 A3 B1 VGND VNB VPB VPWR X
.ends

* Black-box entry subcircuit for sky130_fd_sc_hd__decap_8 abstract view
.subckt sky130_fd_sc_hd__decap_8 VGND VNB VPB VPWR
.ends

* Black-box entry subcircuit for sky130_fd_sc_hd__or2_1 abstract view
.subckt sky130_fd_sc_hd__or2_1 A B VGND VNB VPB VPWR X
.ends

* Black-box entry subcircuit for sky130_fd_sc_hd__a21oi_1 abstract view
.subckt sky130_fd_sc_hd__a21oi_1 A1 A2 B1 VGND VNB VPB VPWR Y
.ends

* Black-box entry subcircuit for sky130_fd_sc_hd__mux2_1 abstract view
.subckt sky130_fd_sc_hd__mux2_1 A0 A1 S VGND VNB VPB VPWR X
.ends

* Black-box entry subcircuit for sky130_fd_sc_hd__dlygate4sd3_1 abstract view
.subckt sky130_fd_sc_hd__dlygate4sd3_1 A VGND VNB VPB VPWR X
.ends

* Black-box entry subcircuit for sky130_fd_sc_hd__fill_2 abstract view
.subckt sky130_fd_sc_hd__fill_2 VGND VNB VPB VPWR
.ends

* Black-box entry subcircuit for sky130_fd_sc_hd__clkbuf_4 abstract view
.subckt sky130_fd_sc_hd__clkbuf_4 A VGND VNB VPB VPWR X
.ends

* Black-box entry subcircuit for sky130_fd_sc_hd__o211a_1 abstract view
.subckt sky130_fd_sc_hd__o211a_1 A1 A2 B1 C1 VGND VNB VPB VPWR X
.ends

* Black-box entry subcircuit for sky130_fd_sc_hd__nand2_1 abstract view
.subckt sky130_fd_sc_hd__nand2_1 A B VGND VNB VPB VPWR Y
.ends

* Black-box entry subcircuit for sky130_fd_sc_hd__tapvpwrvgnd_1 abstract view
.subckt sky130_fd_sc_hd__tapvpwrvgnd_1 VGND VPWR
.ends

* Black-box entry subcircuit for sky130_fd_sc_hd__buf_2 abstract view
.subckt sky130_fd_sc_hd__buf_2 A VGND VNB VPB VPWR X
.ends

* Black-box entry subcircuit for sky130_fd_sc_hd__nand3_1 abstract view
.subckt sky130_fd_sc_hd__nand3_1 A B C VGND VNB VPB VPWR Y
.ends

* Black-box entry subcircuit for sky130_fd_sc_hd__clkbuf_16 abstract view
.subckt sky130_fd_sc_hd__clkbuf_16 A VGND VNB VPB VPWR X
.ends

* Black-box entry subcircuit for sky130_fd_sc_hd__decap_6 abstract view
.subckt sky130_fd_sc_hd__decap_6 VGND VNB VPB VPWR
.ends

* Black-box entry subcircuit for sky130_fd_sc_hd__and3_1 abstract view
.subckt sky130_fd_sc_hd__and3_1 A B C VGND VNB VPB VPWR X
.ends

* Black-box entry subcircuit for sky130_fd_sc_hd__o21ai_1 abstract view
.subckt sky130_fd_sc_hd__o21ai_1 A1 A2 B1 VGND VNB VPB VPWR Y
.ends

* Black-box entry subcircuit for sky130_fd_sc_hd__buf_4 abstract view
.subckt sky130_fd_sc_hd__buf_4 A VGND VNB VPB VPWR X
.ends

* Black-box entry subcircuit for sky130_fd_sc_hd__a211o_1 abstract view
.subckt sky130_fd_sc_hd__a211o_1 A1 A2 B1 C1 VGND VNB VPB VPWR X
.ends

* Black-box entry subcircuit for sky130_fd_sc_hd__o21a_1 abstract view
.subckt sky130_fd_sc_hd__o21a_1 A1 A2 B1 VGND VNB VPB VPWR X
.ends

* Black-box entry subcircuit for sky130_fd_sc_hd__and2_1 abstract view
.subckt sky130_fd_sc_hd__and2_1 A B VGND VNB VPB VPWR X
.ends

* Black-box entry subcircuit for sky130_fd_sc_hd__xnor2_1 abstract view
.subckt sky130_fd_sc_hd__xnor2_1 A B VGND VNB VPB VPWR Y
.ends

* Black-box entry subcircuit for sky130_fd_sc_hd__a22o_1 abstract view
.subckt sky130_fd_sc_hd__a22o_1 A1 A2 B1 B2 VGND VNB VPB VPWR X
.ends

* Black-box entry subcircuit for sky130_fd_sc_hd__a221o_1 abstract view
.subckt sky130_fd_sc_hd__a221o_1 A1 A2 B1 B2 C1 VGND VNB VPB VPWR X
.ends

* Black-box entry subcircuit for sky130_fd_sc_hd__clkbuf_1 abstract view
.subckt sky130_fd_sc_hd__clkbuf_1 A VGND VNB VPB VPWR X
.ends

* Black-box entry subcircuit for sky130_fd_sc_hd__a21boi_1 abstract view
.subckt sky130_fd_sc_hd__a21boi_1 A1 A2 B1_N VGND VNB VPB VPWR Y
.ends

* Black-box entry subcircuit for sky130_fd_sc_hd__or4b_1 abstract view
.subckt sky130_fd_sc_hd__or4b_1 A B C D_N VGND VNB VPB VPWR X
.ends

* Black-box entry subcircuit for sky130_fd_sc_hd__or4_1 abstract view
.subckt sky130_fd_sc_hd__or4_1 A B C D VGND VNB VPB VPWR X
.ends

* Black-box entry subcircuit for sky130_fd_sc_hd__or2b_1 abstract view
.subckt sky130_fd_sc_hd__or2b_1 A B_N VGND VNB VPB VPWR X
.ends

* Black-box entry subcircuit for sky130_fd_sc_hd__a22oi_1 abstract view
.subckt sky130_fd_sc_hd__a22oi_1 A1 A2 B1 B2 VGND VNB VPB VPWR Y
.ends

* Black-box entry subcircuit for sky130_fd_sc_hd__a31o_1 abstract view
.subckt sky130_fd_sc_hd__a31o_1 A1 A2 A3 B1 VGND VNB VPB VPWR X
.ends

* Black-box entry subcircuit for sky130_fd_sc_hd__or3_1 abstract view
.subckt sky130_fd_sc_hd__or3_1 A B C VGND VNB VPB VPWR X
.ends

* Black-box entry subcircuit for sky130_fd_sc_hd__nand4b_1 abstract view
.subckt sky130_fd_sc_hd__nand4b_1 A_N B C D VGND VNB VPB VPWR Y
.ends

* Black-box entry subcircuit for sky130_fd_sc_hd__and4_1 abstract view
.subckt sky130_fd_sc_hd__and4_1 A B C D VGND VNB VPB VPWR X
.ends

* Black-box entry subcircuit for sky130_fd_sc_hd__o21ba_1 abstract view
.subckt sky130_fd_sc_hd__o21ba_1 A1 A2 B1_N VGND VNB VPB VPWR X
.ends

* Black-box entry subcircuit for sky130_fd_sc_hd__a311o_1 abstract view
.subckt sky130_fd_sc_hd__a311o_1 A1 A2 A3 B1 C1 VGND VNB VPB VPWR X
.ends

* Black-box entry subcircuit for sky130_fd_sc_hd__nor2_2 abstract view
.subckt sky130_fd_sc_hd__nor2_2 A B VGND VNB VPB VPWR Y
.ends

* Black-box entry subcircuit for sky130_fd_sc_hd__nand2_2 abstract view
.subckt sky130_fd_sc_hd__nand2_2 A B VGND VNB VPB VPWR Y
.ends

* Black-box entry subcircuit for sky130_fd_sc_hd__xor2_2 abstract view
.subckt sky130_fd_sc_hd__xor2_2 A B VGND VNB VPB VPWR X
.ends

* Black-box entry subcircuit for sky130_fd_sc_hd__inv_2 abstract view
.subckt sky130_fd_sc_hd__inv_2 A VGND VNB VPB VPWR Y
.ends

* Black-box entry subcircuit for sky130_fd_sc_hd__o31a_2 abstract view
.subckt sky130_fd_sc_hd__o31a_2 A1 A2 A3 B1 VGND VNB VPB VPWR X
.ends

* Black-box entry subcircuit for sky130_fd_sc_hd__clkbuf_2 abstract view
.subckt sky130_fd_sc_hd__clkbuf_2 A VGND VNB VPB VPWR X
.ends

* Black-box entry subcircuit for sky130_fd_sc_hd__nand3b_1 abstract view
.subckt sky130_fd_sc_hd__nand3b_1 A_N B C VGND VNB VPB VPWR Y
.ends

* Black-box entry subcircuit for sky130_fd_sc_hd__and3b_1 abstract view
.subckt sky130_fd_sc_hd__and3b_1 A_N B C VGND VNB VPB VPWR X
.ends

* Black-box entry subcircuit for sky130_fd_sc_hd__dlymetal6s2s_1 abstract view
.subckt sky130_fd_sc_hd__dlymetal6s2s_1 A VGND VNB VPB VPWR X
.ends

* Black-box entry subcircuit for sky130_fd_sc_hd__a21bo_1 abstract view
.subckt sky130_fd_sc_hd__a21bo_1 A1 A2 B1_N VGND VNB VPB VPWR X
.ends

* Black-box entry subcircuit for sky130_fd_sc_hd__or2_2 abstract view
.subckt sky130_fd_sc_hd__or2_2 A B VGND VNB VPB VPWR X
.ends

* Black-box entry subcircuit for sky130_fd_sc_hd__buf_1 abstract view
.subckt sky130_fd_sc_hd__buf_1 A VGND VNB VPB VPWR X
.ends

* Black-box entry subcircuit for sky130_fd_sc_hd__nand2_4 abstract view
.subckt sky130_fd_sc_hd__nand2_4 A B VGND VNB VPB VPWR Y
.ends

* Black-box entry subcircuit for sky130_fd_sc_hd__o21bai_2 abstract view
.subckt sky130_fd_sc_hd__o21bai_2 A1 A2 B1_N VGND VNB VPB VPWR Y
.ends

* Black-box entry subcircuit for sky130_fd_sc_hd__o221a_1 abstract view
.subckt sky130_fd_sc_hd__o221a_1 A1 A2 B1 B2 C1 VGND VNB VPB VPWR X
.ends

* Black-box entry subcircuit for sky130_fd_sc_hd__o211ai_4 abstract view
.subckt sky130_fd_sc_hd__o211ai_4 A1 A2 B1 C1 VGND VNB VPB VPWR Y
.ends

* Black-box entry subcircuit for sky130_fd_sc_hd__o2bb2a_1 abstract view
.subckt sky130_fd_sc_hd__o2bb2a_1 A1_N A2_N B1 B2 VGND VNB VPB VPWR X
.ends

* Black-box entry subcircuit for sky130_fd_sc_hd__o22a_1 abstract view
.subckt sky130_fd_sc_hd__o22a_1 A1 A2 B1 B2 VGND VNB VPB VPWR X
.ends

* Black-box entry subcircuit for sky130_fd_sc_hd__and4b_1 abstract view
.subckt sky130_fd_sc_hd__and4b_1 A_N B C D VGND VNB VPB VPWR X
.ends

* Black-box entry subcircuit for sky130_fd_sc_hd__a31oi_2 abstract view
.subckt sky130_fd_sc_hd__a31oi_2 A1 A2 A3 B1 VGND VNB VPB VPWR Y
.ends

* Black-box entry subcircuit for sky130_fd_sc_hd__and2b_1 abstract view
.subckt sky130_fd_sc_hd__and2b_1 A_N B VGND VNB VPB VPWR X
.ends

* Black-box entry subcircuit for sky130_fd_sc_hd__nand4_1 abstract view
.subckt sky130_fd_sc_hd__nand4_1 A B C D VGND VNB VPB VPWR Y
.ends

* Black-box entry subcircuit for sky130_fd_sc_hd__a31oi_1 abstract view
.subckt sky130_fd_sc_hd__a31oi_1 A1 A2 A3 B1 VGND VNB VPB VPWR Y
.ends

* Black-box entry subcircuit for sky130_fd_sc_hd__o2111a_1 abstract view
.subckt sky130_fd_sc_hd__o2111a_1 A1 A2 B1 C1 D1 VGND VNB VPB VPWR X
.ends

* Black-box entry subcircuit for sky130_fd_sc_hd__nand3b_4 abstract view
.subckt sky130_fd_sc_hd__nand3b_4 A_N B C VGND VNB VPB VPWR Y
.ends

* Black-box entry subcircuit for sky130_fd_sc_hd__and4bb_1 abstract view
.subckt sky130_fd_sc_hd__and4bb_1 A_N B_N C D VGND VNB VPB VPWR X
.ends

.subckt mult_seq_32x32 VGND VPWR clk done mcand[0] mcand[10] mcand[11] mcand[12] mcand[13]
+ mcand[14] mcand[15] mcand[16] mcand[17] mcand[18] mcand[19] mcand[1] mcand[20] mcand[21]
+ mcand[22] mcand[23] mcand[24] mcand[25] mcand[26] mcand[27] mcand[28] mcand[29]
+ mcand[2] mcand[30] mcand[31] mcand[3] mcand[4] mcand[5] mcand[6] mcand[7] mcand[8]
+ mcand[9] mplier[0] mplier[10] mplier[11] mplier[12] mplier[13] mplier[14] mplier[15]
+ mplier[16] mplier[17] mplier[18] mplier[19] mplier[1] mplier[20] mplier[21] mplier[22]
+ mplier[23] mplier[24] mplier[25] mplier[26] mplier[27] mplier[28] mplier[29] mplier[2]
+ mplier[30] mplier[31] mplier[3] mplier[4] mplier[5] mplier[6] mplier[7] mplier[8]
+ mplier[9] product[0] product[10] product[11] product[12] product[13] product[14]
+ product[15] product[16] product[17] product[18] product[19] product[1] product[20]
+ product[21] product[22] product[23] product[24] product[25] product[26] product[27]
+ product[28] product[29] product[2] product[30] product[31] product[32] product[33]
+ product[34] product[35] product[36] product[37] product[38] product[39] product[3]
+ product[40] product[41] product[42] product[43] product[44] product[45] product[46]
+ product[47] product[48] product[49] product[4] product[50] product[51] product[52]
+ product[53] product[54] product[55] product[56] product[57] product[58] product[59]
+ product[5] product[60] product[61] product[62] product[63] product[6] product[7]
+ product[8] product[9] st
X_501_ _103_ _106_ _121_ _122_ _111_ VGND VGND VPWR VPWR _123_ sky130_fd_sc_hd__o311a_1
XFILLER_0_1_196 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_18_29 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_4_93 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_36_191 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_28_125 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_0_28_103 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
X_895_ clknet_3_7__leaf_clk _006_ VGND VGND VPWR VPWR net96 sky130_fd_sc_hd__dfxtp_2
XFILLER_0_19_169 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_0_19_136 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_0_31_18 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_18_191 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
X_680_ _276_ _278_ _274_ VGND VGND VPWR VPWR _283_ sky130_fd_sc_hd__a21o_1
X_878_ _361_ _437_ VGND VGND VPWR VPWR _438_ sky130_fd_sc_hd__nor2_1
X_947_ clknet_3_2__leaf_clk _058_ VGND VGND VPWR VPWR net82 sky130_fd_sc_hd__dfxtp_1
XFILLER_0_16_139 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_16_128 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
X_594_ _179_ _192_ _195_ _205_ VGND VGND VPWR VPWR _206_ sky130_fd_sc_hd__o31a_1
XFILLER_0_26_29 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_663_ _266_ _267_ VGND VGND VPWR VPWR _268_ sky130_fd_sc_hd__or2_1
X_732_ _325_ _328_ _329_ VGND VGND VPWR VPWR _330_ sky130_fd_sc_hd__a21oi_1
X_801_ net130 _383_ _384_ VGND VGND VPWR VPWR _385_ sky130_fd_sc_hd__mux2_1
Xhold30 net87 VGND VGND VPWR VPWR net160 sky130_fd_sc_hd__dlygate4sd3_1
XFILLER_0_32_50 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_35_201 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XFILLER_0_12_120 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
Xoutput86 net86 VGND VGND VPWR VPWR product[27] sky130_fd_sc_hd__clkbuf_4
X_646_ net145 _210_ _216_ _252_ VGND VGND VPWR VPWR _021_ sky130_fd_sc_hd__o211a_1
X_577_ _181_ _190_ VGND VGND VPWR VPWR _191_ sky130_fd_sc_hd__nand2_1
XTAP_TAPCELL_ROW_26_170 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
Xoutput97 net97 VGND VGND VPWR VPWR product[37] sky130_fd_sc_hd__buf_2
Xoutput75 net75 VGND VGND VPWR VPWR product[17] sky130_fd_sc_hd__buf_2
X_715_ net121 net20 VGND VGND VPWR VPWR _314_ sky130_fd_sc_hd__or2_1
XFILLER_0_27_83 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_7_71 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_500_ net94 net23 _112_ VGND VGND VPWR VPWR _122_ sky130_fd_sc_hd__nand3_1
Xclkbuf_3_6__f_clk clknet_0_clk VGND VGND VPWR VPWR clknet_3_6__leaf_clk sky130_fd_sc_hd__clkbuf_16
X_629_ _078_ _236_ _237_ _087_ VGND VGND VPWR VPWR _019_ sky130_fd_sc_hd__o211a_1
XFILLER_0_34_29 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_0_34_18 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XPHY_EDGE_ROW_21_Right_21 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XPHY_EDGE_ROW_12_Right_12 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_0_4_83 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_36_181 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XPHY_EDGE_ROW_30_Right_30 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
X_894_ clknet_3_6__leaf_clk _005_ VGND VGND VPWR VPWR net95 sky130_fd_sc_hd__dfxtp_1
XFILLER_0_29_6 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_19_148 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_10_53 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_33_140 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_25_129 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
X_877_ contador_act\[1\] contador_act\[0\] _434_ VGND VGND VPWR VPWR _437_ sky130_fd_sc_hd__and3_1
X_946_ clknet_3_2__leaf_clk _057_ VGND VGND VPWR VPWR net81 sky130_fd_sc_hd__dfxtp_1
X_731_ _325_ _328_ _090_ VGND VGND VPWR VPWR _329_ sky130_fd_sc_hd__o21ai_1
X_662_ net115 net14 VGND VGND VPWR VPWR _267_ sky130_fd_sc_hd__nor2_1
Xhold20 net117 VGND VGND VPWR VPWR net150 sky130_fd_sc_hd__dlygate4sd3_1
Xhold31 net68 VGND VGND VPWR VPWR net161 sky130_fd_sc_hd__dlygate4sd3_1
XFILLER_0_1_51 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
X_800_ _075_ VGND VGND VPWR VPWR _384_ sky130_fd_sc_hd__buf_4
X_593_ net106 net5 VGND VGND VPWR VPWR _205_ sky130_fd_sc_hd__or2_1
X_929_ clknet_3_6__leaf_clk _040_ VGND VGND VPWR VPWR net122 sky130_fd_sc_hd__dfxtp_1
XFILLER_0_16_85 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_0_32_62 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XPHY_EDGE_ROW_6_Right_6 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_0_8_126 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
Xoutput98 net98 VGND VGND VPWR VPWR product[38] sky130_fd_sc_hd__buf_2
X_645_ net114 _082_ _099_ _251_ VGND VGND VPWR VPWR _252_ sky130_fd_sc_hd__a211o_1
X_576_ _154_ _185_ _189_ VGND VGND VPWR VPWR _190_ sky130_fd_sc_hd__o21a_1
XTAP_TAPCELL_ROW_26_171 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
X_714_ net121 net20 VGND VGND VPWR VPWR _313_ sky130_fd_sc_hd__nand2_1
Xoutput87 net87 VGND VGND VPWR VPWR product[28] sky130_fd_sc_hd__clkbuf_4
Xoutput76 net76 VGND VGND VPWR VPWR product[18] sky130_fd_sc_hd__clkbuf_4
XFILLER_0_27_95 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_4_195 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
X_628_ net110 _083_ VGND VGND VPWR VPWR _237_ sky130_fd_sc_hd__or2_1
X_559_ net103 net2 VGND VGND VPWR VPWR _174_ sky130_fd_sc_hd__and2_1
XFILLER_0_1_176 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_1_121 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XTAP_TAPCELL_ROW_3_90 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_11_208 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_0_24_85 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
X_893_ clknet_3_6__leaf_clk _004_ VGND VGND VPWR VPWR net94 sky130_fd_sc_hd__dfxtp_2
XFILLER_0_36_160 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_0_19_30 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XTAP_TAPCELL_ROW_0_80 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_9_18 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XPHY_EDGE_ROW_28_Left_65 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XPHY_EDGE_ROW_12_Left_49 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
X_876_ net137 _434_ _436_ VGND VGND VPWR VPWR _067_ sky130_fd_sc_hd__o21a_1
X_945_ clknet_3_2__leaf_clk _056_ VGND VGND VPWR VPWR net80 sky130_fd_sc_hd__dfxtp_1
Xhold10 net107 VGND VGND VPWR VPWR net140 sky130_fd_sc_hd__dlygate4sd3_1
X_592_ _202_ _203_ VGND VGND VPWR VPWR _204_ sky130_fd_sc_hd__nor2_1
X_730_ _326_ _327_ VGND VGND VPWR VPWR _328_ sky130_fd_sc_hd__nor2_1
XFILLER_0_21_133 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
X_661_ net115 net14 VGND VGND VPWR VPWR _266_ sky130_fd_sc_hd__and2_1
Xhold32 net116 VGND VGND VPWR VPWR net162 sky130_fd_sc_hd__dlygate4sd3_1
Xhold21 net89 VGND VGND VPWR VPWR net151 sky130_fd_sc_hd__dlygate4sd3_1
X_928_ clknet_3_0__leaf_clk _039_ VGND VGND VPWR VPWR net111 sky130_fd_sc_hd__dfxtp_1
XFILLER_0_32_85 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_0_32_74 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_32_41 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_29_200 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XTAP_TAPCELL_ROW_29_180 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_16_53 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_0_12_133 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
X_859_ net86 _424_ _407_ VGND VGND VPWR VPWR _425_ sky130_fd_sc_hd__mux2_1
XFILLER_0_8_105 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_8_138 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XFILLER_0_8_149 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
X_644_ _108_ _250_ VGND VGND VPWR VPWR _251_ sky130_fd_sc_hd__nor2_1
X_575_ _182_ _187_ _188_ VGND VGND VPWR VPWR _189_ sky130_fd_sc_hd__and3_1
X_713_ net120 _210_ _216_ _312_ VGND VGND VPWR VPWR _028_ sky130_fd_sc_hd__o211a_1
Xoutput99 net99 VGND VGND VPWR VPWR product[39] sky130_fd_sc_hd__clkbuf_4
Xoutput66 net66 VGND VGND VPWR VPWR done sky130_fd_sc_hd__clkbuf_4
Xoutput88 net88 VGND VGND VPWR VPWR product[29] sky130_fd_sc_hd__clkbuf_4
Xoutput77 net77 VGND VGND VPWR VPWR product[19] sky130_fd_sc_hd__buf_2
XFILLER_0_9_3 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XFILLER_0_27_74 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XPHY_EDGE_ROW_15_Left_52 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
X_558_ net104 net3 VGND VGND VPWR VPWR _173_ sky130_fd_sc_hd__xnor2_1
X_627_ net112 _235_ _090_ VGND VGND VPWR VPWR _236_ sky130_fd_sc_hd__mux2_1
X_489_ net95 net26 VGND VGND VPWR VPWR _112_ sky130_fd_sc_hd__or2_1
XFILLER_0_13_98 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_13_32 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_1_188 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XPHY_EDGE_ROW_0_Left_37 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_0_24_97 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_4_85 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
X_961_ clknet_3_6__leaf_clk _072_ VGND VGND VPWR VPWR contador_act\[5\] sky130_fd_sc_hd__dfxtp_1
X_892_ clknet_3_6__leaf_clk _003_ VGND VGND VPWR VPWR net93 sky130_fd_sc_hd__dfxtp_2
XFILLER_0_28_139 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_19_128 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_875_ _361_ _435_ VGND VGND VPWR VPWR _436_ sky130_fd_sc_hd__nor2_1
X_944_ clknet_3_0__leaf_clk _055_ VGND VGND VPWR VPWR net79 sky130_fd_sc_hd__dfxtp_1
XPHY_EDGE_ROW_3_Left_40 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
X_591_ net107 net6 VGND VGND VPWR VPWR _203_ sky130_fd_sc_hd__nor2_1
X_660_ net114 _210_ _216_ _265_ VGND VGND VPWR VPWR _022_ sky130_fd_sc_hd__o211a_1
XFILLER_0_21_167 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_21_156 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
Xhold11 net69 VGND VGND VPWR VPWR net141 sky130_fd_sc_hd__dlygate4sd3_1
Xhold22 net111 VGND VGND VPWR VPWR net152 sky130_fd_sc_hd__dlygate4sd3_1
XFILLER_0_32_97 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XTAP_TAPCELL_ROW_29_181 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_16_76 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_12_178 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
X_858_ net52 _360_ _409_ net87 VGND VGND VPWR VPWR _424_ sky130_fd_sc_hd__a22o_1
X_927_ clknet_3_0__leaf_clk _038_ VGND VGND VPWR VPWR net100 sky130_fd_sc_hd__dfxtp_1
X_789_ _360_ VGND VGND VPWR VPWR _376_ sky130_fd_sc_hd__clkbuf_4
XFILLER_0_8_117 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
Xoutput67 net67 VGND VGND VPWR VPWR product[0] sky130_fd_sc_hd__clkbuf_4
XFILLER_0_32_3 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
X_712_ net121 _115_ _309_ _311_ _158_ VGND VGND VPWR VPWR _312_ sky130_fd_sc_hd__a221o_1
Xoutput89 net89 VGND VGND VPWR VPWR product[2] sky130_fd_sc_hd__clkbuf_4
Xoutput78 net78 VGND VGND VPWR VPWR product[1] sky130_fd_sc_hd__clkbuf_4
X_643_ _248_ _249_ VGND VGND VPWR VPWR _250_ sky130_fd_sc_hd__xnor2_1
X_574_ _174_ _183_ VGND VGND VPWR VPWR _188_ sky130_fd_sc_hd__nand2_1
XFILLER_0_4_120 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_7_52 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
X_626_ _233_ _234_ VGND VGND VPWR VPWR _235_ sky130_fd_sc_hd__xnor2_1
X_557_ net103 _094_ _101_ _172_ VGND VGND VPWR VPWR _012_ sky130_fd_sc_hd__o211a_1
X_488_ net95 net26 VGND VGND VPWR VPWR _111_ sky130_fd_sc_hd__nand2_1
XFILLER_0_9_201 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
X_609_ _179_ _195_ _205_ VGND VGND VPWR VPWR _219_ sky130_fd_sc_hd__o21ai_1
X_891_ clknet_3_3__leaf_clk _002_ VGND VGND VPWR VPWR net92 sky130_fd_sc_hd__dfxtp_2
X_960_ clknet_3_3__leaf_clk _071_ VGND VGND VPWR VPWR contador_act\[4\] sky130_fd_sc_hd__dfxtp_1
XFILLER_0_4_53 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XFILLER_0_4_64 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XFILLER_0_36_195 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_28_118 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XFILLER_0_19_54 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XFILLER_0_10_45 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_35_20 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XFILLER_0_33_165 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_0_33_121 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XFILLER_0_18_195 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_18_173 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
X_874_ contador_act\[0\] _434_ VGND VGND VPWR VPWR _435_ sky130_fd_sc_hd__and2_1
X_943_ clknet_3_2__leaf_clk _054_ VGND VGND VPWR VPWR net77 sky130_fd_sc_hd__dfxtp_1
X_590_ net107 net6 VGND VGND VPWR VPWR _202_ sky130_fd_sc_hd__and2_1
Xhold23 net109 VGND VGND VPWR VPWR net153 sky130_fd_sc_hd__dlygate4sd3_1
Xhold12 net94 VGND VGND VPWR VPWR net142 sky130_fd_sc_hd__dlygate4sd3_1
XFILLER_0_15_165 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_0_15_154 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
X_788_ _375_ VGND VGND VPWR VPWR _040_ sky130_fd_sc_hd__clkbuf_1
XFILLER_0_16_22 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
X_926_ clknet_3_0__leaf_clk _037_ VGND VGND VPWR VPWR net89 sky130_fd_sc_hd__dfxtp_1
X_857_ _423_ VGND VGND VPWR VPWR _061_ sky130_fd_sc_hd__clkbuf_1
X_642_ _240_ _242_ _238_ VGND VGND VPWR VPWR _249_ sky130_fd_sc_hd__a21boi_1
X_573_ _161_ _186_ _173_ _167_ VGND VGND VPWR VPWR _187_ sky130_fd_sc_hd__or4b_1
XPHY_EDGE_ROW_28_Right_28 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XPHY_EDGE_ROW_19_Right_19 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
X_711_ _308_ _310_ _108_ VGND VGND VPWR VPWR _311_ sky130_fd_sc_hd__a21oi_1
Xoutput79 net79 VGND VGND VPWR VPWR product[20] sky130_fd_sc_hd__clkbuf_4
Xoutput68 net68 VGND VGND VPWR VPWR product[10] sky130_fd_sc_hd__clkbuf_4
Xclkbuf_3_1__f_clk clknet_0_clk VGND VGND VPWR VPWR clknet_3_1__leaf_clk sky130_fd_sc_hd__clkbuf_16
X_909_ clknet_3_7__leaf_clk _020_ VGND VGND VPWR VPWR net112 sky130_fd_sc_hd__dfxtp_1
XFILLER_0_27_65 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_0_27_54 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XFILLER_0_27_32 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_11_9 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_7_86 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XTAP_TAPCELL_ROW_9_109 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
X_625_ _224_ _228_ VGND VGND VPWR VPWR _234_ sky130_fd_sc_hd__nor2_1
X_556_ net104 _095_ _170_ _171_ _158_ VGND VGND VPWR VPWR _172_ sky130_fd_sc_hd__a221o_1
X_487_ net142 _094_ _101_ _110_ VGND VGND VPWR VPWR _004_ sky130_fd_sc_hd__o211a_1
XFILLER_0_1_113 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XTAP_TAPCELL_ROW_20_147 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
X_539_ _154_ _155_ _108_ VGND VGND VPWR VPWR _157_ sky130_fd_sc_hd__a21oi_1
X_608_ _181_ _195_ _196_ _217_ VGND VGND VPWR VPWR _218_ sky130_fd_sc_hd__or4_1
XFILLER_0_4_21 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_0_36_141 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
X_890_ clknet_3_3__leaf_clk _001_ VGND VGND VPWR VPWR estado_act\[1\] sky130_fd_sc_hd__dfxtp_1
XFILLER_0_3_208 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_0_27_163 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_0_19_108 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_33_111 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_18_141 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
X_873_ estado_act\[1\] estado_act\[0\] _074_ _080_ VGND VGND VPWR VPWR _434_ sky130_fd_sc_hd__o211a_1
X_942_ clknet_3_2__leaf_clk _053_ VGND VGND VPWR VPWR net76 sky130_fd_sc_hd__dfxtp_1
XFILLER_0_1_55 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_30_169 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_30_147 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
Xhold13 net92 VGND VGND VPWR VPWR net143 sky130_fd_sc_hd__dlygate4sd3_1
XFILLER_0_15_133 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_15_111 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
Xhold24 net84 VGND VGND VPWR VPWR net154 sky130_fd_sc_hd__dlygate4sd3_1
XFILLER_0_29_214 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
X_787_ net159 _374_ _000_ VGND VGND VPWR VPWR _375_ sky130_fd_sc_hd__mux2_1
XFILLER_0_21_169 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_0_21_125 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_925_ clknet_3_2__leaf_clk _036_ VGND VGND VPWR VPWR net78 sky130_fd_sc_hd__dfxtp_1
X_856_ net85 _422_ _407_ VGND VGND VPWR VPWR _423_ sky130_fd_sc_hd__mux2_1
XFILLER_0_18_3 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XFILLER_0_7_141 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
X_641_ _246_ _247_ VGND VGND VPWR VPWR _248_ sky130_fd_sc_hd__or2b_1
X_572_ net101 net31 net32 net102 VGND VGND VPWR VPWR _186_ sky130_fd_sc_hd__a22oi_1
Xoutput69 net69 VGND VGND VPWR VPWR product[11] sky130_fd_sc_hd__clkbuf_4
X_710_ _292_ _295_ _298_ _305_ VGND VGND VPWR VPWR _310_ sky130_fd_sc_hd__a31o_1
XFILLER_0_32_209 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XTAP_TAPCELL_ROW_32_189 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
X_908_ clknet_3_6__leaf_clk _019_ VGND VGND VPWR VPWR net110 sky130_fd_sc_hd__dfxtp_2
X_839_ _411_ VGND VGND VPWR VPWR _055_ sky130_fd_sc_hd__clkbuf_1
XFILLER_0_7_98 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_7_3 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
X_624_ _231_ _232_ VGND VGND VPWR VPWR _233_ sky130_fd_sc_hd__nor2_1
X_555_ _167_ _169_ _089_ VGND VGND VPWR VPWR _171_ sky130_fd_sc_hd__o21a_1
X_486_ net95 _095_ _107_ _109_ _099_ VGND VGND VPWR VPWR _110_ sky130_fd_sc_hd__a221o_1
XFILLER_0_13_68 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XTAP_TAPCELL_ROW_20_148 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XPHY_EDGE_ROW_19_Left_56 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_0_9_214 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
X_607_ _202_ _203_ _211_ VGND VGND VPWR VPWR _217_ sky130_fd_sc_hd__or3_1
X_538_ _154_ _155_ VGND VGND VPWR VPWR _156_ sky130_fd_sc_hd__or2_1
XFILLER_0_24_67 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_24_56 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
X_469_ _084_ VGND VGND VPWR VPWR _094_ sky130_fd_sc_hd__clkbuf_4
XFILLER_0_6_217 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XFILLER_0_36_197 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XFILLER_0_10_25 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_0_35_55 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_27_175 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_18_197 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_0_18_153 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
X_941_ clknet_3_3__leaf_clk _052_ VGND VGND VPWR VPWR net75 sky130_fd_sc_hd__dfxtp_1
XFILLER_0_21_79 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
X_872_ _433_ VGND VGND VPWR VPWR _066_ sky130_fd_sc_hd__clkbuf_1
XFILLER_0_30_126 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_0_15_145 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
Xhold25 net118 VGND VGND VPWR VPWR net155 sky130_fd_sc_hd__dlygate4sd3_1
Xhold14 net75 VGND VGND VPWR VPWR net144 sky130_fd_sc_hd__dlygate4sd3_1
XFILLER_0_1_23 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
X_786_ net60 _361_ _363_ net127 VGND VGND VPWR VPWR _374_ sky130_fd_sc_hd__a22o_1
X_924_ clknet_3_2__leaf_clk _035_ VGND VGND VPWR VPWR net67 sky130_fd_sc_hd__dfxtp_2
XPHY_EDGE_ROW_7_Left_44 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
X_855_ net51 _360_ _409_ net86 VGND VGND VPWR VPWR _422_ sky130_fd_sc_hd__a22o_1
XFILLER_0_32_89 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_12_126 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_0_12_104 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
X_640_ net113 net11 VGND VGND VPWR VPWR _247_ sky130_fd_sc_hd__nand2_1
X_571_ _155_ _162_ _167_ _184_ VGND VGND VPWR VPWR _185_ sky130_fd_sc_hd__nand4b_1
XPHY_EDGE_ROW_1_Right_1 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_0_7_153 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
X_907_ clknet_3_5__leaf_clk _018_ VGND VGND VPWR VPWR net109 sky130_fd_sc_hd__dfxtp_1
X_769_ _088_ _360_ VGND VGND VPWR VPWR _362_ sky130_fd_sc_hd__nor2_1
X_838_ net79 _410_ _407_ VGND VGND VPWR VPWR _411_ sky130_fd_sc_hd__mux2_1
XFILLER_0_4_112 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_4_156 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_4_189 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
X_623_ net110 net9 VGND VGND VPWR VPWR _232_ sky130_fd_sc_hd__nor2_1
X_554_ _167_ _169_ VGND VGND VPWR VPWR _170_ sky130_fd_sc_hd__nand2_1
X_485_ _103_ _106_ _108_ VGND VGND VPWR VPWR _109_ sky130_fd_sc_hd__a21oi_1
XTAP_TAPCELL_ROW_20_149 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XPHY_EDGE_ROW_36_Left_73 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XPHY_EDGE_ROW_20_Left_57 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XTAP_TAPCELL_ROW_11_116 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
X_537_ net101 net31 VGND VGND VPWR VPWR _155_ sky130_fd_sc_hd__xnor2_1
X_468_ net143 _085_ _087_ _093_ VGND VGND VPWR VPWR _002_ sky130_fd_sc_hd__o211a_1
X_606_ _086_ VGND VGND VPWR VPWR _216_ sky130_fd_sc_hd__clkbuf_4
XFILLER_0_36_121 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_27_187 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
Xclkbuf_3_7__f_clk clknet_0_clk VGND VGND VPWR VPWR clknet_3_7__leaf_clk sky130_fd_sc_hd__clkbuf_16
XTAP_TAPCELL_ROW_0_74 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_33_157 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_18_165 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_24_135 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
X_940_ clknet_3_2__leaf_clk _051_ VGND VGND VPWR VPWR net74 sky130_fd_sc_hd__dfxtp_1
X_871_ net91 _432_ _075_ VGND VGND VPWR VPWR _433_ sky130_fd_sc_hd__mux2_1
XFILLER_0_27_9 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XPHY_EDGE_ROW_23_Left_60 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_0_1_57 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
Xhold15 net113 VGND VGND VPWR VPWR net145 sky130_fd_sc_hd__dlygate4sd3_1
X_923_ clknet_3_1__leaf_clk _034_ VGND VGND VPWR VPWR acu_act\[64\] sky130_fd_sc_hd__dfxtp_1
X_854_ _421_ VGND VGND VPWR VPWR _060_ sky130_fd_sc_hd__clkbuf_1
Xhold26 net78 VGND VGND VPWR VPWR net156 sky130_fd_sc_hd__dlygate4sd3_1
XFILLER_0_32_35 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_0_12_116 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
X_785_ _373_ VGND VGND VPWR VPWR _039_ sky130_fd_sc_hd__clkbuf_1
X_570_ _182_ _183_ VGND VGND VPWR VPWR _184_ sky130_fd_sc_hd__and2_1
XFILLER_0_7_110 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XFILLER_0_7_176 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
X_906_ clknet_3_5__leaf_clk _017_ VGND VGND VPWR VPWR net108 sky130_fd_sc_hd__dfxtp_2
Xclkbuf_0_clk clk VGND VGND VPWR VPWR clknet_0_clk sky130_fd_sc_hd__clkbuf_16
X_699_ _292_ _295_ _298_ _299_ VGND VGND VPWR VPWR _300_ sky130_fd_sc_hd__and4_1
X_837_ net45 _399_ _409_ net80 VGND VGND VPWR VPWR _410_ sky130_fd_sc_hd__a22o_1
X_768_ _360_ VGND VGND VPWR VPWR _361_ sky130_fd_sc_hd__clkbuf_4
XPHY_EDGE_ROW_24_Right_24 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XTAP_TAPCELL_ROW_23_158 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_23_3 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XPHY_EDGE_ROW_15_Right_15 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_0_4_168 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XPHY_EDGE_ROW_33_Right_33 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
X_553_ _168_ _163_ _161_ VGND VGND VPWR VPWR _169_ sky130_fd_sc_hd__a21oi_1
X_622_ net110 net9 VGND VGND VPWR VPWR _231_ sky130_fd_sc_hd__and2_1
X_484_ _081_ VGND VGND VPWR VPWR _108_ sky130_fd_sc_hd__clkbuf_4
XTAP_TAPCELL_ROW_11_117 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
X_605_ net108 _210_ _101_ _215_ VGND VGND VPWR VPWR _017_ sky130_fd_sc_hd__o211a_1
X_536_ _123_ _149_ _153_ VGND VGND VPWR VPWR _154_ sky130_fd_sc_hd__o21ba_1
X_467_ _084_ _092_ VGND VGND VPWR VPWR _093_ sky130_fd_sc_hd__nand2_1
XFILLER_0_14_91 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_36_177 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_36_111 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_35_57 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XTAP_TAPCELL_ROW_0_75 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
X_519_ net99 _095_ _137_ _138_ _099_ VGND VGND VPWR VPWR _139_ sky130_fd_sc_hd__a221o_1
XFILLER_0_27_199 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_27_111 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_33_169 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_33_103 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_21_26 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
X_870_ net57 _360_ _362_ net92 VGND VGND VPWR VPWR _432_ sky130_fd_sc_hd__a22o_1
XFILLER_0_15_169 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_15_158 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_23_180 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_21_106 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
Xhold16 net77 VGND VGND VPWR VPWR net146 sky130_fd_sc_hd__dlygate4sd3_1
Xhold27 net73 VGND VGND VPWR VPWR net157 sky130_fd_sc_hd__dlygate4sd3_1
XFILLER_0_29_206 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_922_ clknet_3_4__leaf_clk _033_ VGND VGND VPWR VPWR net126 sky130_fd_sc_hd__dfxtp_1
XFILLER_0_12_139 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
X_853_ net154 _420_ _407_ VGND VGND VPWR VPWR _421_ sky130_fd_sc_hd__mux2_1
X_784_ net152 _372_ _000_ VGND VGND VPWR VPWR _373_ sky130_fd_sc_hd__mux2_1
XFILLER_0_7_133 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_0_7_166 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XFILLER_0_7_188 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
X_905_ clknet_3_5__leaf_clk _016_ VGND VGND VPWR VPWR net107 sky130_fd_sc_hd__dfxtp_1
XFILLER_0_27_36 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
X_767_ _359_ VGND VGND VPWR VPWR _360_ sky130_fd_sc_hd__buf_2
X_836_ _362_ VGND VGND VPWR VPWR _409_ sky130_fd_sc_hd__clkbuf_4
XFILLER_0_7_57 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_7_79 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
X_698_ net119 net18 VGND VGND VPWR VPWR _299_ sky130_fd_sc_hd__or2_1
X_552_ net102 net32 VGND VGND VPWR VPWR _168_ sky130_fd_sc_hd__nand2_1
X_621_ net153 _210_ _216_ _230_ VGND VGND VPWR VPWR _018_ sky130_fd_sc_hd__o211a_1
XTAP_TAPCELL_ROW_23_159 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
X_483_ _103_ _106_ VGND VGND VPWR VPWR _107_ sky130_fd_sc_hd__or2_1
XFILLER_0_13_49 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XTAP_TAPCELL_ROW_14_126 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
X_819_ net39 _376_ _386_ net74 VGND VGND VPWR VPWR _397_ sky130_fd_sc_hd__a22o_1
XTAP_TAPCELL_ROW_11_118 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
X_604_ net109 _082_ _099_ _214_ VGND VGND VPWR VPWR _215_ sky130_fd_sc_hd__a211o_1
X_535_ _135_ _141_ _150_ _151_ _152_ VGND VGND VPWR VPWR _153_ sky130_fd_sc_hd__a311o_1
XFILLER_0_24_26 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
X_466_ net92 net1 _090_ _091_ VGND VGND VPWR VPWR _092_ sky130_fd_sc_hd__a31o_1
XFILLER_0_14_81 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_0_36_167 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_36_156 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_36_134 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XTAP_TAPCELL_ROW_0_76 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
X_518_ _135_ _136_ _089_ VGND VGND VPWR VPWR _138_ sky130_fd_sc_hd__o21a_1
XFILLER_0_27_167 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
X_449_ estado_act\[1\] estado_act\[0\] VGND VGND VPWR VPWR _076_ sky130_fd_sc_hd__nor2_2
XFILLER_0_2_201 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_2_212 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_33_148 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_25_91 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_0_32_181 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_21_38 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_36_90 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
Xhold28 net72 VGND VGND VPWR VPWR net158 sky130_fd_sc_hd__dlygate4sd3_1
Xhold17 net129 VGND VGND VPWR VPWR net147 sky130_fd_sc_hd__dlygate4sd3_1
XFILLER_0_32_15 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
X_783_ net59 _361_ _363_ net122 VGND VGND VPWR VPWR _372_ sky130_fd_sc_hd__a22o_1
X_921_ clknet_3_1__leaf_clk _032_ VGND VGND VPWR VPWR net125 sky130_fd_sc_hd__dfxtp_2
X_852_ net50 _399_ _409_ net85 VGND VGND VPWR VPWR _420_ sky130_fd_sc_hd__a22o_1
XFILLER_0_27_26 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XTAP_TAPCELL_ROW_26_168 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
X_904_ clknet_3_5__leaf_clk _015_ VGND VGND VPWR VPWR net106 sky130_fd_sc_hd__dfxtp_1
XFILLER_0_27_48 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
X_766_ net65 _076_ VGND VGND VPWR VPWR _359_ sky130_fd_sc_hd__and2_1
XFILLER_0_4_137 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
X_835_ _408_ VGND VGND VPWR VPWR _054_ sky130_fd_sc_hd__clkbuf_1
X_697_ net119 net18 VGND VGND VPWR VPWR _298_ sky130_fd_sc_hd__nand2_2
XFILLER_0_33_91 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_31_202 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
X_620_ net110 _095_ _227_ _229_ _158_ VGND VGND VPWR VPWR _230_ sky130_fd_sc_hd__a221o_1
X_551_ net103 net2 VGND VGND VPWR VPWR _167_ sky130_fd_sc_hd__xor2_2
XFILLER_0_17_70 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XPHY_EDGE_ROW_5_Right_5 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
X_482_ _104_ _105_ VGND VGND VPWR VPWR _106_ sky130_fd_sc_hd__nand2_1
X_749_ _341_ _344_ VGND VGND VPWR VPWR _345_ sky130_fd_sc_hd__nand2_1
X_818_ _396_ VGND VGND VPWR VPWR _049_ sky130_fd_sc_hd__clkbuf_1
XTAP_TAPCELL_ROW_14_127 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_13_28 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_0_0_195 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_0_184 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
X_603_ _108_ _213_ VGND VGND VPWR VPWR _214_ sky130_fd_sc_hd__nor2_1
X_534_ _140_ VGND VGND VPWR VPWR _152_ sky130_fd_sc_hd__inv_2
X_465_ net93 _089_ VGND VGND VPWR VPWR _091_ sky130_fd_sc_hd__nor2_1
XFILLER_0_30_81 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_0_36_146 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_0_36_113 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XFILLER_0_35_37 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
X_517_ _135_ _136_ VGND VGND VPWR VPWR _137_ sky130_fd_sc_hd__nand2_1
XFILLER_0_27_135 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_27_113 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XTAP_TAPCELL_ROW_0_77 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
X_448_ _075_ VGND VGND VPWR VPWR _000_ sky130_fd_sc_hd__buf_4
XFILLER_0_18_135 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_0_32_193 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_0_24_149 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XFILLER_0_24_127 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_1_27 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
Xhold29 net122 VGND VGND VPWR VPWR net159 sky130_fd_sc_hd__dlygate4sd3_1
Xhold18 net104 VGND VGND VPWR VPWR net148 sky130_fd_sc_hd__dlygate4sd3_1
X_920_ clknet_3_4__leaf_clk _031_ VGND VGND VPWR VPWR net124 sky130_fd_sc_hd__dfxtp_1
X_851_ _419_ VGND VGND VPWR VPWR _059_ sky130_fd_sc_hd__clkbuf_1
XTAP_TAPCELL_ROW_6_98 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
X_782_ _371_ VGND VGND VPWR VPWR _038_ sky130_fd_sc_hd__clkbuf_1
XPHY_EDGE_ROW_27_Left_64 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_0_22_71 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_0_20_141 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XPHY_EDGE_ROW_11_Left_48 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_0_7_113 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XTAP_TAPCELL_ROW_26_169 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_11_196 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_2_70 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XFILLER_0_2_81 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
X_903_ clknet_3_5__leaf_clk _014_ VGND VGND VPWR VPWR net105 sky130_fd_sc_hd__dfxtp_2
XFILLER_0_25_211 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
X_765_ _358_ VGND VGND VPWR VPWR _034_ sky130_fd_sc_hd__clkbuf_1
X_696_ net155 _210_ _216_ _297_ VGND VGND VPWR VPWR _026_ sky130_fd_sc_hd__o211a_1
X_834_ net146 _406_ _407_ VGND VGND VPWR VPWR _408_ sky130_fd_sc_hd__mux2_1
XFILLER_0_17_82 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
X_550_ _078_ _165_ _166_ _087_ VGND VGND VPWR VPWR _011_ sky130_fd_sc_hd__o211a_1
X_481_ net94 net23 VGND VGND VPWR VPWR _105_ sky130_fd_sc_hd__or2_1
XPHY_EDGE_ROW_20_Right_20 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
X_817_ net158 _395_ _384_ VGND VGND VPWR VPWR _396_ sky130_fd_sc_hd__mux2_1
XTAP_TAPCELL_ROW_14_128 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XPHY_EDGE_ROW_11_Right_11 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XTAP_TAPCELL_ROW_3_88 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
X_748_ _333_ _342_ _343_ _325_ VGND VGND VPWR VPWR _344_ sky130_fd_sc_hd__a22o_1
X_679_ net117 net16 VGND VGND VPWR VPWR _282_ sky130_fd_sc_hd__xor2_2
XFILLER_0_0_163 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
X_602_ _211_ _212_ VGND VGND VPWR VPWR _213_ sky130_fd_sc_hd__xnor2_1
X_533_ _143_ _141_ VGND VGND VPWR VPWR _151_ sky130_fd_sc_hd__and2_1
X_464_ _089_ VGND VGND VPWR VPWR _090_ sky130_fd_sc_hd__buf_4
XPHY_EDGE_ROW_14_Left_51 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_0_4_27 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
Xclkbuf_3_2__f_clk clknet_0_clk VGND VGND VPWR VPWR clknet_3_2__leaf_clk sky130_fd_sc_hd__clkbuf_16
XFILLER_0_36_169 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XFILLER_0_30_93 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
X_516_ _118_ _124_ _128_ _129_ VGND VGND VPWR VPWR _136_ sky130_fd_sc_hd__o31a_1
XFILLER_0_27_147 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_27_125 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
X_447_ net65 estado_act\[1\] estado_act\[0\] _074_ VGND VGND VPWR VPWR _075_ sky130_fd_sc_hd__o31a_2
XTAP_TAPCELL_ROW_0_78 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_18_103 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_21_18 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
Xhold19 net101 VGND VGND VPWR VPWR net149 sky130_fd_sc_hd__dlygate4sd3_1
XFILLER_0_1_39 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_1_17 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_0_16_29 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
X_850_ net83 _418_ _407_ VGND VGND VPWR VPWR _419_ sky130_fd_sc_hd__mux2_1
X_781_ net100 _370_ _000_ VGND VGND VPWR VPWR _371_ sky130_fd_sc_hd__mux2_1
XTAP_TAPCELL_ROW_6_99 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_7_125 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XFILLER_0_27_17 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
X_902_ clknet_3_4__leaf_clk _013_ VGND VGND VPWR VPWR net104 sky130_fd_sc_hd__dfxtp_2
XTAP_TAPCELL_ROW_17_137 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
X_764_ _086_ _357_ VGND VGND VPWR VPWR _358_ sky130_fd_sc_hd__and2_1
X_695_ net119 _115_ _295_ _296_ _158_ VGND VGND VPWR VPWR _297_ sky130_fd_sc_hd__a221o_1
X_833_ _075_ VGND VGND VPWR VPWR _407_ sky130_fd_sc_hd__clkbuf_4
XFILLER_0_17_94 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_3_172 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XTAP_TAPCELL_ROW_8_105 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_22_215 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
X_480_ net94 net23 VGND VGND VPWR VPWR _104_ sky130_fd_sc_hd__nand2_1
XTAP_TAPCELL_ROW_14_129 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_3_89 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
X_747_ _328_ _332_ _333_ VGND VGND VPWR VPWR _343_ sky130_fd_sc_hd__and3_1
X_678_ net162 _210_ _216_ _281_ VGND VGND VPWR VPWR _024_ sky130_fd_sc_hd__o211a_1
X_816_ net38 _376_ _386_ net73 VGND VGND VPWR VPWR _395_ sky130_fd_sc_hd__a22o_1
X_601_ _204_ _206_ _202_ VGND VGND VPWR VPWR _212_ sky130_fd_sc_hd__a21oi_1
X_532_ _118_ _128_ _129_ VGND VGND VPWR VPWR _150_ sky130_fd_sc_hd__o21a_1
XFILLER_0_24_29 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XFILLER_0_24_18 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_463_ _088_ VGND VGND VPWR VPWR _089_ sky130_fd_sc_hd__clkbuf_4
XFILLER_0_14_73 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_14_51 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_0_5_201 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
X_515_ net98 net29 VGND VGND VPWR VPWR _135_ sky130_fd_sc_hd__xor2_2
XFILLER_0_19_18 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
X_446_ estado_act\[1\] net67 estado_act\[0\] VGND VGND VPWR VPWR _074_ sky130_fd_sc_hd__o21ai_1
XTAP_TAPCELL_ROW_0_79 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_35_181 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_15_107 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
Xinput1 mcand[0] VGND VGND VPWR VPWR net1 sky130_fd_sc_hd__clkbuf_2
X_780_ net58 _361_ _363_ net111 VGND VGND VPWR VPWR _370_ sky130_fd_sc_hd__a22o_1
XTAP_TAPCELL_ROW_29_179 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_22_62 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_0_7_137 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
X_901_ clknet_3_4__leaf_clk _012_ VGND VGND VPWR VPWR net103 sky130_fd_sc_hd__dfxtp_2
XTAP_TAPCELL_ROW_17_138 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
X_763_ acu_act\[64\] _077_ _356_ _089_ VGND VGND VPWR VPWR _357_ sky130_fd_sc_hd__a22o_1
X_694_ _291_ _294_ _108_ VGND VGND VPWR VPWR _296_ sky130_fd_sc_hd__a21oi_1
XFILLER_0_6_170 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_832_ net43 _399_ _386_ net79 VGND VGND VPWR VPWR _406_ sky130_fd_sc_hd__a22o_1
XFILLER_0_17_40 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_16_213 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XFILLER_0_3_184 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XTAP_TAPCELL_ROW_8_106 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
X_746_ _326_ _332_ VGND VGND VPWR VPWR _342_ sky130_fd_sc_hd__or2b_1
X_677_ net117 _115_ _279_ _280_ _158_ VGND VGND VPWR VPWR _281_ sky130_fd_sc_hd__a221o_1
X_815_ _394_ VGND VGND VPWR VPWR _048_ sky130_fd_sc_hd__clkbuf_1
XPHY_EDGE_ROW_9_Right_9 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_0_0_154 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_0_28_83 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_8_93 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
X_600_ net108 net7 VGND VGND VPWR VPWR _211_ sky130_fd_sc_hd__xnor2_1
X_531_ _120_ _130_ _148_ VGND VGND VPWR VPWR _149_ sky130_fd_sc_hd__nand3b_1
X_462_ estado_act\[1\] estado_act\[0\] net67 VGND VGND VPWR VPWR _088_ sky130_fd_sc_hd__and3b_1
XFILLER_0_4_29 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_729_ net123 net21 VGND VGND VPWR VPWR _327_ sky130_fd_sc_hd__nor2_1
XFILLER_0_35_29 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_514_ _078_ _133_ _134_ _087_ VGND VGND VPWR VPWR _007_ sky130_fd_sc_hd__o211a_1
XFILLER_0_35_193 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_445_ _073_ VGND VGND VPWR VPWR net66 sky130_fd_sc_hd__dlymetal6s2s_1
XFILLER_0_26_182 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_0_5_94 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XFILLER_0_32_141 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_23_152 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_0_11_75 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_0_11_42 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_36_83 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_36_72 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_14_141 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
Xinput2 mcand[10] VGND VGND VPWR VPWR net2 sky130_fd_sc_hd__clkbuf_2
XFILLER_0_28_200 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_22_85 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
X_900_ clknet_3_4__leaf_clk _011_ VGND VGND VPWR VPWR net102 sky130_fd_sc_hd__dfxtp_2
XFILLER_0_19_200 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
X_762_ _349_ _352_ _350_ VGND VGND VPWR VPWR _356_ sky130_fd_sc_hd__a21bo_1
X_693_ _291_ _294_ VGND VGND VPWR VPWR _295_ sky130_fd_sc_hd__or2_2
X_831_ _405_ VGND VGND VPWR VPWR _053_ sky130_fd_sc_hd__clkbuf_1
XTAP_TAPCELL_ROW_17_139 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_4_108 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_0_7_29 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
Xinput60 mplier[5] VGND VGND VPWR VPWR net60 sky130_fd_sc_hd__buf_1
XTAP_TAPCELL_ROW_31_186 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_3_152 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_3_196 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XTAP_TAPCELL_ROW_8_107 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
X_676_ _276_ _278_ _089_ VGND VGND VPWR VPWR _280_ sky130_fd_sc_hd__o21a_1
X_745_ _339_ _340_ VGND VGND VPWR VPWR _341_ sky130_fd_sc_hd__nor2_1
X_814_ net71 _393_ _384_ VGND VGND VPWR VPWR _394_ sky130_fd_sc_hd__mux2_1
XFILLER_0_21_6 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_0_133 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_0_8_83 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
X_530_ _135_ _140_ _141_ VGND VGND VPWR VPWR _148_ sky130_fd_sc_hd__and3_1
X_461_ _086_ VGND VGND VPWR VPWR _087_ sky130_fd_sc_hd__clkbuf_4
XTAP_TAPCELL_ROW_10_112 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
X_659_ net115 _115_ _263_ _264_ _158_ VGND VGND VPWR VPWR _265_ sky130_fd_sc_hd__a221o_1
X_728_ net123 net21 VGND VGND VPWR VPWR _326_ sky130_fd_sc_hd__and2_1
XPHY_EDGE_ROW_18_Left_55 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
X_513_ net97 _083_ VGND VGND VPWR VPWR _134_ sky130_fd_sc_hd__or2_1
XFILLER_0_25_52 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
X_444_ estado_act\[1\] estado_act\[0\] VGND VGND VPWR VPWR _073_ sky130_fd_sc_hd__and2_1
XFILLER_0_26_161 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_0_18_139 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_32_197 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_32_153 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
Xinput3 mcand[11] VGND VGND VPWR VPWR net3 sky130_fd_sc_hd__buf_1
XPHY_EDGE_ROW_27_Right_27 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XPHY_EDGE_ROW_18_Right_18 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_0_11_54 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XPHY_EDGE_ROW_36_Right_36 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_0_20_101 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_0_14_197 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XFILLER_0_14_186 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XFILLER_0_14_153 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_22_75 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_11_156 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_0_11_134 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
X_761_ _348_ _355_ _087_ VGND VGND VPWR VPWR _033_ sky130_fd_sc_hd__o21a_1
XFILLER_0_2_41 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
X_830_ net76 _404_ _384_ VGND VGND VPWR VPWR _405_ sky130_fd_sc_hd__mux2_1
XFILLER_0_25_215 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
X_959_ clknet_3_3__leaf_clk _070_ VGND VGND VPWR VPWR contador_act\[3\] sky130_fd_sc_hd__dfxtp_1
X_692_ _292_ _293_ VGND VGND VPWR VPWR _294_ sky130_fd_sc_hd__nand2_1
XPHY_EDGE_ROW_6_Left_43 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_0_33_52 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XTAP_TAPCELL_ROW_31_187 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
Xinput50 mplier[25] VGND VGND VPWR VPWR net50 sky130_fd_sc_hd__buf_1
Xinput61 mplier[6] VGND VGND VPWR VPWR net61 sky130_fd_sc_hd__clkbuf_1
XTAP_TAPCELL_ROW_8_108 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XPHY_EDGE_ROW_32_Left_69 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XTAP_TAPCELL_ROW_22_154 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
X_675_ _276_ _278_ VGND VGND VPWR VPWR _279_ sky130_fd_sc_hd__nand2_1
X_744_ net125 net24 VGND VGND VPWR VPWR _340_ sky130_fd_sc_hd__nor2_1
X_813_ net37 _376_ _386_ net72 VGND VGND VPWR VPWR _393_ sky130_fd_sc_hd__a22o_1
XPHY_EDGE_ROW_0_Right_0 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_0_28_85 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_13_218 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_0_189 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_0_0_167 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
X_460_ net65 _076_ VGND VGND VPWR VPWR _086_ sky130_fd_sc_hd__nand2_4
XTAP_TAPCELL_ROW_10_113 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_5_9 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
X_589_ _078_ _200_ _201_ _087_ VGND VGND VPWR VPWR _015_ sky130_fd_sc_hd__o211a_1
X_658_ _256_ _262_ _089_ VGND VGND VPWR VPWR _264_ sky130_fd_sc_hd__o21a_1
X_727_ _291_ _321_ _324_ VGND VGND VPWR VPWR _325_ sky130_fd_sc_hd__o21bai_2
XTAP_TAPCELL_ROW_4_91 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_36_107 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XPHY_EDGE_ROW_35_Left_72 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
X_512_ net98 _132_ _090_ VGND VGND VPWR VPWR _133_ sky130_fd_sc_hd__mux2_1
XFILLER_0_27_129 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_27_107 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_0_25_75 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_25_31 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_1_3 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XFILLER_0_36_85 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XFILLER_0_36_41 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XFILLER_0_23_121 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
Xinput4 mcand[12] VGND VGND VPWR VPWR net4 sky130_fd_sc_hd__buf_1
XTAP_TAPCELL_ROW_1_81 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_34_205 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XTAP_TAPCELL_ROW_34_196 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
X_760_ acu_act\[64\] _090_ _353_ _354_ _084_ VGND VGND VPWR VPWR _355_ sky130_fd_sc_hd__o221a_1
X_691_ net118 net17 VGND VGND VPWR VPWR _293_ sky130_fd_sc_hd__or2_1
Xinput62 mplier[7] VGND VGND VPWR VPWR net62 sky130_fd_sc_hd__dlymetal6s2s_1
Xinput51 mplier[26] VGND VGND VPWR VPWR net51 sky130_fd_sc_hd__buf_1
XTAP_TAPCELL_ROW_31_188 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
X_958_ clknet_3_3__leaf_clk _069_ VGND VGND VPWR VPWR contador_act\[2\] sky130_fd_sc_hd__dfxtp_1
Xinput40 mplier[16] VGND VGND VPWR VPWR net40 sky130_fd_sc_hd__clkbuf_1
X_889_ clknet_3_3__leaf_clk _000_ VGND VGND VPWR VPWR estado_act\[0\] sky130_fd_sc_hd__dfxtp_2
XTAP_TAPCELL_ROW_22_155 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
X_674_ _266_ _270_ _277_ VGND VGND VPWR VPWR _278_ sky130_fd_sc_hd__o21a_1
X_743_ net125 net24 VGND VGND VPWR VPWR _339_ sky130_fd_sc_hd__and2_1
X_812_ _392_ VGND VGND VPWR VPWR _047_ sky130_fd_sc_hd__clkbuf_1
XTAP_TAPCELL_ROW_36_203 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_28_97 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_0_0_102 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_0_8_63 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_8_85 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_588_ net106 _083_ VGND VGND VPWR VPWR _201_ sky130_fd_sc_hd__or2_1
X_657_ _256_ _262_ VGND VGND VPWR VPWR _263_ sky130_fd_sc_hd__nand2_1
XTAP_TAPCELL_ROW_10_114 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
X_726_ net121 net20 _319_ _322_ _323_ VGND VGND VPWR VPWR _324_ sky130_fd_sc_hd__a221o_1
XTAP_TAPCELL_ROW_4_92 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
X_511_ _130_ _131_ VGND VGND VPWR VPWR _132_ sky130_fd_sc_hd__xnor2_1
X_709_ _292_ _295_ _298_ _305_ _308_ VGND VGND VPWR VPWR _309_ sky130_fd_sc_hd__a311o_1
XFILLER_0_32_133 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_0_17_141 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_36_97 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
Xinput5 mcand[13] VGND VGND VPWR VPWR net5 sky130_fd_sc_hd__buf_1
XFILLER_0_23_111 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XTAP_TAPCELL_ROW_1_82 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_20_158 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_9_160 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XTAP_TAPCELL_ROW_34_197 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_22_66 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_11_169 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_690_ net118 net17 VGND VGND VPWR VPWR _292_ sky130_fd_sc_hd__nand2_2
Xinput63 mplier[8] VGND VGND VPWR VPWR net63 sky130_fd_sc_hd__buf_1
Xinput41 mplier[17] VGND VGND VPWR VPWR net41 sky130_fd_sc_hd__buf_1
XFILLER_0_33_87 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
X_888_ _443_ VGND VGND VPWR VPWR _072_ sky130_fd_sc_hd__clkbuf_1
Xinput30 mcand[7] VGND VGND VPWR VPWR net30 sky130_fd_sc_hd__buf_1
X_957_ clknet_3_3__leaf_clk _068_ VGND VGND VPWR VPWR contador_act\[1\] sky130_fd_sc_hd__dfxtp_1
Xinput52 mplier[27] VGND VGND VPWR VPWR net52 sky130_fd_sc_hd__clkbuf_1
XFILLER_0_3_122 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_0_3_144 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_35_3 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XFILLER_0_22_209 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XTAP_TAPCELL_ROW_22_156 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
X_811_ net70 _391_ _384_ VGND VGND VPWR VPWR _392_ sky130_fd_sc_hd__mux2_1
XFILLER_0_28_65 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
X_673_ _267_ VGND VGND VPWR VPWR _277_ sky130_fd_sc_hd__inv_2
X_742_ net124 _084_ _216_ _338_ VGND VGND VPWR VPWR _031_ sky130_fd_sc_hd__o211a_1
XTAP_TAPCELL_ROW_13_123 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_36_204 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_8_75 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_656_ _223_ _258_ _259_ _261_ VGND VGND VPWR VPWR _262_ sky130_fd_sc_hd__o211ai_4
X_587_ _197_ _199_ net107 _090_ VGND VGND VPWR VPWR _200_ sky130_fd_sc_hd__o2bb2a_1
XFILLER_0_14_23 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XTAP_TAPCELL_ROW_10_115 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
X_725_ net120 net19 _314_ VGND VGND VPWR VPWR _323_ sky130_fd_sc_hd__and3_1
XTAP_TAPCELL_ROW_4_93 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
X_510_ _118_ _124_ VGND VGND VPWR VPWR _131_ sky130_fd_sc_hd__nor2_1
X_639_ net113 net11 VGND VGND VPWR VPWR _246_ sky130_fd_sc_hd__nor2_1
XFILLER_0_26_197 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
X_708_ _306_ _307_ VGND VGND VPWR VPWR _308_ sky130_fd_sc_hd__nand2_1
XFILLER_0_17_186 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_5_21 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_23_189 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_0_23_167 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_11_79 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_11_57 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XTAP_TAPCELL_ROW_1_83 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_36_54 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XFILLER_0_14_123 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
Xinput6 mcand[14] VGND VGND VPWR VPWR net6 sky130_fd_sc_hd__buf_1
XPHY_EDGE_ROW_23_Right_23 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_0_20_137 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XPHY_EDGE_ROW_14_Right_14 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
Xclkbuf_3_3__f_clk clknet_0_clk VGND VGND VPWR VPWR clknet_3_3__leaf_clk sky130_fd_sc_hd__clkbuf_16
XPHY_EDGE_ROW_32_Right_32 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_0_28_204 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_11_104 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_2_11 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XTAP_TAPCELL_ROW_34_198 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_25_165 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_6_197 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
Xinput20 mcand[27] VGND VGND VPWR VPWR net20 sky130_fd_sc_hd__buf_1
XFILLER_0_33_22 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
Xinput31 mcand[8] VGND VGND VPWR VPWR net31 sky130_fd_sc_hd__buf_1
X_887_ net135 _086_ VGND VGND VPWR VPWR _443_ sky130_fd_sc_hd__and2_1
X_956_ clknet_3_3__leaf_clk _067_ VGND VGND VPWR VPWR contador_act\[0\] sky130_fd_sc_hd__dfxtp_1
Xinput53 mplier[28] VGND VGND VPWR VPWR net53 sky130_fd_sc_hd__buf_1
Xinput64 mplier[9] VGND VGND VPWR VPWR net64 sky130_fd_sc_hd__clkbuf_1
Xinput42 mplier[18] VGND VGND VPWR VPWR net42 sky130_fd_sc_hd__buf_1
XFILLER_0_28_3 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XTAP_TAPCELL_ROW_22_157 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_3_167 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_21_210 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
X_672_ _274_ _275_ VGND VGND VPWR VPWR _276_ sky130_fd_sc_hd__nor2_1
X_741_ net125 _082_ _099_ _337_ VGND VGND VPWR VPWR _338_ sky130_fd_sc_hd__a211o_1
XTAP_TAPCELL_ROW_13_124 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
X_810_ net36 _376_ _386_ net71 VGND VGND VPWR VPWR _391_ sky130_fd_sc_hd__a22o_1
XFILLER_0_0_126 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XTAP_TAPCELL_ROW_36_205 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_14_9 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XPHY_EDGE_ROW_4_Right_4 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
X_939_ clknet_3_1__leaf_clk _050_ VGND VGND VPWR VPWR net73 sky130_fd_sc_hd__dfxtp_1
X_724_ _292_ _298_ _305_ VGND VGND VPWR VPWR _322_ sky130_fd_sc_hd__a21oi_1
X_586_ _108_ _198_ VGND VGND VPWR VPWR _199_ sky130_fd_sc_hd__nor2_1
X_655_ _232_ _257_ _260_ VGND VGND VPWR VPWR _261_ sky130_fd_sc_hd__or3_1
XTAP_TAPCELL_ROW_4_94 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
X_638_ net139 _210_ _216_ _245_ VGND VGND VPWR VPWR _020_ sky130_fd_sc_hd__o211a_1
X_569_ net104 net3 VGND VGND VPWR VPWR _183_ sky130_fd_sc_hd__or2_1
XFILLER_0_26_110 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_25_12 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
X_707_ net120 net19 VGND VGND VPWR VPWR _307_ sky130_fd_sc_hd__or2_1
XFILLER_0_26_165 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_17_198 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_0_5_33 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_0_32_157 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_23_113 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XFILLER_0_36_66 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
Xinput7 mcand[15] VGND VGND VPWR VPWR net7 sky130_fd_sc_hd__buf_1
XFILLER_0_36_22 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XFILLER_0_20_105 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_28_216 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_0_2_23 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XTAP_TAPCELL_ROW_34_199 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
Xoutput130 net130 VGND VGND VPWR VPWR product[9] sky130_fd_sc_hd__clkbuf_4
XFILLER_0_10_193 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XTAP_TAPCELL_ROW_25_166 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_17_57 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_0_17_35 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
X_886_ _361_ net132 VGND VGND VPWR VPWR _071_ sky130_fd_sc_hd__nor2_1
XTAP_TAPCELL_ROW_16_133 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
X_955_ clknet_3_3__leaf_clk _066_ VGND VGND VPWR VPWR net91 sky130_fd_sc_hd__dfxtp_1
Xinput10 mcand[18] VGND VGND VPWR VPWR net10 sky130_fd_sc_hd__clkbuf_1
Xinput54 mplier[29] VGND VGND VPWR VPWR net54 sky130_fd_sc_hd__buf_1
Xinput32 mcand[9] VGND VGND VPWR VPWR net32 sky130_fd_sc_hd__clkbuf_2
XPHY_EDGE_ROW_26_Left_63 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
Xinput21 mcand[28] VGND VGND VPWR VPWR net21 sky130_fd_sc_hd__buf_1
Xinput65 st VGND VGND VPWR VPWR net65 sky130_fd_sc_hd__clkbuf_2
XPHY_EDGE_ROW_10_Left_47 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
Xinput43 mplier[19] VGND VGND VPWR VPWR net43 sky130_fd_sc_hd__clkbuf_1
X_740_ _108_ _336_ VGND VGND VPWR VPWR _337_ sky130_fd_sc_hd__nor2_1
X_671_ net116 net15 VGND VGND VPWR VPWR _275_ sky130_fd_sc_hd__nor2_1
XTAP_TAPCELL_ROW_13_125 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_36_206 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_28_45 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
X_938_ clknet_3_1__leaf_clk _049_ VGND VGND VPWR VPWR net72 sky130_fd_sc_hd__dfxtp_1
X_869_ _431_ VGND VGND VPWR VPWR _065_ sky130_fd_sc_hd__clkbuf_1
X_654_ _224_ _231_ VGND VGND VPWR VPWR _260_ sky130_fd_sc_hd__nor2_1
XFILLER_0_30_13 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
X_585_ _179_ _192_ _195_ _196_ VGND VGND VPWR VPWR _198_ sky130_fd_sc_hd__o22a_1
X_723_ _320_ VGND VGND VPWR VPWR _321_ sky130_fd_sc_hd__inv_2
XPHY_EDGE_ROW_13_Left_50 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_0_35_144 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XFILLER_0_35_122 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
X_637_ net113 _095_ _243_ _244_ _158_ VGND VGND VPWR VPWR _245_ sky130_fd_sc_hd__a221o_1
XFILLER_0_25_57 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
X_706_ net120 net19 VGND VGND VPWR VPWR _306_ sky130_fd_sc_hd__nand2_1
X_568_ net104 net3 VGND VGND VPWR VPWR _182_ sky130_fd_sc_hd__nand2_1
XFILLER_0_26_122 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
X_499_ net95 net26 VGND VGND VPWR VPWR _121_ sky130_fd_sc_hd__nor2_1
XFILLER_0_5_67 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XFILLER_0_32_169 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_23_169 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
Xinput8 mcand[16] VGND VGND VPWR VPWR net8 sky130_fd_sc_hd__buf_1
XFILLER_0_14_103 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_22_180 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_0_9_130 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XTAP_TAPCELL_ROW_28_175 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_11_117 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
Xoutput120 net120 VGND VGND VPWR VPWR product[58] sky130_fd_sc_hd__clkbuf_4
XTAP_TAPCELL_ROW_25_167 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
X_885_ contador_act\[3\] _439_ net131 VGND VGND VPWR VPWR _442_ sky130_fd_sc_hd__a21oi_1
X_954_ clknet_3_2__leaf_clk _065_ VGND VGND VPWR VPWR net90 sky130_fd_sc_hd__dfxtp_1
Xinput11 mcand[19] VGND VGND VPWR VPWR net11 sky130_fd_sc_hd__buf_1
Xinput44 mplier[1] VGND VGND VPWR VPWR net44 sky130_fd_sc_hd__buf_1
Xinput22 mcand[29] VGND VGND VPWR VPWR net22 sky130_fd_sc_hd__buf_1
XTAP_TAPCELL_ROW_16_134 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
Xinput55 mplier[2] VGND VGND VPWR VPWR net55 sky130_fd_sc_hd__clkbuf_1
XFILLER_0_3_103 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
Xinput33 mplier[0] VGND VGND VPWR VPWR net33 sky130_fd_sc_hd__clkbuf_1
XFILLER_0_30_212 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
X_670_ net116 net15 VGND VGND VPWR VPWR _274_ sky130_fd_sc_hd__and2_1
XTAP_TAPCELL_ROW_7_102 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_36_207 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_28_57 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_799_ net64 _376_ _363_ net68 VGND VGND VPWR VPWR _383_ sky130_fd_sc_hd__a22o_1
X_937_ clknet_3_1__leaf_clk _048_ VGND VGND VPWR VPWR net71 sky130_fd_sc_hd__dfxtp_1
XFILLER_0_0_139 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
X_868_ net90 _430_ _075_ VGND VGND VPWR VPWR _431_ sky130_fd_sc_hd__mux2_1
X_653_ _238_ _246_ _247_ VGND VGND VPWR VPWR _259_ sky130_fd_sc_hd__o21a_1
X_584_ _179_ _192_ _195_ _196_ VGND VGND VPWR VPWR _197_ sky130_fd_sc_hd__or4_1
XFILLER_0_14_15 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
X_722_ _294_ _298_ _299_ _319_ VGND VGND VPWR VPWR _320_ sky130_fd_sc_hd__and4b_1
XFILLER_0_35_167 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
X_636_ _240_ _242_ _089_ VGND VGND VPWR VPWR _244_ sky130_fd_sc_hd__o21a_1
X_498_ _118_ _119_ VGND VGND VPWR VPWR _120_ sky130_fd_sc_hd__or2_1
X_567_ _179_ _180_ VGND VGND VPWR VPWR _181_ sky130_fd_sc_hd__or2_1
X_705_ net119 net18 VGND VGND VPWR VPWR _305_ sky130_fd_sc_hd__nor2_1
Xinput9 mcand[17] VGND VGND VPWR VPWR net9 sky130_fd_sc_hd__buf_1
XFILLER_0_36_79 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
X_619_ _081_ _228_ VGND VGND VPWR VPWR _229_ sky130_fd_sc_hd__nor2_1
XFILLER_0_23_159 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_11_27 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_0_14_115 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_9_197 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XTAP_TAPCELL_ROW_28_176 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
Xoutput110 net110 VGND VGND VPWR VPWR product[49] sky130_fd_sc_hd__clkbuf_4
XPHY_EDGE_ROW_10_Right_10 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
Xoutput121 net121 VGND VGND VPWR VPWR product[59] sky130_fd_sc_hd__clkbuf_4
XFILLER_0_6_101 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_6_178 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
X_953_ clknet_3_2__leaf_clk _064_ VGND VGND VPWR VPWR net88 sky130_fd_sc_hd__dfxtp_1
Xinput34 mplier[10] VGND VGND VPWR VPWR net34 sky130_fd_sc_hd__buf_1
Xinput56 mplier[30] VGND VGND VPWR VPWR net56 sky130_fd_sc_hd__buf_1
Xinput12 mcand[1] VGND VGND VPWR VPWR net12 sky130_fd_sc_hd__buf_1
XFILLER_0_17_48 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XTAP_TAPCELL_ROW_16_135 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
X_884_ net134 _439_ _441_ VGND VGND VPWR VPWR _070_ sky130_fd_sc_hd__a21oi_1
Xinput23 mcand[2] VGND VGND VPWR VPWR net23 sky130_fd_sc_hd__buf_1
Xinput45 mplier[20] VGND VGND VPWR VPWR net45 sky130_fd_sc_hd__clkbuf_1
XTAP_TAPCELL_ROW_30_182 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_2_181 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XTAP_TAPCELL_ROW_7_103 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_36_208 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_28_25 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
X_936_ clknet_3_1__leaf_clk _047_ VGND VGND VPWR VPWR net70 sky130_fd_sc_hd__dfxtp_1
X_867_ net56 _360_ _362_ net91 VGND VGND VPWR VPWR _430_ sky130_fd_sc_hd__a22o_1
X_798_ _382_ VGND VGND VPWR VPWR _043_ sky130_fd_sc_hd__clkbuf_1
XFILLER_0_30_37 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
X_652_ _226_ _231_ _232_ _257_ VGND VGND VPWR VPWR _258_ sky130_fd_sc_hd__or4_1
X_583_ net106 net5 VGND VGND VPWR VPWR _196_ sky130_fd_sc_hd__nor2_1
XFILLER_0_14_27 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
X_721_ _306_ _307_ _313_ _314_ VGND VGND VPWR VPWR _319_ sky130_fd_sc_hd__and4_1
X_919_ clknet_3_4__leaf_clk _030_ VGND VGND VPWR VPWR net123 sky130_fd_sc_hd__dfxtp_1
Xhold1 contador_act\[4\] VGND VGND VPWR VPWR net131 sky130_fd_sc_hd__dlygate4sd3_1
XPHY_EDGE_ROW_8_Right_8 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_0_35_113 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
X_635_ _240_ _242_ VGND VGND VPWR VPWR _243_ sky130_fd_sc_hd__nand2_1
X_497_ net96 net27 VGND VGND VPWR VPWR _119_ sky130_fd_sc_hd__nor2_1
X_566_ net105 net4 VGND VGND VPWR VPWR _180_ sky130_fd_sc_hd__nor2_1
X_704_ _078_ _303_ _304_ _087_ VGND VGND VPWR VPWR _027_ sky130_fd_sc_hd__o211a_1
XFILLER_0_32_116 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_31_91 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_23_105 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
X_618_ _223_ _226_ VGND VGND VPWR VPWR _228_ sky130_fd_sc_hd__nor2_1
X_549_ net102 _083_ VGND VGND VPWR VPWR _166_ sky130_fd_sc_hd__or2_1
XTAP_TAPCELL_ROW_28_177 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_22_38 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_9_187 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XFILLER_0_9_165 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_0_9_110 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XTAP_TAPCELL_ROW_19_144 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
Xoutput100 net100 VGND VGND VPWR VPWR product[3] sky130_fd_sc_hd__clkbuf_4
Xoutput122 net122 VGND VGND VPWR VPWR product[5] sky130_fd_sc_hd__buf_2
XFILLER_0_12_82 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XFILLER_0_10_141 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
Xoutput111 net111 VGND VGND VPWR VPWR product[4] sky130_fd_sc_hd__clkbuf_4
Xinput46 mplier[21] VGND VGND VPWR VPWR net46 sky130_fd_sc_hd__buf_1
Xinput35 mplier[11] VGND VGND VPWR VPWR net35 sky130_fd_sc_hd__buf_1
XFILLER_0_33_26 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
Xinput13 mcand[20] VGND VGND VPWR VPWR net13 sky130_fd_sc_hd__buf_1
X_883_ net134 _439_ _086_ VGND VGND VPWR VPWR _441_ sky130_fd_sc_hd__o21ai_1
XFILLER_0_17_27 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XTAP_TAPCELL_ROW_16_136 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
Xinput57 mplier[31] VGND VGND VPWR VPWR net57 sky130_fd_sc_hd__clkbuf_1
Xinput24 mcand[30] VGND VGND VPWR VPWR net24 sky130_fd_sc_hd__buf_1
X_952_ clknet_3_0__leaf_clk _063_ VGND VGND VPWR VPWR net87 sky130_fd_sc_hd__dfxtp_1
XTAP_TAPCELL_ROW_30_183 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_2_193 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XTAP_TAPCELL_ROW_7_104 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_28_15 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
X_935_ clknet_3_1__leaf_clk _046_ VGND VGND VPWR VPWR net69 sky130_fd_sc_hd__dfxtp_1
X_866_ _429_ VGND VGND VPWR VPWR _064_ sky130_fd_sc_hd__clkbuf_1
XTAP_TAPCELL_ROW_36_209 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_18_81 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
X_797_ net147 _381_ _000_ VGND VGND VPWR VPWR _382_ sky130_fd_sc_hd__mux2_1
X_651_ _246_ _247_ _240_ VGND VGND VPWR VPWR _257_ sky130_fd_sc_hd__nand3b_1
X_582_ net106 net5 VGND VGND VPWR VPWR _195_ sky130_fd_sc_hd__and2_1
X_720_ net121 _210_ _216_ _318_ VGND VGND VPWR VPWR _029_ sky130_fd_sc_hd__o211a_1
XFILLER_0_14_39 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_30_49 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_30_27 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
Xhold2 _442_ VGND VGND VPWR VPWR net132 sky130_fd_sc_hd__dlygate4sd3_1
X_918_ clknet_3_3__leaf_clk _029_ VGND VGND VPWR VPWR net121 sky130_fd_sc_hd__dfxtp_1
X_849_ net49 _399_ _409_ net84 VGND VGND VPWR VPWR _418_ sky130_fd_sc_hd__a22o_1
XFILLER_0_35_169 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_35_136 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_496_ net96 net27 VGND VGND VPWR VPWR _118_ sky130_fd_sc_hd__and2_1
X_634_ _241_ _234_ _232_ VGND VGND VPWR VPWR _242_ sky130_fd_sc_hd__a21oi_1
X_565_ net105 net4 VGND VGND VPWR VPWR _179_ sky130_fd_sc_hd__and2_1
X_703_ net119 _083_ VGND VGND VPWR VPWR _304_ sky130_fd_sc_hd__or2_1
XFILLER_0_32_139 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_32_128 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XPHY_EDGE_ROW_17_Left_54 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_0_16_191 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XFILLER_0_36_37 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
X_617_ _223_ _226_ VGND VGND VPWR VPWR _227_ sky130_fd_sc_hd__nand2_1
X_548_ net103 _164_ _090_ VGND VGND VPWR VPWR _165_ sky130_fd_sc_hd__mux2_1
XFILLER_0_22_161 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
X_479_ net92 net1 _096_ _102_ VGND VGND VPWR VPWR _103_ sky130_fd_sc_hd__a31oi_2
XPHY_EDGE_ROW_2_Left_39 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XTAP_TAPCELL_ROW_28_178 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_19_145 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_2_27 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
Xoutput112 net112 VGND VGND VPWR VPWR product[50] sky130_fd_sc_hd__clkbuf_4
Xoutput101 net101 VGND VGND VPWR VPWR product[40] sky130_fd_sc_hd__clkbuf_4
XFILLER_0_12_72 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XFILLER_0_10_197 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
Xoutput123 net123 VGND VGND VPWR VPWR product[60] sky130_fd_sc_hd__clkbuf_4
XFILLER_0_33_38 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
Xinput25 mcand[31] VGND VGND VPWR VPWR net25 sky130_fd_sc_hd__buf_1
Xinput36 mplier[12] VGND VGND VPWR VPWR net36 sky130_fd_sc_hd__clkbuf_1
X_882_ net133 _437_ _440_ VGND VGND VPWR VPWR _069_ sky130_fd_sc_hd__o21a_1
Xinput14 mcand[21] VGND VGND VPWR VPWR net14 sky130_fd_sc_hd__buf_1
X_951_ clknet_3_0__leaf_clk _062_ VGND VGND VPWR VPWR net86 sky130_fd_sc_hd__dfxtp_1
XTAP_TAPCELL_ROW_30_184 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_23_93 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
Xinput47 mplier[22] VGND VGND VPWR VPWR net47 sky130_fd_sc_hd__clkbuf_1
Xinput58 mplier[3] VGND VGND VPWR VPWR net58 sky130_fd_sc_hd__clkbuf_1
XFILLER_0_21_204 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XTAP_TAPCELL_ROW_21_151 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_2_150 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XPHY_EDGE_ROW_5_Left_42 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
X_796_ net63 _376_ _363_ net130 VGND VGND VPWR VPWR _381_ sky130_fd_sc_hd__a22o_1
X_934_ clknet_3_1__leaf_clk _045_ VGND VGND VPWR VPWR net68 sky130_fd_sc_hd__dfxtp_1
X_865_ net88 _428_ _075_ VGND VGND VPWR VPWR _429_ sky130_fd_sc_hd__mux2_1
XFILLER_0_33_6 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XPHY_EDGE_ROW_31_Left_68 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
X_650_ _255_ VGND VGND VPWR VPWR _256_ sky130_fd_sc_hd__inv_2
XFILLER_0_18_71 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
X_581_ net105 _094_ _101_ _194_ VGND VGND VPWR VPWR _014_ sky130_fd_sc_hd__o211a_1
Xhold3 contador_act\[2\] VGND VGND VPWR VPWR net133 sky130_fd_sc_hd__dlygate4sd3_1
X_848_ _417_ VGND VGND VPWR VPWR _058_ sky130_fd_sc_hd__clkbuf_1
X_779_ _369_ VGND VGND VPWR VPWR _037_ sky130_fd_sc_hd__clkbuf_1
X_917_ clknet_3_3__leaf_clk _028_ VGND VGND VPWR VPWR net120 sky130_fd_sc_hd__dfxtp_1
XFILLER_0_29_178 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_0_29_167 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_29_145 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_35_159 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_633_ net110 net9 VGND VGND VPWR VPWR _241_ sky130_fd_sc_hd__nand2_1
XFILLER_0_26_126 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
X_495_ net95 _094_ _101_ _117_ VGND VGND VPWR VPWR _005_ sky130_fd_sc_hd__o211a_1
X_564_ net148 _094_ _101_ _178_ VGND VGND VPWR VPWR _013_ sky130_fd_sc_hd__o211a_1
X_702_ net120 _090_ _300_ _302_ VGND VGND VPWR VPWR _303_ sky130_fd_sc_hd__o22a_1
XFILLER_0_36_27 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XPHY_EDGE_ROW_34_Left_71 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
X_547_ _162_ _163_ VGND VGND VPWR VPWR _164_ sky130_fd_sc_hd__xnor2_1
X_616_ _224_ _225_ VGND VGND VPWR VPWR _226_ sky130_fd_sc_hd__or2_1
XFILLER_0_22_184 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_22_173 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
X_478_ net93 net12 VGND VGND VPWR VPWR _102_ sky130_fd_sc_hd__and2_1
XFILLER_0_13_173 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
Xoutput113 net113 VGND VGND VPWR VPWR product[51] sky130_fd_sc_hd__clkbuf_4
XTAP_TAPCELL_ROW_19_146 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
Xoutput102 net102 VGND VGND VPWR VPWR product[41] sky130_fd_sc_hd__clkbuf_4
XFILLER_0_10_165 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
Xoutput124 net124 VGND VGND VPWR VPWR product[61] sky130_fd_sc_hd__clkbuf_4
XTAP_TAPCELL_ROW_33_193 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
X_881_ _361_ _439_ VGND VGND VPWR VPWR _440_ sky130_fd_sc_hd__nor2_1
X_950_ clknet_3_0__leaf_clk _061_ VGND VGND VPWR VPWR net85 sky130_fd_sc_hd__dfxtp_1
Xinput59 mplier[4] VGND VGND VPWR VPWR net59 sky130_fd_sc_hd__clkbuf_1
Xinput37 mplier[13] VGND VGND VPWR VPWR net37 sky130_fd_sc_hd__buf_1
Xinput48 mplier[23] VGND VGND VPWR VPWR net48 sky130_fd_sc_hd__buf_1
Xinput15 mcand[22] VGND VGND VPWR VPWR net15 sky130_fd_sc_hd__buf_1
Xinput26 mcand[3] VGND VGND VPWR VPWR net26 sky130_fd_sc_hd__buf_1
XFILLER_0_3_107 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XTAP_TAPCELL_ROW_30_185 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_21_152 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
Xclkbuf_3_4__f_clk clknet_0_clk VGND VGND VPWR VPWR clknet_3_4__leaf_clk sky130_fd_sc_hd__clkbuf_16
X_933_ clknet_3_4__leaf_clk _044_ VGND VGND VPWR VPWR net130 sky130_fd_sc_hd__dfxtp_1
X_864_ net54 _360_ _409_ net90 VGND VGND VPWR VPWR _428_ sky130_fd_sc_hd__a22o_1
XFILLER_0_8_38 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
X_795_ _380_ VGND VGND VPWR VPWR _042_ sky130_fd_sc_hd__clkbuf_1
XTAP_TAPCELL_ROW_35_200 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_34_71 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_34_60 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_0_30_29 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
X_580_ net106 _095_ _191_ _193_ _158_ VGND VGND VPWR VPWR _194_ sky130_fd_sc_hd__a221o_1
Xhold4 contador_act\[3\] VGND VGND VPWR VPWR net134 sky130_fd_sc_hd__dlygate4sd3_1
X_916_ clknet_3_1__leaf_clk _027_ VGND VGND VPWR VPWR net119 sky130_fd_sc_hd__dfxtp_2
XFILLER_0_29_157 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XFILLER_0_20_73 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
X_847_ net82 _416_ _407_ VGND VGND VPWR VPWR _417_ sky130_fd_sc_hd__mux2_1
X_778_ net151 _368_ _000_ VGND VGND VPWR VPWR _369_ sky130_fd_sc_hd__mux2_1
X_632_ _238_ _239_ VGND VGND VPWR VPWR _240_ sky130_fd_sc_hd__and2_1
XPHY_EDGE_ROW_26_Right_26 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
X_563_ net105 _082_ _099_ _177_ VGND VGND VPWR VPWR _178_ sky130_fd_sc_hd__a211o_1
XPHY_EDGE_ROW_17_Right_17 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
X_701_ _090_ _301_ VGND VGND VPWR VPWR _302_ sky130_fd_sc_hd__nand2_1
XPHY_EDGE_ROW_35_Right_35 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
X_494_ net96 _082_ _078_ _116_ VGND VGND VPWR VPWR _117_ sky130_fd_sc_hd__a211o_1
XFILLER_0_5_39 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_17_149 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
X_546_ net101 net31 _156_ VGND VGND VPWR VPWR _163_ sky130_fd_sc_hd__a21boi_1
XFILLER_0_31_174 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
X_615_ net109 net8 VGND VGND VPWR VPWR _225_ sky130_fd_sc_hd__nor2_1
X_477_ _086_ VGND VGND VPWR VPWR _101_ sky130_fd_sc_hd__clkbuf_4
XFILLER_0_16_171 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_26_83 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_26_72 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_9_113 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XFILLER_0_36_211 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XFILLER_0_6_71 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_6_82 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
Xoutput125 net125 VGND VGND VPWR VPWR product[62] sky130_fd_sc_hd__clkbuf_4
XFILLER_0_27_211 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
X_529_ net99 _094_ _101_ _147_ VGND VGND VPWR VPWR _009_ sky130_fd_sc_hd__o211a_1
XFILLER_0_12_85 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_0_10_100 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
Xoutput103 net103 VGND VGND VPWR VPWR product[42] sky130_fd_sc_hd__clkbuf_4
Xoutput114 net114 VGND VGND VPWR VPWR product[52] sky130_fd_sc_hd__clkbuf_4
XFILLER_0_2_29 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_6_138 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XTAP_TAPCELL_ROW_33_194 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
X_880_ contador_act\[2\] contador_act\[1\] _435_ VGND VGND VPWR VPWR _439_ sky130_fd_sc_hd__and3_1
Xinput38 mplier[14] VGND VGND VPWR VPWR net38 sky130_fd_sc_hd__dlymetal6s2s_1
XFILLER_0_33_18 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
Xinput27 mcand[4] VGND VGND VPWR VPWR net27 sky130_fd_sc_hd__buf_1
Xinput49 mplier[24] VGND VGND VPWR VPWR net49 sky130_fd_sc_hd__buf_1
XFILLER_0_24_214 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XTAP_TAPCELL_ROW_24_161 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
Xinput16 mcand[23] VGND VGND VPWR VPWR net16 sky130_fd_sc_hd__clkbuf_2
XFILLER_0_30_206 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_0_28_29 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XTAP_TAPCELL_ROW_21_153 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_12_120 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
X_863_ _427_ VGND VGND VPWR VPWR _063_ sky130_fd_sc_hd__clkbuf_1
X_932_ clknet_3_1__leaf_clk _043_ VGND VGND VPWR VPWR net129 sky130_fd_sc_hd__dfxtp_1
X_794_ net128 _379_ _000_ VGND VGND VPWR VPWR _380_ sky130_fd_sc_hd__mux2_1
XTAP_TAPCELL_ROW_35_201 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_8_17 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
Xhold5 contador_act\[5\] VGND VGND VPWR VPWR net135 sky130_fd_sc_hd__dlygate4sd3_1
X_915_ clknet_3_1__leaf_clk _026_ VGND VGND VPWR VPWR net118 sky130_fd_sc_hd__dfxtp_1
X_846_ net48 _399_ _409_ net83 VGND VGND VPWR VPWR _416_ sky130_fd_sc_hd__a22o_1
X_777_ net55 _361_ _363_ net100 VGND VGND VPWR VPWR _368_ sky130_fd_sc_hd__a22o_1
X_700_ _292_ _295_ _298_ _299_ VGND VGND VPWR VPWR _301_ sky130_fd_sc_hd__a22o_1
X_631_ net112 net10 VGND VGND VPWR VPWR _239_ sky130_fd_sc_hd__or2_1
XFILLER_0_34_194 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
X_562_ _115_ _176_ VGND VGND VPWR VPWR _177_ sky130_fd_sc_hd__nor2_1
X_493_ _113_ _114_ _115_ VGND VGND VPWR VPWR _116_ sky130_fd_sc_hd__a21oi_1
X_829_ net42 _399_ _386_ net77 VGND VGND VPWR VPWR _404_ sky130_fd_sc_hd__a22o_1
XFILLER_0_31_40 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_0_25_183 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_15_41 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_36_29 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XFILLER_0_31_131 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
X_545_ _160_ _161_ VGND VGND VPWR VPWR _162_ sky130_fd_sc_hd__nor2_1
X_614_ net109 net8 VGND VGND VPWR VPWR _224_ sky130_fd_sc_hd__and2_1
X_476_ net93 _094_ _087_ _100_ VGND VGND VPWR VPWR _003_ sky130_fd_sc_hd__o211a_1
XFILLER_0_16_183 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_22_197 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_9_169 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
Xoutput115 net115 VGND VGND VPWR VPWR product[53] sky130_fd_sc_hd__clkbuf_4
Xoutput126 net126 VGND VGND VPWR VPWR product[63] sky130_fd_sc_hd__clkbuf_4
X_528_ net101 _082_ _078_ _146_ VGND VGND VPWR VPWR _147_ sky130_fd_sc_hd__a211o_1
X_459_ net1 _082_ _084_ VGND VGND VPWR VPWR _085_ sky130_fd_sc_hd__o21a_1
Xoutput104 net104 VGND VGND VPWR VPWR product[43] sky130_fd_sc_hd__clkbuf_4
XTAP_TAPCELL_ROW_33_195 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
Xinput17 mcand[24] VGND VGND VPWR VPWR net17 sky130_fd_sc_hd__buf_1
Xinput28 mcand[5] VGND VGND VPWR VPWR net28 sky130_fd_sc_hd__buf_1
XTAP_TAPCELL_ROW_24_162 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
Xinput39 mplier[15] VGND VGND VPWR VPWR net39 sky130_fd_sc_hd__clkbuf_1
XFILLER_0_23_63 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_2_197 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_0_3_73 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
X_793_ net62 _376_ _363_ net129 VGND VGND VPWR VPWR _379_ sky130_fd_sc_hd__a22o_1
X_862_ net160 _426_ _407_ VGND VGND VPWR VPWR _427_ sky130_fd_sc_hd__mux2_1
X_931_ clknet_3_1__leaf_clk _042_ VGND VGND VPWR VPWR net128 sky130_fd_sc_hd__dfxtp_1
XTAP_TAPCELL_ROW_35_202 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_19_7 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_18_85 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_18_63 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XTAP_TAPCELL_ROW_12_121 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XPHY_EDGE_ROW_9_Left_46 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_0_20_42 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
X_914_ clknet_3_4__leaf_clk _025_ VGND VGND VPWR VPWR net117 sky130_fd_sc_hd__dfxtp_2
Xhold6 contador_act\[1\] VGND VGND VPWR VPWR net136 sky130_fd_sc_hd__dlygate4sd3_1
X_776_ _367_ VGND VGND VPWR VPWR _036_ sky130_fd_sc_hd__clkbuf_1
X_845_ _415_ VGND VGND VPWR VPWR _057_ sky130_fd_sc_hd__clkbuf_1
XFILLER_0_0_85 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_0_63 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XPHY_EDGE_ROW_3_Right_3 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
X_630_ net112 net10 VGND VGND VPWR VPWR _238_ sky130_fd_sc_hd__nand2_1
XFILLER_0_34_162 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
X_561_ _173_ _175_ VGND VGND VPWR VPWR _176_ sky130_fd_sc_hd__xnor2_1
X_492_ _081_ VGND VGND VPWR VPWR _115_ sky130_fd_sc_hd__clkbuf_4
XFILLER_0_19_181 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_25_195 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_759_ _351_ _352_ _081_ VGND VGND VPWR VPWR _354_ sky130_fd_sc_hd__a21o_1
XFILLER_0_17_129 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_15_53 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
X_828_ _403_ VGND VGND VPWR VPWR _052_ sky130_fd_sc_hd__clkbuf_1
XFILLER_0_31_165 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_0_31_143 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
X_613_ _154_ _185_ _218_ _222_ VGND VGND VPWR VPWR _223_ sky130_fd_sc_hd__o31a_2
X_544_ net102 net32 VGND VGND VPWR VPWR _161_ sky130_fd_sc_hd__nor2_1
XFILLER_0_26_85 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XFILLER_0_22_121 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_475_ net94 _095_ _097_ _098_ _099_ VGND VGND VPWR VPWR _100_ sky130_fd_sc_hd__a221o_1
XFILLER_0_13_110 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
X_527_ _115_ _145_ VGND VGND VPWR VPWR _146_ sky130_fd_sc_hd__nor2_1
XPHY_EDGE_ROW_22_Left_59 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
X_458_ _083_ VGND VGND VPWR VPWR _084_ sky130_fd_sc_hd__clkbuf_4
XFILLER_0_6_118 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
Xoutput127 net127 VGND VGND VPWR VPWR product[6] sky130_fd_sc_hd__clkbuf_4
XFILLER_0_33_205 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
Xoutput105 net105 VGND VGND VPWR VPWR product[44] sky130_fd_sc_hd__clkbuf_4
Xoutput116 net116 VGND VGND VPWR VPWR product[54] sky130_fd_sc_hd__clkbuf_4
XTAP_TAPCELL_ROW_24_163 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
Xinput29 mcand[6] VGND VGND VPWR VPWR net29 sky130_fd_sc_hd__clkbuf_2
Xinput18 mcand[25] VGND VGND VPWR VPWR net18 sky130_fd_sc_hd__dlymetal6s2s_1
XFILLER_0_23_75 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_23_53 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XTAP_TAPCELL_ROW_15_130 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
X_792_ _378_ VGND VGND VPWR VPWR _041_ sky130_fd_sc_hd__clkbuf_1
X_930_ clknet_3_4__leaf_clk _041_ VGND VGND VPWR VPWR net127 sky130_fd_sc_hd__dfxtp_1
XFILLER_0_3_85 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
X_861_ net53 _360_ _409_ net88 VGND VGND VPWR VPWR _426_ sky130_fd_sc_hd__a22o_1
XPHY_EDGE_ROW_25_Left_62 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_0_18_97 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XTAP_TAPCELL_ROW_12_122 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_12_208 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
X_913_ clknet_3_3__leaf_clk _024_ VGND VGND VPWR VPWR net116 sky130_fd_sc_hd__dfxtp_1
Xhold7 contador_act\[0\] VGND VGND VPWR VPWR net137 sky130_fd_sc_hd__dlygate4sd3_1
X_844_ net81 _414_ _407_ VGND VGND VPWR VPWR _415_ sky130_fd_sc_hd__mux2_1
X_775_ net156 _366_ _000_ VGND VGND VPWR VPWR _367_ sky130_fd_sc_hd__mux2_1
XFILLER_0_29_52 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_28_171 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_24_6 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_0_42 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_0_4_205 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_0_34_174 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_34_141 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
X_560_ _167_ _169_ _174_ VGND VGND VPWR VPWR _175_ sky130_fd_sc_hd__a21oi_1
X_491_ _104_ _107_ _111_ _112_ VGND VGND VPWR VPWR _114_ sky130_fd_sc_hd__a22o_1
XPHY_EDGE_ROW_22_Right_22 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
X_689_ _262_ _287_ _290_ VGND VGND VPWR VPWR _291_ sky130_fd_sc_hd__a21oi_1
X_758_ _351_ _352_ VGND VGND VPWR VPWR _353_ sky130_fd_sc_hd__nor2_1
XFILLER_0_15_87 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XFILLER_0_15_21 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XPHY_EDGE_ROW_13_Right_13 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
X_827_ net144 _402_ _384_ VGND VGND VPWR VPWR _403_ sky130_fd_sc_hd__mux2_1
XPHY_EDGE_ROW_31_Right_31 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_0_31_111 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
X_543_ net102 net32 VGND VGND VPWR VPWR _160_ sky130_fd_sc_hd__and2_1
X_612_ _189_ _218_ _219_ _217_ _221_ VGND VGND VPWR VPWR _222_ sky130_fd_sc_hd__o221a_1
XFILLER_0_26_20 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
X_474_ _077_ VGND VGND VPWR VPWR _099_ sky130_fd_sc_hd__clkbuf_4
XFILLER_0_13_155 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
X_526_ _142_ _144_ VGND VGND VPWR VPWR _145_ sky130_fd_sc_hd__xnor2_1
XTAP_TAPCELL_ROW_27_172 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_8_182 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
Xoutput117 net117 VGND VGND VPWR VPWR product[55] sky130_fd_sc_hd__clkbuf_4
Xoutput106 net106 VGND VGND VPWR VPWR product[45] sky130_fd_sc_hd__clkbuf_4
X_457_ net66 _076_ VGND VGND VPWR VPWR _083_ sky130_fd_sc_hd__nor2_2
XFILLER_0_12_55 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_0_10_136 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
Xoutput128 net128 VGND VGND VPWR VPWR product[7] sky130_fd_sc_hd__clkbuf_4
XTAP_TAPCELL_ROW_24_164 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
Xinput19 mcand[26] VGND VGND VPWR VPWR net19 sky130_fd_sc_hd__buf_1
X_509_ _128_ _129_ VGND VGND VPWR VPWR _130_ sky130_fd_sc_hd__and2b_1
XFILLER_0_23_21 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_0_15_206 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XTAP_TAPCELL_ROW_15_131 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_3_97 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
X_791_ net127 _377_ _000_ VGND VGND VPWR VPWR _378_ sky130_fd_sc_hd__mux2_1
XFILLER_0_18_21 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
X_860_ _425_ VGND VGND VPWR VPWR _062_ sky130_fd_sc_hd__clkbuf_1
XFILLER_0_7_214 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
Xhold8 net96 VGND VGND VPWR VPWR net138 sky130_fd_sc_hd__dlygate4sd3_1
X_912_ clknet_3_6__leaf_clk _023_ VGND VGND VPWR VPWR net115 sky130_fd_sc_hd__dfxtp_1
X_843_ net47 _399_ _409_ net82 VGND VGND VPWR VPWR _414_ sky130_fd_sc_hd__a22o_1
X_774_ net44 _361_ _363_ net89 VGND VGND VPWR VPWR _366_ sky130_fd_sc_hd__a22o_1
XFILLER_0_29_86 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_0_17_6 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_0_4_217 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XFILLER_0_28_183 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_0_28_161 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
X_490_ _104_ _107_ _111_ _112_ VGND VGND VPWR VPWR _113_ sky130_fd_sc_hd__nand4_1
XFILLER_0_8_9 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_34_197 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_34_186 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_25_175 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
X_688_ net117 net16 _288_ _289_ VGND VGND VPWR VPWR _290_ sky130_fd_sc_hd__a211o_1
X_757_ _341_ _344_ _339_ VGND VGND VPWR VPWR _352_ sky130_fd_sc_hd__a21o_1
XFILLER_0_15_33 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
X_826_ net41 _399_ _386_ net76 VGND VGND VPWR VPWR _402_ sky130_fd_sc_hd__a22o_1
X_611_ net108 net7 _220_ VGND VGND VPWR VPWR _221_ sky130_fd_sc_hd__a21oi_1
X_542_ net149 _094_ _101_ _159_ VGND VGND VPWR VPWR _010_ sky130_fd_sc_hd__o211a_1
XFILLER_0_22_189 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
X_473_ net92 net1 _096_ _081_ VGND VGND VPWR VPWR _098_ sky130_fd_sc_hd__a31oi_1
XFILLER_0_13_167 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
X_809_ _390_ VGND VGND VPWR VPWR _046_ sky130_fd_sc_hd__clkbuf_1
XFILLER_0_6_20 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_0_8_194 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
Xoutput107 net107 VGND VGND VPWR VPWR product[46] sky130_fd_sc_hd__clkbuf_4
X_525_ _135_ _136_ _143_ VGND VGND VPWR VPWR _144_ sky130_fd_sc_hd__a21oi_1
XTAP_TAPCELL_ROW_27_173 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_18_140 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
X_456_ _078_ _080_ _082_ VGND VGND VPWR VPWR _001_ sky130_fd_sc_hd__o21ai_1
Xoutput118 net118 VGND VGND VPWR VPWR product[56] sky130_fd_sc_hd__clkbuf_4
Xoutput129 net129 VGND VGND VPWR VPWR product[8] sky130_fd_sc_hd__clkbuf_4
XFILLER_0_5_120 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
X_508_ net97 net28 VGND VGND VPWR VPWR _129_ sky130_fd_sc_hd__or2_1
XFILLER_0_24_218 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XTAP_TAPCELL_ROW_15_132 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
X_790_ net61 _376_ _363_ net128 VGND VGND VPWR VPWR _377_ sky130_fd_sc_hd__a22o_1
XFILLER_0_20_210 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XTAP_TAPCELL_ROW_6_100 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_34_76 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
Xhold9 net112 VGND VGND VPWR VPWR net139 sky130_fd_sc_hd__dlygate4sd3_1
X_911_ clknet_3_6__leaf_clk _022_ VGND VGND VPWR VPWR net114 sky130_fd_sc_hd__dfxtp_1
X_842_ _413_ VGND VGND VPWR VPWR _056_ sky130_fd_sc_hd__clkbuf_1
XFILLER_0_20_89 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_20_78 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
X_773_ _365_ VGND VGND VPWR VPWR _035_ sky130_fd_sc_hd__clkbuf_1
XFILLER_0_28_195 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_0_77 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_9_97 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_0_19_162 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
X_687_ _269_ _266_ _277_ _276_ _282_ VGND VGND VPWR VPWR _289_ sky130_fd_sc_hd__o2111a_1
X_756_ _349_ _350_ VGND VGND VPWR VPWR _351_ sky130_fd_sc_hd__nand2_1
X_825_ _401_ VGND VGND VPWR VPWR _051_ sky130_fd_sc_hd__clkbuf_1
XFILLER_0_31_55 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XPHY_EDGE_ROW_7_Right_7 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
X_610_ net108 net7 _202_ VGND VGND VPWR VPWR _220_ sky130_fd_sc_hd__o21a_1
X_541_ net102 _095_ _156_ _157_ _158_ VGND VGND VPWR VPWR _159_ sky130_fd_sc_hd__a221o_1
XFILLER_0_31_113 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_0_22_113 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
X_472_ net92 net1 _096_ VGND VGND VPWR VPWR _097_ sky130_fd_sc_hd__a21o_1
X_739_ _334_ _335_ VGND VGND VPWR VPWR _336_ sky130_fd_sc_hd__xnor2_1
XFILLER_0_13_135 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_13_113 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
X_808_ net141 _389_ _384_ VGND VGND VPWR VPWR _390_ sky130_fd_sc_hd__mux2_1
Xoutput108 net108 VGND VGND VPWR VPWR product[47] sky130_fd_sc_hd__clkbuf_4
X_524_ net98 net29 VGND VGND VPWR VPWR _143_ sky130_fd_sc_hd__and2_1
XTAP_TAPCELL_ROW_27_174 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
X_455_ _081_ VGND VGND VPWR VPWR _082_ sky130_fd_sc_hd__clkbuf_4
XFILLER_0_12_46 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
Xoutput90 net90 VGND VGND VPWR VPWR product[30] sky130_fd_sc_hd__clkbuf_4
Xoutput119 net119 VGND VGND VPWR VPWR product[57] sky130_fd_sc_hd__clkbuf_4
XTAP_TAPCELL_ROW_18_141 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
X_507_ net97 net28 VGND VGND VPWR VPWR _128_ sky130_fd_sc_hd__and2_1
XTAP_TAPCELL_ROW_6_101 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_34_88 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
X_910_ clknet_3_5__leaf_clk _021_ VGND VGND VPWR VPWR net113 sky130_fd_sc_hd__dfxtp_1
XFILLER_0_29_108 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_29_22 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XPHY_EDGE_ROW_29_Left_66 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_0_20_46 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
X_841_ net80 _412_ _407_ VGND VGND VPWR VPWR _413_ sky130_fd_sc_hd__mux2_1
X_772_ net67 _364_ _000_ VGND VGND VPWR VPWR _365_ sky130_fd_sc_hd__mux2_1
XFILLER_0_28_141 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_34_111 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XFILLER_0_19_196 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
X_755_ net126 net25 VGND VGND VPWR VPWR _350_ sky130_fd_sc_hd__nand2_1
X_824_ net74 _400_ _384_ VGND VGND VPWR VPWR _401_ sky130_fd_sc_hd__mux2_1
XFILLER_0_31_12 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
Xclkbuf_3_5__f_clk clknet_0_clk VGND VGND VPWR VPWR clknet_3_5__leaf_clk sky130_fd_sc_hd__clkbuf_16
XFILLER_0_25_100 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_0_22_6 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
X_686_ net117 net16 _274_ VGND VGND VPWR VPWR _288_ sky130_fd_sc_hd__o21a_1
XFILLER_0_15_57 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_0_31_103 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_471_ net93 net12 VGND VGND VPWR VPWR _096_ sky130_fd_sc_hd__xor2_2
X_540_ _077_ VGND VGND VPWR VPWR _158_ sky130_fd_sc_hd__clkbuf_4
X_669_ _078_ _272_ _273_ _087_ VGND VGND VPWR VPWR _023_ sky130_fd_sc_hd__o211a_1
XFILLER_0_22_136 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
X_738_ _325_ _328_ _326_ VGND VGND VPWR VPWR _335_ sky130_fd_sc_hd__a21oi_1
X_807_ net35 _376_ _386_ net70 VGND VGND VPWR VPWR _389_ sky130_fd_sc_hd__a22o_1
XFILLER_0_20_3 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XPHY_EDGE_ROW_16_Left_53 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_0_13_147 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_13_125 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XFILLER_0_8_141 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
Xoutput109 net109 VGND VGND VPWR VPWR product[48] sky130_fd_sc_hd__clkbuf_4
X_523_ _140_ _141_ VGND VGND VPWR VPWR _142_ sky130_fd_sc_hd__nand2_1
X_454_ estado_act\[1\] estado_act\[0\] net67 VGND VGND VPWR VPWR _081_ sky130_fd_sc_hd__nand3b_4
XFILLER_0_12_36 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XTAP_TAPCELL_ROW_2_84 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
Xoutput91 net91 VGND VGND VPWR VPWR product[31] sky130_fd_sc_hd__buf_2
XTAP_TAPCELL_ROW_18_142 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
Xoutput80 net80 VGND VGND VPWR VPWR product[21] sky130_fd_sc_hd__clkbuf_4
XPHY_EDGE_ROW_1_Left_38 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XTAP_TAPCELL_ROW_9_110 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
X_506_ _084_ _126_ _127_ VGND VGND VPWR VPWR _006_ sky130_fd_sc_hd__a21oi_1
XFILLER_0_2_136 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_0_3_12 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XPHY_EDGE_ROW_29_Right_29 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_0_20_36 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
X_840_ net46 _399_ _409_ net81 VGND VGND VPWR VPWR _412_ sky130_fd_sc_hd__a22o_1
XPHY_EDGE_ROW_4_Left_41 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
X_771_ net33 _361_ _363_ net78 VGND VGND VPWR VPWR _364_ sky130_fd_sc_hd__a22o_1
XFILLER_0_29_34 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_29_12 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XFILLER_0_28_153 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_0_35 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_9_77 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_34_145 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XPHY_EDGE_ROW_30_Left_67 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
X_823_ net40 _399_ _386_ net75 VGND VGND VPWR VPWR _400_ sky130_fd_sc_hd__a22o_1
XFILLER_0_31_79 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_31_57 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_25_167 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
X_685_ _255_ _268_ _276_ _282_ VGND VGND VPWR VPWR _287_ sky130_fd_sc_hd__and4bb_1
X_754_ net126 net25 VGND VGND VPWR VPWR _349_ sky130_fd_sc_hd__or2_1
XFILLER_0_15_69 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XTAP_TAPCELL_ROW_5_95 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_16_167 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_26_79 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
X_668_ net115 _083_ VGND VGND VPWR VPWR _273_ sky130_fd_sc_hd__or2_1
X_470_ _081_ VGND VGND VPWR VPWR _095_ sky130_fd_sc_hd__clkbuf_4
X_599_ _084_ VGND VGND VPWR VPWR _210_ sky130_fd_sc_hd__clkbuf_4
X_737_ _332_ _333_ VGND VGND VPWR VPWR _334_ sky130_fd_sc_hd__nand2_1
X_806_ _388_ VGND VGND VPWR VPWR _045_ sky130_fd_sc_hd__clkbuf_1
XFILLER_0_13_3 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_0_6_12 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_6_45 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XFILLER_0_6_67 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
X_522_ net99 net30 VGND VGND VPWR VPWR _141_ sky130_fd_sc_hd__or2_1
X_453_ net131 _079_ net135 VGND VGND VPWR VPWR _080_ sky130_fd_sc_hd__a21oi_1
XFILLER_0_12_26 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XFILLER_0_8_197 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
Xoutput81 net81 VGND VGND VPWR VPWR product[22] sky130_fd_sc_hd__clkbuf_4
XPHY_EDGE_ROW_33_Left_70 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
Xoutput70 net70 VGND VGND VPWR VPWR product[12] sky130_fd_sc_hd__clkbuf_4
XTAP_TAPCELL_ROW_18_143 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
Xoutput92 net92 VGND VGND VPWR VPWR product[32] sky130_fd_sc_hd__buf_2
XTAP_TAPCELL_ROW_2_85 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_5_167 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XTAP_TAPCELL_ROW_32_190 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_9_111 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_2_3 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
X_505_ net138 _084_ _086_ VGND VGND VPWR VPWR _127_ sky130_fd_sc_hd__o21ai_1
XFILLER_0_13_80 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_3_24 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
X_770_ _362_ VGND VGND VPWR VPWR _363_ sky130_fd_sc_hd__clkbuf_4
X_899_ clknet_3_5__leaf_clk _010_ VGND VGND VPWR VPWR net101 sky130_fd_sc_hd__dfxtp_2
XFILLER_0_29_46 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_0_28_187 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_20_15 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_9_89 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_31_69 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
X_753_ net126 _099_ VGND VGND VPWR VPWR _348_ sky130_fd_sc_hd__and2_1
X_684_ net150 _210_ _216_ _286_ VGND VGND VPWR VPWR _025_ sky130_fd_sc_hd__o211a_1
XFILLER_0_15_37 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XTAP_TAPCELL_ROW_5_96 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
X_822_ _360_ VGND VGND VPWR VPWR _399_ sky130_fd_sc_hd__clkbuf_4
XFILLER_0_16_157 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_0_22_105 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_736_ net124 net22 VGND VGND VPWR VPWR _333_ sky130_fd_sc_hd__or2_1
X_805_ net161 _387_ _384_ VGND VGND VPWR VPWR _388_ sky130_fd_sc_hd__mux2_1
X_598_ net140 _094_ _101_ _209_ VGND VGND VPWR VPWR _016_ sky130_fd_sc_hd__o211a_1
X_667_ net116 _271_ _090_ VGND VGND VPWR VPWR _272_ sky130_fd_sc_hd__mux2_1
XFILLER_0_6_24 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
X_521_ net99 net30 VGND VGND VPWR VPWR _140_ sky130_fd_sc_hd__nand2_1
X_452_ contador_act\[3\] contador_act\[2\] contador_act\[1\] contador_act\[0\] VGND
+ VGND VPWR VPWR _079_ sky130_fd_sc_hd__and4_1
X_719_ net123 _082_ _099_ _317_ VGND VGND VPWR VPWR _318_ sky130_fd_sc_hd__a211o_1
Xoutput71 net71 VGND VGND VPWR VPWR product[13] sky130_fd_sc_hd__buf_2
Xoutput93 net93 VGND VGND VPWR VPWR product[33] sky130_fd_sc_hd__clkbuf_4
Xoutput82 net82 VGND VGND VPWR VPWR product[23] sky130_fd_sc_hd__clkbuf_4
XTAP_TAPCELL_ROW_2_86 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_32_191 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
X_504_ net97 _115_ _124_ _125_ VGND VGND VPWR VPWR _126_ sky130_fd_sc_hd__o2bb2a_1
XFILLER_0_23_15 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_0_3_36 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_20_214 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XTAP_TAPCELL_ROW_20_150 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_24_80 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
X_898_ clknet_3_7__leaf_clk _009_ VGND VGND VPWR VPWR net99 sky130_fd_sc_hd__dfxtp_1
XFILLER_0_20_27 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_0_48 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_36_3 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_0_9_46 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_9_57 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_25_169 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_0_25_158 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_25_147 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
X_752_ net125 _084_ _086_ _347_ VGND VGND VPWR VPWR _032_ sky130_fd_sc_hd__o211a_1
X_683_ net118 _082_ _099_ _285_ VGND VGND VPWR VPWR _286_ sky130_fd_sc_hd__a211o_1
XTAP_TAPCELL_ROW_5_97 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
X_821_ _398_ VGND VGND VPWR VPWR _050_ sky130_fd_sc_hd__clkbuf_1
XFILLER_0_24_180 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_22_117 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
X_597_ net108 _095_ _207_ _208_ _158_ VGND VGND VPWR VPWR _209_ sky130_fd_sc_hd__a221o_1
XFILLER_0_26_37 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_26_26 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
X_735_ net124 net22 VGND VGND VPWR VPWR _332_ sky130_fd_sc_hd__nand2_1
X_666_ _268_ _270_ VGND VGND VPWR VPWR _271_ sky130_fd_sc_hd__xnor2_1
X_804_ net34 _376_ _386_ net69 VGND VGND VPWR VPWR _387_ sky130_fd_sc_hd__a22o_1
X_520_ net98 _094_ _101_ _139_ VGND VGND VPWR VPWR _008_ sky130_fd_sc_hd__o211a_1
Xoutput72 net72 VGND VGND VPWR VPWR product[14] sky130_fd_sc_hd__clkbuf_4
Xoutput94 net94 VGND VGND VPWR VPWR product[34] sky130_fd_sc_hd__clkbuf_4
X_649_ _253_ _254_ VGND VGND VPWR VPWR _255_ sky130_fd_sc_hd__nand2_1
X_451_ _077_ VGND VGND VPWR VPWR _078_ sky130_fd_sc_hd__clkbuf_4
X_718_ _315_ _316_ _115_ VGND VGND VPWR VPWR _317_ sky130_fd_sc_hd__a21oi_1
Xoutput83 net83 VGND VGND VPWR VPWR product[24] sky130_fd_sc_hd__buf_2
XTAP_TAPCELL_ROW_2_87 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_32_192 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
X_503_ _120_ _123_ _081_ VGND VGND VPWR VPWR _125_ sky130_fd_sc_hd__a21o_1
XFILLER_0_23_27 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_23_201 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XFILLER_0_3_48 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_34_26 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XPHY_EDGE_ROW_25_Right_25 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XPHY_EDGE_ROW_16_Right_16 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XPHY_EDGE_ROW_34_Right_34 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
X_897_ clknet_3_7__leaf_clk _008_ VGND VGND VPWR VPWR net98 sky130_fd_sc_hd__dfxtp_1
XFILLER_0_35_80 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_10_83 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_10_61 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_0_0_27 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_9_14 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_0_9_69 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_19_156 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
X_751_ net126 _115_ _345_ _346_ _077_ VGND VGND VPWR VPWR _347_ sky130_fd_sc_hd__a221o_1
X_682_ _108_ _284_ VGND VGND VPWR VPWR _285_ sky130_fd_sc_hd__nor2_1
Xclkbuf_3_0__f_clk clknet_0_clk VGND VGND VPWR VPWR clknet_3_0__leaf_clk sky130_fd_sc_hd__clkbuf_16
X_820_ net157 _397_ _384_ VGND VGND VPWR VPWR _398_ sky130_fd_sc_hd__mux2_1
XPHY_EDGE_ROW_8_Left_45 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_0_33_181 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_0_215 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
X_949_ clknet_3_0__leaf_clk _060_ VGND VGND VPWR VPWR net84 sky130_fd_sc_hd__dfxtp_1
XFILLER_0_15_181 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XPHY_EDGE_ROW_2_Right_2 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
X_596_ _204_ _206_ _089_ VGND VGND VPWR VPWR _208_ sky130_fd_sc_hd__o21a_1
XFILLER_0_30_195 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_30_151 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
X_665_ _256_ _262_ _269_ VGND VGND VPWR VPWR _270_ sky130_fd_sc_hd__a21o_1
X_734_ net123 _084_ _330_ _331_ _087_ VGND VGND VPWR VPWR _030_ sky130_fd_sc_hd__o221a_1
XFILLER_0_15_192 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
X_803_ _362_ VGND VGND VPWR VPWR _386_ sky130_fd_sc_hd__clkbuf_4
XFILLER_0_4_9 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
X_450_ net66 _076_ VGND VGND VPWR VPWR _077_ sky130_fd_sc_hd__or2_2
Xoutput73 net73 VGND VGND VPWR VPWR product[15] sky130_fd_sc_hd__clkbuf_4
Xoutput84 net84 VGND VGND VPWR VPWR product[25] sky130_fd_sc_hd__clkbuf_4
Xoutput95 net95 VGND VGND VPWR VPWR product[35] sky130_fd_sc_hd__buf_2
X_579_ _108_ _192_ VGND VGND VPWR VPWR _193_ sky130_fd_sc_hd__nor2_1
X_648_ net114 net13 VGND VGND VPWR VPWR _254_ sky130_fd_sc_hd__or2_1
X_717_ _306_ _309_ _313_ _314_ VGND VGND VPWR VPWR _316_ sky130_fd_sc_hd__a22o_1
X_502_ _120_ _123_ VGND VGND VPWR VPWR _124_ sky130_fd_sc_hd__nor2_1
XTAP_TAPCELL_ROW_23_160 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XPHY_EDGE_ROW_21_Left_58 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XTAP_TAPCELL_ROW_12_119 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_1_140 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
X_896_ clknet_3_7__leaf_clk _007_ VGND VGND VPWR VPWR net97 sky130_fd_sc_hd__dfxtp_1
XPHY_EDGE_ROW_24_Left_61 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_0_19_71 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_0_35_92 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
X_681_ _282_ _283_ VGND VGND VPWR VPWR _284_ sky130_fd_sc_hd__xnor2_1
X_750_ _341_ _344_ _089_ VGND VGND VPWR VPWR _346_ sky130_fd_sc_hd__o21a_1
XFILLER_0_33_193 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_31_28 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
X_879_ net136 _435_ _438_ VGND VGND VPWR VPWR _068_ sky130_fd_sc_hd__o21a_1
X_948_ clknet_3_0__leaf_clk _059_ VGND VGND VPWR VPWR net83 sky130_fd_sc_hd__dfxtp_1
XFILLER_0_31_119 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_21_94 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_21_50 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
X_595_ _204_ _206_ VGND VGND VPWR VPWR _207_ sky130_fd_sc_hd__nand2_1
XFILLER_0_30_141 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
X_733_ net124 _095_ _078_ VGND VGND VPWR VPWR _331_ sky130_fd_sc_hd__a21o_1
X_664_ _253_ VGND VGND VPWR VPWR _269_ sky130_fd_sc_hd__inv_2
X_802_ _385_ VGND VGND VPWR VPWR _044_ sky130_fd_sc_hd__clkbuf_1
XFILLER_0_32_82 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XFILLER_0_13_7 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_12_141 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
X_578_ _181_ _190_ VGND VGND VPWR VPWR _192_ sky130_fd_sc_hd__nor2_1
X_647_ net114 net13 VGND VGND VPWR VPWR _253_ sky130_fd_sc_hd__nand2_1
X_716_ _306_ _309_ _313_ _314_ VGND VGND VPWR VPWR _315_ sky130_fd_sc_hd__nand4_1
Xoutput85 net85 VGND VGND VPWR VPWR product[26] sky130_fd_sc_hd__clkbuf_4
Xoutput74 net74 VGND VGND VPWR VPWR product[16] sky130_fd_sc_hd__clkbuf_4
Xoutput96 net96 VGND VGND VPWR VPWR product[36] sky130_fd_sc_hd__clkbuf_4
.ends
